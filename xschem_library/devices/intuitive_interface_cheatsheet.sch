v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 1 917.5 -8072.5 922.5 -8072.5 {}
L 1 917.5 -8070 922.5 -8070 {}
L 1 917.5 -8067.5 922.5 -8067.5 {}
L 1 917.5 -8065 922.5 -8065 {}
L 1 917.5 -8062.5 922.5 -8062.5 {}
L 1 917.5 -8060 922.5 -8060 {}
L 1 917.5 -8057.5 922.5 -8057.5 {}
L 1 917.5 -8055 922.5 -8055 {}
L 1 917.5 -8052.5 922.5 -8052.5 {}
L 1 1347.5 -8072.5 1352.5 -8072.5 {}
L 1 1347.5 -8070 1352.5 -8070 {}
L 1 1347.5 -8067.5 1352.5 -8067.5 {}
L 1 1347.5 -8065 1352.5 -8065 {}
L 1 1347.5 -8062.5 1352.5 -8062.5 {}
L 1 1347.5 -8060 1352.5 -8060 {}
L 1 1347.5 -8057.5 1352.5 -8057.5 {}
L 1 1347.5 -8055 1352.5 -8055 {}
L 1 1347.5 -8052.5 1352.5 -8052.5 {}
L 1 2117.5 -8072.5 2122.5 -8072.5 {}
L 1 2117.5 -8070 2122.5 -8070 {}
L 1 2117.5 -8067.5 2122.5 -8067.5 {}
L 1 2117.5 -8065 2122.5 -8065 {}
L 1 2117.5 -8062.5 2122.5 -8062.5 {}
L 1 2117.5 -8060 2122.5 -8060 {}
L 1 2117.5 -8057.5 2122.5 -8057.5 {}
L 1 2117.5 -8055 2122.5 -8055 {}
L 1 2117.5 -8052.5 2122.5 -8052.5 {}
L 1 1417.5 -7882.5 1422.5 -7882.5 {}
L 1 1417.5 -7880 1422.5 -7880 {}
L 1 1417.5 -7877.5 1422.5 -7877.5 {}
L 1 1417.5 -7875 1422.5 -7875 {}
L 1 1417.5 -7872.5 1422.5 -7872.5 {}
L 1 1417.5 -7870 1422.5 -7870 {}
L 1 1417.5 -7867.5 1422.5 -7867.5 {}
L 1 1417.5 -7865 1422.5 -7865 {}
L 1 1417.5 -7862.5 1422.5 -7862.5 {}
L 1 1437.5 -7062.5 1442.5 -7062.5 {}
L 1 1437.5 -7060 1442.5 -7060 {}
L 1 1437.5 -7057.5 1442.5 -7057.5 {}
L 1 1437.5 -7055 1442.5 -7055 {}
L 1 1437.5 -7052.5 1442.5 -7052.5 {}
L 1 1437.5 -7050 1442.5 -7050 {}
L 1 1437.5 -7047.5 1442.5 -7047.5 {}
L 1 1437.5 -7045 1442.5 -7045 {}
L 1 1437.5 -7042.5 1442.5 -7042.5 {}
L 1 1437.5 -6572.5 1442.5 -6572.5 {}
L 1 1437.5 -6570 1442.5 -6570 {}
L 1 1437.5 -6567.5 1442.5 -6567.5 {}
L 1 1437.5 -6565 1442.5 -6565 {}
L 1 1437.5 -6562.5 1442.5 -6562.5 {}
L 1 1437.5 -6560 1442.5 -6560 {}
L 1 1437.5 -6557.5 1442.5 -6557.5 {}
L 1 1437.5 -6555 1442.5 -6555 {}
L 1 1437.5 -6552.5 1442.5 -6552.5 {}
L 1 947.5 -5842.5 952.5 -5842.5 {}
L 1 947.5 -5840 952.5 -5840 {}
L 1 947.5 -5837.5 952.5 -5837.5 {}
L 1 947.5 -5835 952.5 -5835 {}
L 1 947.5 -5832.5 952.5 -5832.5 {}
L 1 947.5 -5830 952.5 -5830 {}
L 1 947.5 -5827.5 952.5 -5827.5 {}
L 1 947.5 -5825 952.5 -5825 {}
L 1 947.5 -5822.5 952.5 -5822.5 {}
L 1 1040 -6100 1280 -6100 {}
L 1 1040 -5840 1280 -5840 {}
L 1 1427.5 -5852.5 1432.5 -5852.5 {}
L 1 1427.5 -5850 1432.5 -5850 {}
L 1 1427.5 -5847.5 1432.5 -5847.5 {}
L 1 1427.5 -5845 1432.5 -5845 {}
L 1 1427.5 -5842.5 1432.5 -5842.5 {}
L 1 1427.5 -5840 1432.5 -5840 {}
L 1 1427.5 -5837.5 1432.5 -5837.5 {}
L 1 1427.5 -5835 1432.5 -5835 {}
L 1 1427.5 -5832.5 1432.5 -5832.5 {}
L 1 917.5 -7242.5 922.5 -7242.5 {}
L 1 917.5 -7240 922.5 -7240 {}
L 1 917.5 -7237.5 922.5 -7237.5 {}
L 1 917.5 -7235 922.5 -7235 {}
L 1 917.5 -7232.5 922.5 -7232.5 {}
L 1 917.5 -7230 922.5 -7230 {}
L 1 917.5 -7227.5 922.5 -7227.5 {}
L 1 917.5 -7225 922.5 -7225 {}
L 1 917.5 -7222.5 922.5 -7222.5 {}
L 1 1347.5 -7242.5 1352.5 -7242.5 {}
L 1 1347.5 -7240 1352.5 -7240 {}
L 1 1347.5 -7237.5 1352.5 -7237.5 {}
L 1 1347.5 -7235 1352.5 -7235 {}
L 1 1347.5 -7232.5 1352.5 -7232.5 {}
L 1 1347.5 -7230 1352.5 -7230 {}
L 1 1347.5 -7227.5 1352.5 -7227.5 {}
L 1 1347.5 -7225 1352.5 -7225 {}
L 1 1347.5 -7222.5 1352.5 -7222.5 {}
L 1 2117.5 -7242.5 2122.5 -7242.5 {}
L 1 2117.5 -7240 2122.5 -7240 {}
L 1 2117.5 -7237.5 2122.5 -7237.5 {}
L 1 2117.5 -7235 2122.5 -7235 {}
L 1 2117.5 -7232.5 2122.5 -7232.5 {}
L 1 2117.5 -7230 2122.5 -7230 {}
L 1 2117.5 -7227.5 2122.5 -7227.5 {}
L 1 2117.5 -7225 2122.5 -7225 {}
L 1 2117.5 -7222.5 2122.5 -7222.5 {}
L 1 917.5 -8542.5 922.5 -8542.5 {}
L 1 917.5 -8540 922.5 -8540 {}
L 1 917.5 -8537.5 922.5 -8537.5 {}
L 1 917.5 -8535 922.5 -8535 {}
L 1 917.5 -8532.5 922.5 -8532.5 {}
L 1 917.5 -8530 922.5 -8530 {}
L 1 917.5 -8527.5 922.5 -8527.5 {}
L 1 917.5 -8525 922.5 -8525 {}
L 1 917.5 -8522.5 922.5 -8522.5 {}
L 1 1627.5 -8532.5 1632.5 -8532.5 {}
L 1 1627.5 -8530 1632.5 -8530 {}
L 1 1627.5 -8527.5 1632.5 -8527.5 {}
L 1 1627.5 -8525 1632.5 -8525 {}
L 1 1627.5 -8522.5 1632.5 -8522.5 {}
L 1 1627.5 -8520 1632.5 -8520 {}
L 1 1627.5 -8517.5 1632.5 -8517.5 {}
L 1 1627.5 -8515 1632.5 -8515 {}
L 1 1627.5 -8512.5 1632.5 -8512.5 {}
L 1 2407.5 -8522.5 2412.5 -8522.5 {}
L 1 2407.5 -8520 2412.5 -8520 {}
L 1 2407.5 -8517.5 2412.5 -8517.5 {}
L 1 2407.5 -8515 2412.5 -8515 {}
L 1 2407.5 -8512.5 2412.5 -8512.5 {}
L 1 2407.5 -8510 2412.5 -8510 {}
L 1 2407.5 -8507.5 2412.5 -8507.5 {}
L 1 2407.5 -8505 2412.5 -8505 {}
L 1 2407.5 -8502.5 2412.5 -8502.5 {}
L 1 3350 -8480 3590 -8480 {}
L 1 3650 -6550 3650 -6220 {}
L 1 4190 -6550 4190 -6220 {}
L 1 4730 -6380 4730 -6220 {}
L 1 3650 -6030 3650 -5930 {}
L 1 3540 -6030 3540 -5930 {}
L 1 3760 -6030 3760 -5930 {}
L 1 3650 -6910 3650 -6760 {}
L 1 4190 -6910 4190 -6760 {}
L 1 4730 -6910 4730 -6800 {}
L 1 4317.5 -8852.5 4322.5 -8852.5 {}
L 1 4317.5 -8850 4322.5 -8850 {}
L 1 4317.5 -8847.5 4322.5 -8847.5 {}
L 1 4317.5 -8845 4322.5 -8845 {}
L 1 4317.5 -8842.5 4322.5 -8842.5 {}
L 1 4317.5 -8840 4322.5 -8840 {}
L 1 4317.5 -8837.5 4322.5 -8837.5 {}
L 1 4317.5 -8835 4322.5 -8835 {}
L 1 4317.5 -8832.5 4322.5 -8832.5 {}
L 1 4767.5 -8922.5 4772.5 -8922.5 {}
L 1 4767.5 -8920 4772.5 -8920 {}
L 1 4767.5 -8917.5 4772.5 -8917.5 {}
L 1 4767.5 -8915 4772.5 -8915 {}
L 1 4767.5 -8912.5 4772.5 -8912.5 {}
L 1 4767.5 -8910 4772.5 -8910 {}
L 1 4767.5 -8907.5 4772.5 -8907.5 {}
L 1 4767.5 -8905 4772.5 -8905 {}
L 1 4767.5 -8902.5 4772.5 -8902.5 {}
L 1 5387.5 -8832.5 5392.5 -8832.5 {}
L 1 5387.5 -8830 5392.5 -8830 {}
L 1 5387.5 -8827.5 5392.5 -8827.5 {}
L 1 5387.5 -8825 5392.5 -8825 {}
L 1 5387.5 -8822.5 5392.5 -8822.5 {}
L 1 5387.5 -8820 5392.5 -8820 {}
L 1 5387.5 -8817.5 5392.5 -8817.5 {}
L 1 5387.5 -8815 5392.5 -8815 {}
L 1 5387.5 -8812.5 5392.5 -8812.5 {}
L 1 3517.5 -8022.5 3522.5 -8022.5 {}
L 1 3517.5 -8020 3522.5 -8020 {}
L 1 3517.5 -8017.5 3522.5 -8017.5 {}
L 1 3517.5 -8015 3522.5 -8015 {}
L 1 3517.5 -8012.5 3522.5 -8012.5 {}
L 1 3517.5 -8010 3522.5 -8010 {}
L 1 3517.5 -8007.5 3522.5 -8007.5 {}
L 1 3517.5 -8005 3522.5 -8005 {}
L 1 3517.5 -8002.5 3522.5 -8002.5 {}
L 1 4177.5 -8042.5 4182.5 -8042.5 {}
L 1 4177.5 -8040 4182.5 -8040 {}
L 1 4177.5 -8037.5 4182.5 -8037.5 {}
L 1 4177.5 -8035 4182.5 -8035 {}
L 1 4177.5 -8032.5 4182.5 -8032.5 {}
L 1 4177.5 -8030 4182.5 -8030 {}
L 1 4177.5 -8027.5 4182.5 -8027.5 {}
L 1 4177.5 -8025 4182.5 -8025 {}
L 1 4177.5 -8022.5 4182.5 -8022.5 {}
L 1 5367.5 -8092.5 5372.5 -8092.5 {}
L 1 5367.5 -8090 5372.5 -8090 {}
L 1 5367.5 -8087.5 5372.5 -8087.5 {}
L 1 5367.5 -8085 5372.5 -8085 {}
L 1 5367.5 -8082.5 5372.5 -8082.5 {}
L 1 5367.5 -8080 5372.5 -8080 {}
L 1 5367.5 -8077.5 5372.5 -8077.5 {}
L 1 5367.5 -8075 5372.5 -8075 {}
L 1 5367.5 -8072.5 5372.5 -8072.5 {}
L 1 3677.5 -7662.5 3682.5 -7662.5 {}
L 1 3677.5 -7660 3682.5 -7660 {}
L 1 3677.5 -7657.5 3682.5 -7657.5 {}
L 1 3677.5 -7655 3682.5 -7655 {}
L 1 3677.5 -7652.5 3682.5 -7652.5 {}
L 1 3677.5 -7650 3682.5 -7650 {}
L 1 3677.5 -7647.5 3682.5 -7647.5 {}
L 1 3677.5 -7645 3682.5 -7645 {}
L 1 3677.5 -7642.5 3682.5 -7642.5 {}
L 1 4077.5 -7612.5 4082.5 -7612.5 {}
L 1 4077.5 -7610 4082.5 -7610 {}
L 1 4077.5 -7607.5 4082.5 -7607.5 {}
L 1 4077.5 -7605 4082.5 -7605 {}
L 1 4077.5 -7602.5 4082.5 -7602.5 {}
L 1 4077.5 -7600 4082.5 -7600 {}
L 1 4077.5 -7597.5 4082.5 -7597.5 {}
L 1 4077.5 -7595 4082.5 -7595 {}
L 1 4077.5 -7592.5 4082.5 -7592.5 {}
L 1 4637.5 -7642.5 4642.5 -7642.5 {}
L 1 4637.5 -7640 4642.5 -7640 {}
L 1 4637.5 -7637.5 4642.5 -7637.5 {}
L 1 4637.5 -7635 4642.5 -7635 {}
L 1 4637.5 -7632.5 4642.5 -7632.5 {}
L 1 4637.5 -7630 4642.5 -7630 {}
L 1 4637.5 -7627.5 4642.5 -7627.5 {}
L 1 4637.5 -7625 4642.5 -7625 {}
L 1 4637.5 -7622.5 4642.5 -7622.5 {}
L 1 4257.5 -7092.5 4262.5 -7092.5 {}
L 1 4257.5 -7090 4262.5 -7090 {}
L 1 4257.5 -7087.5 4262.5 -7087.5 {}
L 1 4257.5 -7085 4262.5 -7085 {}
L 1 4257.5 -7082.5 4262.5 -7082.5 {}
L 1 4257.5 -7080 4262.5 -7080 {}
L 1 4257.5 -7077.5 4262.5 -7077.5 {}
L 1 4257.5 -7075 4262.5 -7075 {}
L 1 4257.5 -7072.5 4262.5 -7072.5 {}
L 1 4527.5 -7092.5 4532.5 -7092.5 {}
L 1 4527.5 -7090 4532.5 -7090 {}
L 1 4527.5 -7087.5 4532.5 -7087.5 {}
L 1 4527.5 -7085 4532.5 -7085 {}
L 1 4527.5 -7082.5 4532.5 -7082.5 {}
L 1 4527.5 -7080 4532.5 -7080 {}
L 1 4527.5 -7077.5 4532.5 -7077.5 {}
L 1 4527.5 -7075 4532.5 -7075 {}
L 1 4527.5 -7072.5 4532.5 -7072.5 {}
L 1 5127.5 -7092.5 5132.5 -7092.5 {}
L 1 5127.5 -7090 5132.5 -7090 {}
L 1 5127.5 -7087.5 5132.5 -7087.5 {}
L 1 5127.5 -7085 5132.5 -7085 {}
L 1 5127.5 -7082.5 5132.5 -7082.5 {}
L 1 5127.5 -7080 5132.5 -7080 {}
L 1 5127.5 -7077.5 5132.5 -7077.5 {}
L 1 5127.5 -7075 5132.5 -7075 {}
L 1 5127.5 -7072.5 5132.5 -7072.5 {}
L 1 4257.5 -6712.5 4262.5 -6712.5 {}
L 1 4257.5 -6710 4262.5 -6710 {}
L 1 4257.5 -6707.5 4262.5 -6707.5 {}
L 1 4257.5 -6705 4262.5 -6705 {}
L 1 4257.5 -6702.5 4262.5 -6702.5 {}
L 1 4257.5 -6700 4262.5 -6700 {}
L 1 4257.5 -6697.5 4262.5 -6697.5 {}
L 1 4257.5 -6695 4262.5 -6695 {}
L 1 4257.5 -6692.5 4262.5 -6692.5 {}
L 1 6480 -7170 6480 -7070 {}
L 1 6370 -7170 6370 -7070 {}
L 1 6590 -7170 6590 -7070 {}
L 1 6480 -7010 6480 -6980 {}
L 1 6370 -7010 6370 -6980 {}
L 1 6590 -7010 6590 -6980 {}
L 1 7737.5 -7052.5 7742.5 -7052.5 {}
L 1 7737.5 -7050 7742.5 -7050 {}
L 1 7737.5 -7047.5 7742.5 -7047.5 {}
L 1 7737.5 -7045 7742.5 -7045 {}
L 1 7737.5 -7042.5 7742.5 -7042.5 {}
L 1 7737.5 -7040 7742.5 -7040 {}
L 1 7737.5 -7037.5 7742.5 -7037.5 {}
L 1 7737.5 -7035 7742.5 -7035 {}
L 1 7737.5 -7032.5 7742.5 -7032.5 {}
L 1 7227.5 -7022.5 7232.5 -7022.5 {}
L 1 7227.5 -7020 7232.5 -7020 {}
L 1 7227.5 -7017.5 7232.5 -7017.5 {}
L 1 7227.5 -7015 7232.5 -7015 {}
L 1 7227.5 -7012.5 7232.5 -7012.5 {}
L 1 7227.5 -7010 7232.5 -7010 {}
L 1 7227.5 -7007.5 7232.5 -7007.5 {}
L 1 7227.5 -7005 7232.5 -7005 {}
L 1 7227.5 -7002.5 7232.5 -7002.5 {}
L 1 4257.5 -6352.5 4262.5 -6352.5 {}
L 1 4257.5 -6350 4262.5 -6350 {}
L 1 4257.5 -6347.5 4262.5 -6347.5 {}
L 1 4257.5 -6345 4262.5 -6345 {}
L 1 4257.5 -6342.5 4262.5 -6342.5 {}
L 1 4257.5 -6340 4262.5 -6340 {}
L 1 4257.5 -6337.5 4262.5 -6337.5 {}
L 1 4257.5 -6335 4262.5 -6335 {}
L 1 4257.5 -6332.5 4262.5 -6332.5 {}
L 1 4787.5 -6462.5 4792.5 -6462.5 {}
L 1 4787.5 -6460 4792.5 -6460 {}
L 1 4787.5 -6457.5 4792.5 -6457.5 {}
L 1 4787.5 -6455 4792.5 -6455 {}
L 1 4787.5 -6452.5 4792.5 -6452.5 {}
L 1 4787.5 -6450 4792.5 -6450 {}
L 1 4787.5 -6447.5 4792.5 -6447.5 {}
L 1 4787.5 -6445 4792.5 -6445 {}
L 1 4787.5 -6442.5 4792.5 -6442.5 {}
L 1 4407.5 -5942.5 4412.5 -5942.5 {}
L 1 4407.5 -5940 4412.5 -5940 {}
L 1 4407.5 -5937.5 4412.5 -5937.5 {}
L 1 4407.5 -5935 4412.5 -5935 {}
L 1 4407.5 -5932.5 4412.5 -5932.5 {}
L 1 4407.5 -5930 4412.5 -5930 {}
L 1 4407.5 -5927.5 4412.5 -5927.5 {}
L 1 4407.5 -5925 4412.5 -5925 {}
L 1 4407.5 -5922.5 4412.5 -5922.5 {}
L 1 4897.5 -6002.5 4902.5 -6002.5 {}
L 1 4897.5 -6000 4902.5 -6000 {}
L 1 4897.5 -5997.5 4902.5 -5997.5 {}
L 1 4897.5 -5995 4902.5 -5995 {}
L 1 4897.5 -5992.5 4902.5 -5992.5 {}
L 1 4897.5 -5990 4902.5 -5990 {}
L 1 4897.5 -5987.5 4902.5 -5987.5 {}
L 1 4897.5 -5985 4902.5 -5985 {}
L 1 4897.5 -5982.5 4902.5 -5982.5 {}
L 1 5427.5 -6132.5 5432.5 -6132.5 {}
L 1 5427.5 -6130 5432.5 -6130 {}
L 1 5427.5 -6127.5 5432.5 -6127.5 {}
L 1 5427.5 -6125 5432.5 -6125 {}
L 1 5427.5 -6122.5 5432.5 -6122.5 {}
L 1 5427.5 -6120 5432.5 -6120 {}
L 1 5427.5 -6117.5 5432.5 -6117.5 {}
L 1 5427.5 -6115 5432.5 -6115 {}
L 1 5427.5 -6112.5 5432.5 -6112.5 {}
L 1 987.5 -8812.5 992.5 -8812.5 {}
L 1 987.5 -8810 992.5 -8810 {}
L 1 987.5 -8807.5 992.5 -8807.5 {}
L 1 987.5 -8805 992.5 -8805 {}
L 1 987.5 -8802.5 992.5 -8802.5 {}
L 1 987.5 -8800 992.5 -8800 {}
L 1 987.5 -8797.5 992.5 -8797.5 {}
L 1 987.5 -8795 992.5 -8795 {}
L 1 987.5 -8792.5 992.5 -8792.5 {}
L 1 6480 -6790 6480 -6690 {}
L 1 6370 -6790 6370 -6690 {}
L 1 6590 -6790 6590 -6690 {}
L 1 7227.5 -6642.5 7232.5 -6642.5 {}
L 1 7227.5 -6640 7232.5 -6640 {}
L 1 7227.5 -6637.5 7232.5 -6637.5 {}
L 1 7227.5 -6635 7232.5 -6635 {}
L 1 7227.5 -6632.5 7232.5 -6632.5 {}
L 1 7227.5 -6630 7232.5 -6630 {}
L 1 7227.5 -6627.5 7232.5 -6627.5 {}
L 1 7227.5 -6625 7232.5 -6625 {}
L 1 7227.5 -6622.5 7232.5 -6622.5 {}
L 1 7737.5 -6592.5 7742.5 -6592.5 {}
L 1 7737.5 -6590 7742.5 -6590 {}
L 1 7737.5 -6587.5 7742.5 -6587.5 {}
L 1 7737.5 -6585 7742.5 -6585 {}
L 1 7737.5 -6582.5 7742.5 -6582.5 {}
L 1 7737.5 -6580 7742.5 -6580 {}
L 1 7737.5 -6577.5 7742.5 -6577.5 {}
L 1 7737.5 -6575 7742.5 -6575 {}
L 1 7737.5 -6572.5 7742.5 -6572.5 {}
L 1 6280 -8370 6530 -8370 {}
L 1 7000 -8370 7070 -8370 {}
L 1 6820 -8370 6880 -8370 {}
L 1 7450 -8370 7700 -8370 {}
L 1 8000 -8370 8250 -8370 {}
L 1 6280 -8090 6530 -8090 {}
L 1 6820 -8090 7070 -8090 {}
L 1 7450 -8090 7700 -8090 {}
L 1 7570 -8210 7570 -8090 {}
L 1 8120 -8090 8250 -8090 {}
L 1 8120 -8210 8120 -8090 {}
L 1 5190 -6380 5190 -6220 {}
L 1 5327.5 -6382.5 5332.5 -6382.5 {}
L 1 5327.5 -6380 5332.5 -6380 {}
L 1 5327.5 -6377.5 5332.5 -6377.5 {}
L 1 5327.5 -6375 5332.5 -6375 {}
L 1 5327.5 -6372.5 5332.5 -6372.5 {}
L 1 5327.5 -6370 5332.5 -6370 {}
L 1 5327.5 -6367.5 5332.5 -6367.5 {}
L 1 5327.5 -6365 5332.5 -6365 {}
L 1 5327.5 -6362.5 5332.5 -6362.5 {}
L 1 6820 -7510 7070 -7510 {}
L 1 7540 -7380 7610 -7380 {}
L 1 7360 -7380 7420 -7380 {}
L 1 7477.5 -7492.5 7482.5 -7492.5 {}
L 1 7477.5 -7490 7482.5 -7490 {}
L 1 7477.5 -7487.5 7482.5 -7487.5 {}
L 1 7477.5 -7485 7482.5 -7485 {}
L 1 7477.5 -7482.5 7482.5 -7482.5 {}
L 1 7477.5 -7480 7482.5 -7480 {}
L 1 7477.5 -7477.5 7482.5 -7477.5 {}
L 1 7477.5 -7475 7482.5 -7475 {}
L 1 7477.5 -7472.5 7482.5 -7472.5 {}
L 1 6280 -7510 6530 -7510 {}
L 1 6327.5 -7422.5 6332.5 -7422.5 {}
L 1 6327.5 -7420 6332.5 -7420 {}
L 1 6327.5 -7417.5 6332.5 -7417.5 {}
L 1 6327.5 -7415 6332.5 -7415 {}
L 1 6327.5 -7412.5 6332.5 -7412.5 {}
L 1 6327.5 -7410 6332.5 -7410 {}
L 1 6327.5 -7407.5 6332.5 -7407.5 {}
L 1 6327.5 -7405 6332.5 -7405 {}
L 1 6327.5 -7402.5 6332.5 -7402.5 {}
L 1 6447.5 -7422.5 6452.5 -7422.5 {}
L 1 6447.5 -7420 6452.5 -7420 {}
L 1 6447.5 -7417.5 6452.5 -7417.5 {}
L 1 6447.5 -7415 6452.5 -7415 {}
L 1 6447.5 -7412.5 6452.5 -7412.5 {}
L 1 6447.5 -7410 6452.5 -7410 {}
L 1 6447.5 -7407.5 6452.5 -7407.5 {}
L 1 6447.5 -7405 6452.5 -7405 {}
L 1 6447.5 -7402.5 6452.5 -7402.5 {}
L 1 7307.5 -6092.5 7312.5 -6092.5 {}
L 1 7307.5 -6090 7312.5 -6090 {}
L 1 7307.5 -6087.5 7312.5 -6087.5 {}
L 1 7307.5 -6085 7312.5 -6085 {}
L 1 7307.5 -6082.5 7312.5 -6082.5 {}
L 1 7307.5 -6080 7312.5 -6080 {}
L 1 7307.5 -6077.5 7312.5 -6077.5 {}
L 1 7307.5 -6075 7312.5 -6075 {}
L 1 7307.5 -6072.5 7312.5 -6072.5 {}
L 1 6280 -7690 6530 -7690 {}
L 1 6820 -7690 7070 -7690 {}
L 1 7450 -7690 7700 -7690 {}
L 1 7490 -7860 7490 -7740 {}
L 1 3287.5 -8292.5 3292.5 -8292.5 {}
L 1 3287.5 -8290 3292.5 -8290 {}
L 1 3287.5 -8287.5 3292.5 -8287.5 {}
L 1 3287.5 -8285 3292.5 -8285 {}
L 1 3287.5 -8282.5 3292.5 -8282.5 {}
L 1 3287.5 -8280 3292.5 -8280 {}
L 1 3287.5 -8277.5 3292.5 -8277.5 {}
L 1 3287.5 -8275 3292.5 -8275 {}
L 1 3287.5 -8272.5 3292.5 -8272.5 {}
L 1 3890 -8480 4130 -8480 {}
L 1 3827.5 -8472.5 3832.5 -8472.5 {}
L 1 3827.5 -8470 3832.5 -8470 {}
L 1 3827.5 -8467.5 3832.5 -8467.5 {}
L 1 3827.5 -8465 3832.5 -8465 {}
L 1 3827.5 -8462.5 3832.5 -8462.5 {}
L 1 3827.5 -8460 3832.5 -8460 {}
L 1 3827.5 -8457.5 3832.5 -8457.5 {}
L 1 3827.5 -8455 3832.5 -8455 {}
L 1 3827.5 -8452.5 3832.5 -8452.5 {}
L 1 4450 -8480 4690 -8480 {}
L 1 4837.5 -8262.5 4842.5 -8262.5 {}
L 1 4837.5 -8260 4842.5 -8260 {}
L 1 4837.5 -8257.5 4842.5 -8257.5 {}
L 1 4837.5 -8255 4842.5 -8255 {}
L 1 4837.5 -8252.5 4842.5 -8252.5 {}
L 1 4837.5 -8250 4842.5 -8250 {}
L 1 4837.5 -8247.5 4842.5 -8247.5 {}
L 1 4837.5 -8245 4842.5 -8245 {}
L 1 4837.5 -8242.5 4842.5 -8242.5 {}
L 1 4450 -8480 4450 -8300 {}
L 1 5020 -8480 5260 -8480 {}
L 1 5407.5 -8262.5 5412.5 -8262.5 {}
L 1 5407.5 -8260 5412.5 -8260 {}
L 1 5407.5 -8257.5 5412.5 -8257.5 {}
L 1 5407.5 -8255 5412.5 -8255 {}
L 1 5407.5 -8252.5 5412.5 -8252.5 {}
L 1 5407.5 -8250 5412.5 -8250 {}
L 1 5407.5 -8247.5 5412.5 -8247.5 {}
L 1 5407.5 -8245 5412.5 -8245 {}
L 1 5407.5 -8242.5 5412.5 -8242.5 {}
L 1 5020 -8480 5020 -8300 {}
L 1 2277.5 -5852.5 2282.5 -5852.5 {}
L 1 2277.5 -5850 2282.5 -5850 {}
L 1 2277.5 -5847.5 2282.5 -5847.5 {}
L 1 2277.5 -5845 2282.5 -5845 {}
L 1 2277.5 -5842.5 2282.5 -5842.5 {}
L 1 2277.5 -5840 2282.5 -5840 {}
L 1 2277.5 -5837.5 2282.5 -5837.5 {}
L 1 2277.5 -5835 2282.5 -5835 {}
L 1 2277.5 -5832.5 2282.5 -5832.5 {}
L 1 4807.5 -6712.5 4812.5 -6712.5 {}
L 1 4807.5 -6710 4812.5 -6710 {}
L 1 4807.5 -6707.5 4812.5 -6707.5 {}
L 1 4807.5 -6705 4812.5 -6705 {}
L 1 4807.5 -6702.5 4812.5 -6702.5 {}
L 1 4807.5 -6700 4812.5 -6700 {}
L 1 4807.5 -6697.5 4812.5 -6697.5 {}
L 1 4807.5 -6695 4812.5 -6695 {}
L 1 4807.5 -6692.5 4812.5 -6692.5 {}
L 1 7997.5 -8082.5 8002.5 -8082.5 {}
L 1 7997.5 -8080 8002.5 -8080 {}
L 1 7997.5 -8077.5 8002.5 -8077.5 {}
L 1 7997.5 -8075 8002.5 -8075 {}
L 1 7997.5 -8072.5 8002.5 -8072.5 {}
L 1 7997.5 -8070 8002.5 -8070 {}
L 1 7997.5 -8067.5 8002.5 -8067.5 {}
L 1 7997.5 -8065 8002.5 -8065 {}
L 1 7997.5 -8062.5 8002.5 -8062.5 {}
L 1 6467.5 -8202.5 6472.5 -8202.5 {}
L 1 6467.5 -8200 6472.5 -8200 {}
L 1 6467.5 -8197.5 6472.5 -8197.5 {}
L 1 6467.5 -8195 6472.5 -8195 {}
L 1 6467.5 -8192.5 6472.5 -8192.5 {}
L 1 6467.5 -8190 6472.5 -8190 {}
L 1 6467.5 -8187.5 6472.5 -8187.5 {}
L 1 6467.5 -8185 6472.5 -8185 {}
L 1 6467.5 -8182.5 6472.5 -8182.5 {}
L 1 7007.5 -8182.5 7012.5 -8182.5 {}
L 1 7007.5 -8180 7012.5 -8180 {}
L 1 7007.5 -8177.5 7012.5 -8177.5 {}
L 1 7007.5 -8175 7012.5 -8175 {}
L 1 7007.5 -8172.5 7012.5 -8172.5 {}
L 1 7007.5 -8170 7012.5 -8170 {}
L 1 7007.5 -8167.5 7012.5 -8167.5 {}
L 1 7007.5 -8165 7012.5 -8165 {}
L 1 7007.5 -8162.5 7012.5 -8162.5 {}
L 1 7980 -7860 7980 -7740 {}
L 1 6917.5 -7802.5 6922.5 -7802.5 {}
L 1 6917.5 -7800 6922.5 -7800 {}
L 1 6917.5 -7797.5 6922.5 -7797.5 {}
L 1 6917.5 -7795 6922.5 -7795 {}
L 1 6917.5 -7792.5 6922.5 -7792.5 {}
L 1 6917.5 -7790 6922.5 -7790 {}
L 1 6917.5 -7787.5 6922.5 -7787.5 {}
L 1 6917.5 -7785 6922.5 -7785 {}
L 1 6917.5 -7782.5 6922.5 -7782.5 {}
L 1 8177.5 -7752.5 8182.5 -7752.5 {}
L 1 8177.5 -7750 8182.5 -7750 {}
L 1 8177.5 -7747.5 8182.5 -7747.5 {}
L 1 8177.5 -7745 8182.5 -7745 {}
L 1 8177.5 -7742.5 8182.5 -7742.5 {}
L 1 8177.5 -7740 8182.5 -7740 {}
L 1 8177.5 -7737.5 8182.5 -7737.5 {}
L 1 8177.5 -7735 8182.5 -7735 {}
L 1 8177.5 -7732.5 8182.5 -7732.5 {}
L 1 8137.5 -6342.5 8142.5 -6342.5 {}
L 1 8137.5 -6340 8142.5 -6340 {}
L 1 8137.5 -6337.5 8142.5 -6337.5 {}
L 1 8137.5 -6335 8142.5 -6335 {}
L 1 8137.5 -6332.5 8142.5 -6332.5 {}
L 1 8137.5 -6330 8142.5 -6330 {}
L 1 8137.5 -6327.5 8142.5 -6327.5 {}
L 1 8137.5 -6325 8142.5 -6325 {}
L 1 8137.5 -6322.5 8142.5 -6322.5 {}
L 2 1255 -8250 1255 -8190 {}
L 2 1255 -8240 1270 -8240 {}
L 2 1270 -8250 1270 -8240 {}
L 2 1255 -8200 1270 -8200 {}
L 2 1270 -8200 1270 -8190 {}
L 2 1245 -8235 1245 -8205 {}
L 2 1245 -8220 1245 -8215 {}
L 2 1230 -8220 1237.5 -8220 {}
L 2 1230 -8220 1245 -8220 {}
L 2 1260 -8220 1270 -8220 {}
L 2 1255 -8225 1260 -8220 {}
L 2 1255 -8215 1260 -8220 {}
L 2 1270 -8290 1270 -8280 {}
L 2 1270 -8290 1277.5 -8292.5 {}
L 2 1262.5 -8297.5 1277.5 -8292.5 {}
L 2 1262.5 -8297.5 1277.5 -8302.5 {}
L 2 1262.5 -8307.5 1277.5 -8302.5 {}
L 2 1262.5 -8307.5 1277.5 -8312.5 {}
L 2 1262.5 -8317.5 1277.5 -8312.5 {}
L 2 1262.5 -8317.5 1277.5 -8322.5 {}
L 2 1262.5 -8327.5 1277.5 -8322.5 {}
L 2 1262.5 -8327.5 1270 -8330 {}
L 2 1270 -8340 1270 -8330 {}
L 2 1272.5 -8332.5 1277.5 -8332.5 {}
L 2 1275 -8335 1275 -8330 {}
L 2 1360 -8215 1360 -8190 {}
L 2 1360 -8250 1360 -8225 {}
L 2 1350 -8225 1370 -8225 {}
L 2 1350 -8215 1370 -8215 {}
L 2 1362.5 -8242.5 1367.5 -8242.5 {}
L 2 1365 -8245 1365 -8240 {}
L 2 1270 -8280 1270 -8250 {}
L 2 1270 -8370 1270 -8340 {}
L 2 1360 -8190 1360 -8110 {}
L 2 1270 -8220 1270 -8110 {}
L 2 1270 -8110 1360 -8110 {}
L 2 2035 -8260 2035 -8200 {}
L 2 2035 -8250 2050 -8250 {}
L 2 2050 -8260 2050 -8250 {}
L 2 2035 -8210 2050 -8210 {}
L 2 2050 -8210 2050 -8200 {}
L 2 2025 -8245 2025 -8215 {}
L 2 2025 -8230 2025 -8225 {}
L 2 2010 -8230 2017.5 -8230 {}
L 2 2010 -8230 2025 -8230 {}
L 2 2040 -8230 2050 -8230 {}
L 2 2035 -8235 2040 -8230 {}
L 2 2035 -8225 2040 -8230 {}
L 2 2050 -8300 2050 -8290 {}
L 2 2050 -8300 2057.5 -8302.5 {}
L 2 2042.5 -8307.5 2057.5 -8302.5 {}
L 2 2042.5 -8307.5 2057.5 -8312.5 {}
L 2 2042.5 -8317.5 2057.5 -8312.5 {}
L 2 2042.5 -8317.5 2057.5 -8322.5 {}
L 2 2042.5 -8327.5 2057.5 -8322.5 {}
L 2 2042.5 -8327.5 2057.5 -8332.5 {}
L 2 2042.5 -8337.5 2057.5 -8332.5 {}
L 2 2042.5 -8337.5 2050 -8340 {}
L 2 2050 -8350 2050 -8340 {}
L 2 2052.5 -8342.5 2057.5 -8342.5 {}
L 2 2055 -8345 2055 -8340 {}
L 2 2140 -8225 2140 -8200 {}
L 2 2140 -8260 2140 -8235 {}
L 2 2130 -8235 2150 -8235 {}
L 2 2130 -8225 2150 -8225 {}
L 2 2142.5 -8252.5 2147.5 -8252.5 {}
L 2 2145 -8255 2145 -8250 {}
L 2 2050 -8290 2050 -8260 {}
L 2 2050 -8380 2050 -8350 {}
L 2 2140 -8200 2140 -8120 {}
L 2 2050 -8230 2050 -8120 {}
L 2 2050 -8120 2140 -8120 {}
L 2 1360 -7830 1360 -7820 {}
L 2 1360 -7830 1367.5 -7832.5 {}
L 2 1352.5 -7837.5 1367.5 -7832.5 {}
L 2 1352.5 -7837.5 1367.5 -7842.5 {}
L 2 1352.5 -7847.5 1367.5 -7842.5 {}
L 2 1352.5 -7847.5 1367.5 -7852.5 {}
L 2 1352.5 -7857.5 1367.5 -7852.5 {}
L 2 1352.5 -7857.5 1367.5 -7862.5 {}
L 2 1352.5 -7867.5 1367.5 -7862.5 {}
L 2 1352.5 -7867.5 1360 -7870 {}
L 2 1360 -7880 1360 -7870 {}
L 2 1362.5 -7872.5 1367.5 -7872.5 {}
L 2 1365 -7875 1365 -7870 {}
L 2 1360 -7000 1360 -6990 {}
L 2 1360 -7000 1367.5 -7002.5 {}
L 2 1352.5 -7007.5 1367.5 -7002.5 {}
L 2 1352.5 -7007.5 1367.5 -7012.5 {}
L 2 1352.5 -7017.5 1367.5 -7012.5 {}
L 2 1352.5 -7017.5 1367.5 -7022.5 {}
L 2 1352.5 -7027.5 1367.5 -7022.5 {}
L 2 1352.5 -7027.5 1367.5 -7032.5 {}
L 2 1352.5 -7037.5 1367.5 -7032.5 {}
L 2 1352.5 -7037.5 1360 -7040 {}
L 2 1360 -7050 1360 -7040 {}
L 2 1362.5 -7042.5 1367.5 -7042.5 {}
L 2 1365 -7045 1365 -7040 {}
L 2 1280 -7050 1360 -7050 {}
L 2 1280 -6990 1360 -6990 {}
L 2 1360 -6510 1360 -6500 {}
L 2 1360 -6510 1367.5 -6512.5 {}
L 2 1352.5 -6517.5 1367.5 -6512.5 {}
L 2 1352.5 -6517.5 1367.5 -6522.5 {}
L 2 1352.5 -6527.5 1367.5 -6522.5 {}
L 2 1352.5 -6527.5 1367.5 -6532.5 {}
L 2 1352.5 -6537.5 1367.5 -6532.5 {}
L 2 1352.5 -6537.5 1367.5 -6542.5 {}
L 2 1352.5 -6547.5 1367.5 -6542.5 {}
L 2 1352.5 -6547.5 1360 -6550 {}
L 2 1360 -6560 1360 -6550 {}
L 2 1362.5 -6552.5 1367.5 -6552.5 {}
L 2 1365 -6555 1365 -6550 {}
L 2 1280 -6470 1360 -6500 {}
L 2 1280 -6590 1360 -6560 {}
L 2 725 -8250 725 -8190 {}
L 2 725 -8240 740 -8240 {}
L 2 740 -8250 740 -8240 {}
L 2 725 -8200 740 -8200 {}
L 2 740 -8200 740 -8190 {}
L 2 715 -8235 715 -8205 {}
L 2 715 -8220 715 -8215 {}
L 2 700 -8220 707.5 -8220 {}
L 2 700 -8220 715 -8220 {}
L 2 730 -8220 740 -8220 {}
L 2 725 -8225 730 -8220 {}
L 2 725 -8215 730 -8220 {}
L 2 740 -8290 740 -8280 {}
L 2 740 -8290 747.5 -8292.5 {}
L 2 732.5 -8297.5 747.5 -8292.5 {}
L 2 732.5 -8297.5 747.5 -8302.5 {}
L 2 732.5 -8307.5 747.5 -8302.5 {}
L 2 732.5 -8307.5 747.5 -8312.5 {}
L 2 732.5 -8317.5 747.5 -8312.5 {}
L 2 732.5 -8317.5 747.5 -8322.5 {}
L 2 732.5 -8327.5 747.5 -8322.5 {}
L 2 732.5 -8327.5 740 -8330 {}
L 2 740 -8340 740 -8330 {}
L 2 742.5 -8332.5 747.5 -8332.5 {}
L 2 745 -8335 745 -8330 {}
L 2 830 -8215 830 -8190 {}
L 2 830 -8250 830 -8225 {}
L 2 820 -8225 840 -8225 {}
L 2 820 -8215 840 -8215 {}
L 2 832.5 -8242.5 837.5 -8242.5 {}
L 2 835 -8245 835 -8240 {}
L 2 740 -8280 740 -8250 {}
L 2 740 -8370 740 -8340 {}
L 2 830 -8190 830 -8110 {}
L 2 740 -8220 740 -8110 {}
L 2 740 -8110 830 -8110 {}
L 2 725 -5980 725 -5920 {}
L 2 725 -5970 740 -5970 {}
L 2 740 -5980 740 -5970 {}
L 2 725 -5930 740 -5930 {}
L 2 740 -5930 740 -5920 {}
L 2 715 -5965 715 -5935 {}
L 2 715 -5950 715 -5945 {}
L 2 700 -5950 707.5 -5950 {}
L 2 700 -5950 715 -5950 {}
L 2 730 -5950 740 -5950 {}
L 2 725 -5955 730 -5950 {}
L 2 725 -5945 730 -5950 {}
L 2 740 -6020 740 -6010 {}
L 2 740 -6020 747.5 -6022.5 {}
L 2 732.5 -6027.5 747.5 -6022.5 {}
L 2 732.5 -6027.5 747.5 -6032.5 {}
L 2 732.5 -6037.5 747.5 -6032.5 {}
L 2 732.5 -6037.5 747.5 -6042.5 {}
L 2 732.5 -6047.5 747.5 -6042.5 {}
L 2 732.5 -6047.5 747.5 -6052.5 {}
L 2 732.5 -6057.5 747.5 -6052.5 {}
L 2 732.5 -6057.5 740 -6060 {}
L 2 740 -6070 740 -6060 {}
L 2 742.5 -6062.5 747.5 -6062.5 {}
L 2 745 -6065 745 -6060 {}
L 2 830 -5945 830 -5920 {}
L 2 830 -5980 830 -5955 {}
L 2 820 -5955 840 -5955 {}
L 2 820 -5945 840 -5945 {}
L 2 832.5 -5972.5 837.5 -5972.5 {}
L 2 835 -5975 835 -5970 {}
L 2 740 -6010 740 -5980 {}
L 2 740 -6100 740 -6070 {}
L 2 830 -5920 830 -5840 {}
L 2 740 -5950 740 -5840 {}
L 2 740 -5840 830 -5840 {}
L 2 880 -5980 888.75 -5980 {}
L 2 740 -5980 880 -5980 {}
L 2 1265 -5980 1265 -5920 {}
L 2 1265 -5970 1280 -5970 {}
L 2 1280 -5980 1280 -5970 {}
L 2 1265 -5930 1280 -5930 {}
L 2 1280 -5930 1280 -5920 {}
L 2 1255 -5965 1255 -5935 {}
L 2 1255 -5950 1255 -5945 {}
L 2 1240 -5950 1247.5 -5950 {}
L 2 1240 -5950 1255 -5950 {}
L 2 1270 -5950 1280 -5950 {}
L 2 1265 -5955 1270 -5950 {}
L 2 1265 -5945 1270 -5950 {}
L 2 1280 -6020 1280 -6010 {}
L 2 1280 -6020 1287.5 -6022.5 {}
L 2 1272.5 -6027.5 1287.5 -6022.5 {}
L 2 1272.5 -6027.5 1287.5 -6032.5 {}
L 2 1272.5 -6037.5 1287.5 -6032.5 {}
L 2 1272.5 -6037.5 1287.5 -6042.5 {}
L 2 1272.5 -6047.5 1287.5 -6042.5 {}
L 2 1272.5 -6047.5 1287.5 -6052.5 {}
L 2 1272.5 -6057.5 1287.5 -6052.5 {}
L 2 1272.5 -6057.5 1280 -6060 {}
L 2 1280 -6070 1280 -6060 {}
L 2 1282.5 -6062.5 1287.5 -6062.5 {}
L 2 1285 -6065 1285 -6060 {}
L 2 1370 -5945 1370 -5920 {}
L 2 1370 -5980 1370 -5955 {}
L 2 1360 -5955 1380 -5955 {}
L 2 1360 -5945 1380 -5945 {}
L 2 1372.5 -5972.5 1377.5 -5972.5 {}
L 2 1375 -5975 1375 -5970 {}
L 2 1420 -5980 1428.75 -5980 {}
L 2 1280 -6010 1280 -5980 {}
L 2 1280 -6100 1280 -6070 {}
L 2 1280 -5980 1420 -5980 {}
L 2 1370 -5920 1370 -5840 {}
L 2 1280 -5950 1280 -5840 {}
L 2 1280 -5840 1370 -5840 {}
L 2 2105 -5980 2105 -5920 {}
L 2 2105 -5970 2120 -5970 {}
L 2 2120 -5980 2120 -5970 {}
L 2 2105 -5930 2120 -5930 {}
L 2 2120 -5930 2120 -5920 {}
L 2 2095 -5965 2095 -5935 {}
L 2 2095 -5950 2095 -5945 {}
L 2 2080 -5950 2087.5 -5950 {}
L 2 2080 -5950 2095 -5950 {}
L 2 2110 -5950 2120 -5950 {}
L 2 2105 -5955 2110 -5950 {}
L 2 2105 -5945 2110 -5950 {}
L 2 2120 -6020 2120 -6010 {}
L 2 2120 -6020 2127.5 -6022.5 {}
L 2 2112.5 -6027.5 2127.5 -6022.5 {}
L 2 2112.5 -6027.5 2127.5 -6032.5 {}
L 2 2112.5 -6037.5 2127.5 -6032.5 {}
L 2 2112.5 -6037.5 2127.5 -6042.5 {}
L 2 2112.5 -6047.5 2127.5 -6042.5 {}
L 2 2112.5 -6047.5 2127.5 -6052.5 {}
L 2 2112.5 -6057.5 2127.5 -6052.5 {}
L 2 2112.5 -6057.5 2120 -6060 {}
L 2 2120 -6070 2120 -6060 {}
L 2 2122.5 -6062.5 2127.5 -6062.5 {}
L 2 2125 -6065 2125 -6060 {}
L 2 2210 -5945 2210 -5920 {}
L 2 2210 -5980 2210 -5955 {}
L 2 2200 -5955 2220 -5955 {}
L 2 2200 -5945 2220 -5945 {}
L 2 2212.5 -5972.5 2217.5 -5972.5 {}
L 2 2215 -5975 2215 -5970 {}
L 2 2260 -5980 2268.75 -5980 {}
L 2 2120 -6010 2120 -5980 {}
L 2 2120 -6100 2120 -6070 {}
L 2 2120 -5980 2260 -5980 {}
L 2 2210 -5920 2210 -5840 {}
L 2 2120 -5950 2120 -5840 {}
L 2 2120 -5840 2210 -5840 {}
L 2 1770 -5950 2080 -5950 {}
L 2 1690 -6100 2120 -6100 {}
L 2 1690 -5840 2120 -5840 {}
L 2 1255 -7420 1255 -7360 {}
L 2 1255 -7410 1270 -7410 {}
L 2 1270 -7420 1270 -7410 {}
L 2 1255 -7370 1270 -7370 {}
L 2 1270 -7370 1270 -7360 {}
L 2 1245 -7405 1245 -7375 {}
L 2 1245 -7390 1245 -7385 {}
L 2 1230 -7390 1237.5 -7390 {}
L 2 1230 -7390 1245 -7390 {}
L 2 1260 -7390 1270 -7390 {}
L 2 1255 -7395 1260 -7390 {}
L 2 1255 -7385 1260 -7390 {}
L 2 1270 -7460 1270 -7450 {}
L 2 1270 -7460 1277.5 -7462.5 {}
L 2 1262.5 -7467.5 1277.5 -7462.5 {}
L 2 1262.5 -7467.5 1277.5 -7472.5 {}
L 2 1262.5 -7477.5 1277.5 -7472.5 {}
L 2 1262.5 -7477.5 1277.5 -7482.5 {}
L 2 1262.5 -7487.5 1277.5 -7482.5 {}
L 2 1262.5 -7487.5 1277.5 -7492.5 {}
L 2 1262.5 -7497.5 1277.5 -7492.5 {}
L 2 1262.5 -7497.5 1270 -7500 {}
L 2 1270 -7510 1270 -7500 {}
L 2 1272.5 -7502.5 1277.5 -7502.5 {}
L 2 1275 -7505 1275 -7500 {}
L 2 1360 -7385 1360 -7360 {}
L 2 1360 -7420 1360 -7395 {}
L 2 1350 -7395 1370 -7395 {}
L 2 1350 -7385 1370 -7385 {}
L 2 1362.5 -7412.5 1367.5 -7412.5 {}
L 2 1365 -7415 1365 -7410 {}
L 2 1270 -7450 1270 -7420 {}
L 2 1270 -7540 1270 -7510 {}
L 2 1360 -7360 1360 -7280 {}
L 2 1270 -7390 1270 -7280 {}
L 2 1270 -7280 1360 -7280 {}
L 2 2035 -7430 2035 -7370 {}
L 2 2035 -7420 2050 -7420 {}
L 2 2050 -7430 2050 -7420 {}
L 2 2035 -7380 2050 -7380 {}
L 2 2050 -7380 2050 -7370 {}
L 2 2025 -7415 2025 -7385 {}
L 2 2025 -7400 2025 -7395 {}
L 2 2010 -7400 2017.5 -7400 {}
L 2 2010 -7400 2025 -7400 {}
L 2 2040 -7400 2050 -7400 {}
L 2 2035 -7405 2040 -7400 {}
L 2 2035 -7395 2040 -7400 {}
L 2 2050 -7470 2050 -7460 {}
L 2 2050 -7470 2057.5 -7472.5 {}
L 2 2042.5 -7477.5 2057.5 -7472.5 {}
L 2 2042.5 -7477.5 2057.5 -7482.5 {}
L 2 2042.5 -7487.5 2057.5 -7482.5 {}
L 2 2042.5 -7487.5 2057.5 -7492.5 {}
L 2 2042.5 -7497.5 2057.5 -7492.5 {}
L 2 2042.5 -7497.5 2057.5 -7502.5 {}
L 2 2042.5 -7507.5 2057.5 -7502.5 {}
L 2 2042.5 -7507.5 2050 -7510 {}
L 2 2050 -7520 2050 -7510 {}
L 2 2052.5 -7512.5 2057.5 -7512.5 {}
L 2 2055 -7515 2055 -7510 {}
L 2 2140 -7395 2140 -7370 {}
L 2 2140 -7430 2140 -7405 {}
L 2 2130 -7405 2150 -7405 {}
L 2 2130 -7395 2150 -7395 {}
L 2 2142.5 -7422.5 2147.5 -7422.5 {}
L 2 2145 -7425 2145 -7420 {}
L 2 2050 -7460 2050 -7430 {}
L 2 2050 -7550 2050 -7520 {}
L 2 2140 -7370 2140 -7290 {}
L 2 2050 -7400 2050 -7290 {}
L 2 2050 -7290 2140 -7290 {}
L 2 725 -7420 725 -7360 {}
L 2 725 -7410 740 -7410 {}
L 2 740 -7420 740 -7410 {}
L 2 725 -7370 740 -7370 {}
L 2 740 -7370 740 -7360 {}
L 2 715 -7405 715 -7375 {}
L 2 715 -7390 715 -7385 {}
L 2 700 -7390 707.5 -7390 {}
L 2 700 -7390 715 -7390 {}
L 2 730 -7390 740 -7390 {}
L 2 725 -7395 730 -7390 {}
L 2 725 -7385 730 -7390 {}
L 2 740 -7460 740 -7450 {}
L 2 740 -7460 747.5 -7462.5 {}
L 2 732.5 -7467.5 747.5 -7462.5 {}
L 2 732.5 -7467.5 747.5 -7472.5 {}
L 2 732.5 -7477.5 747.5 -7472.5 {}
L 2 732.5 -7477.5 747.5 -7482.5 {}
L 2 732.5 -7487.5 747.5 -7482.5 {}
L 2 732.5 -7487.5 747.5 -7492.5 {}
L 2 732.5 -7497.5 747.5 -7492.5 {}
L 2 732.5 -7497.5 740 -7500 {}
L 2 740 -7510 740 -7500 {}
L 2 742.5 -7502.5 747.5 -7502.5 {}
L 2 745 -7505 745 -7500 {}
L 2 830 -7385 830 -7360 {}
L 2 830 -7420 830 -7395 {}
L 2 820 -7395 840 -7395 {}
L 2 820 -7385 840 -7385 {}
L 2 832.5 -7412.5 837.5 -7412.5 {}
L 2 835 -7415 835 -7410 {}
L 2 740 -7450 740 -7420 {}
L 2 740 -7540 740 -7510 {}
L 2 830 -7360 830 -7280 {}
L 2 740 -7390 740 -7280 {}
L 2 740 -7280 830 -7280 {}
L 2 1795 -8720 1795 -8660 {}
L 2 1795 -8710 1810 -8710 {}
L 2 1810 -8720 1810 -8710 {}
L 2 1795 -8670 1810 -8670 {}
L 2 1810 -8670 1810 -8660 {}
L 2 1785 -8705 1785 -8675 {}
L 2 1785 -8690 1785 -8685 {}
L 2 1770 -8690 1777.5 -8690 {}
L 2 1770 -8690 1785 -8690 {}
L 2 1800 -8690 1810 -8690 {}
L 2 1795 -8695 1800 -8690 {}
L 2 1795 -8685 1800 -8690 {}
L 2 1810 -8760 1810 -8750 {}
L 2 1810 -8760 1817.5 -8762.5 {}
L 2 1802.5 -8767.5 1817.5 -8762.5 {}
L 2 1802.5 -8767.5 1817.5 -8772.5 {}
L 2 1802.5 -8777.5 1817.5 -8772.5 {}
L 2 1802.5 -8777.5 1817.5 -8782.5 {}
L 2 1802.5 -8787.5 1817.5 -8782.5 {}
L 2 1802.5 -8787.5 1817.5 -8792.5 {}
L 2 1802.5 -8797.5 1817.5 -8792.5 {}
L 2 1802.5 -8797.5 1810 -8800 {}
L 2 1810 -8810 1810 -8800 {}
L 2 1812.5 -8802.5 1817.5 -8802.5 {}
L 2 1815 -8805 1815 -8800 {}
L 2 1900 -8685 1900 -8660 {}
L 2 1900 -8720 1900 -8695 {}
L 2 1890 -8695 1910 -8695 {}
L 2 1890 -8685 1910 -8685 {}
L 2 1902.5 -8712.5 1907.5 -8712.5 {}
L 2 1905 -8715 1905 -8710 {}
L 2 1810 -8750 1810 -8720 {}
L 2 1810 -8840 1810 -8810 {}
L 2 1900 -8660 1900 -8580 {}
L 2 1810 -8690 1810 -8580 {}
L 2 1810 -8580 1900 -8580 {}
L 2 725 -8720 725 -8660 {}
L 2 725 -8710 740 -8710 {}
L 2 740 -8720 740 -8710 {}
L 2 725 -8670 740 -8670 {}
L 2 740 -8670 740 -8660 {}
L 2 715 -8705 715 -8675 {}
L 2 715 -8690 715 -8685 {}
L 2 700 -8690 707.5 -8690 {}
L 2 700 -8690 715 -8690 {}
L 2 730 -8690 740 -8690 {}
L 2 725 -8695 730 -8690 {}
L 2 725 -8685 730 -8690 {}
L 2 740 -8760 740 -8750 {}
L 2 740 -8760 747.5 -8762.5 {}
L 2 732.5 -8767.5 747.5 -8762.5 {}
L 2 732.5 -8767.5 747.5 -8772.5 {}
L 2 732.5 -8777.5 747.5 -8772.5 {}
L 2 732.5 -8777.5 747.5 -8782.5 {}
L 2 732.5 -8787.5 747.5 -8782.5 {}
L 2 732.5 -8787.5 747.5 -8792.5 {}
L 2 732.5 -8797.5 747.5 -8792.5 {}
L 2 732.5 -8797.5 740 -8800 {}
L 2 740 -8810 740 -8800 {}
L 2 742.5 -8802.5 747.5 -8802.5 {}
L 2 745 -8805 745 -8800 {}
L 2 830 -8685 830 -8660 {}
L 2 830 -8720 830 -8695 {}
L 2 820 -8695 840 -8695 {}
L 2 820 -8685 840 -8685 {}
L 2 832.5 -8712.5 837.5 -8712.5 {}
L 2 835 -8715 835 -8710 {}
L 2 740 -8750 740 -8720 {}
L 2 740 -8840 740 -8810 {}
L 2 830 -8660 830 -8580 {}
L 2 740 -8690 740 -8580 {}
L 2 740 -8580 830 -8580 {}
L 2 1572.5 -8652.5 1577.5 -8652.5 {}
L 2 1575 -8655 1575 -8650 {}
L 2 1570 -8660 1570 -8600 {}
L 2 1570 -8600 1570 -8580 {}
L 2 1570 -8840 1570 -8660 {}
L 2 2255 -8720 2255 -8660 {}
L 2 2255 -8710 2270 -8710 {}
L 2 2270 -8720 2270 -8710 {}
L 2 2255 -8670 2270 -8670 {}
L 2 2270 -8670 2270 -8660 {}
L 2 2245 -8705 2245 -8675 {}
L 2 2245 -8690 2245 -8685 {}
L 2 2230 -8690 2237.5 -8690 {}
L 2 2230 -8690 2245 -8690 {}
L 2 2260 -8690 2270 -8690 {}
L 2 2255 -8695 2260 -8690 {}
L 2 2255 -8685 2260 -8690 {}
L 2 2270 -8760 2270 -8750 {}
L 2 2270 -8760 2277.5 -8762.5 {}
L 2 2262.5 -8767.5 2277.5 -8762.5 {}
L 2 2262.5 -8767.5 2277.5 -8772.5 {}
L 2 2262.5 -8777.5 2277.5 -8772.5 {}
L 2 2262.5 -8777.5 2277.5 -8782.5 {}
L 2 2262.5 -8787.5 2277.5 -8782.5 {}
L 2 2262.5 -8787.5 2277.5 -8792.5 {}
L 2 2262.5 -8797.5 2277.5 -8792.5 {}
L 2 2262.5 -8797.5 2270 -8800 {}
L 2 2270 -8810 2270 -8800 {}
L 2 2272.5 -8802.5 2277.5 -8802.5 {}
L 2 2275 -8805 2275 -8800 {}
L 2 2270 -8750 2270 -8720 {}
L 2 2270 -8840 2270 -8810 {}
L 2 2270 -8690 2270 -8580 {}
L 2 2270 -8580 2360 -8580 {}
L 2 2032.5 -8652.5 2037.5 -8652.5 {}
L 2 2035 -8655 2035 -8650 {}
L 2 2030 -8660 2030 -8600 {}
L 2 2030 -8600 2030 -8580 {}
L 2 2030 -8840 2030 -8660 {}
L 2 4130 -8830 4260 -8830 {}
L 2 4690 -8830 4820 -8830 {}
L 2 5260 -8860 5390 -8860 {}
L 2 3350 -8060 3590 -8060 {}
L 2 3890 -8060 4130 -8060 {}
L 2 5020 -8060 5330 -8130 {}
L 2 3590 -7570 3590 -7560 {}
L 2 3590 -7570 3597.5 -7572.5 {}
L 2 3582.5 -7577.5 3597.5 -7572.5 {}
L 2 3582.5 -7577.5 3597.5 -7582.5 {}
L 2 3582.5 -7587.5 3597.5 -7582.5 {}
L 2 3582.5 -7587.5 3597.5 -7592.5 {}
L 2 3582.5 -7597.5 3597.5 -7592.5 {}
L 2 3582.5 -7597.5 3597.5 -7602.5 {}
L 2 3582.5 -7607.5 3597.5 -7602.5 {}
L 2 3582.5 -7607.5 3590 -7610 {}
L 2 3590 -7620 3590 -7610 {}
L 2 3592.5 -7612.5 3597.5 -7612.5 {}
L 2 3595 -7615 3595 -7610 {}
L 2 3460 -7670 3460 -7650 {}
L 2 3450 -7670 3470 -7670 {}
L 2 3590 -7650 3590 -7620 {}
L 2 3350 -7650 3590 -7650 {}
L 2 3350 -7650 3350 -7470 {}
L 2 3590 -7560 3590 -7530 {}
L 2 4690 -7600 4690 -7590 {}
L 2 4690 -7600 4697.5 -7602.5 {}
L 2 4682.5 -7607.5 4697.5 -7602.5 {}
L 2 4682.5 -7607.5 4697.5 -7612.5 {}
L 2 4682.5 -7617.5 4697.5 -7612.5 {}
L 2 4682.5 -7617.5 4697.5 -7622.5 {}
L 2 4682.5 -7627.5 4697.5 -7622.5 {}
L 2 4682.5 -7627.5 4697.5 -7632.5 {}
L 2 4682.5 -7637.5 4697.5 -7632.5 {}
L 2 4682.5 -7637.5 4690 -7640 {}
L 2 4690 -7650 4690 -7640 {}
L 2 4692.5 -7642.5 4697.5 -7642.5 {}
L 2 4695 -7645 4695 -7640 {}
L 2 4560 -7700 4560 -7680 {}
L 2 4550 -7700 4570 -7700 {}
L 2 4690 -7680 4690 -7650 {}
L 2 4450 -7680 4690 -7680 {}
L 2 4450 -7680 4450 -7470 {}
L 2 4690 -7590 4690 -7530 {}
L 2 4130 -7570 4130 -7560 {}
L 2 4130 -7570 4137.5 -7572.5 {}
L 2 4122.5 -7577.5 4137.5 -7572.5 {}
L 2 4122.5 -7577.5 4137.5 -7582.5 {}
L 2 4122.5 -7587.5 4137.5 -7582.5 {}
L 2 4122.5 -7587.5 4137.5 -7592.5 {}
L 2 4122.5 -7597.5 4137.5 -7592.5 {}
L 2 4122.5 -7597.5 4137.5 -7602.5 {}
L 2 4122.5 -7607.5 4137.5 -7602.5 {}
L 2 4122.5 -7607.5 4130 -7610 {}
L 2 4130 -7620 4130 -7610 {}
L 2 4132.5 -7612.5 4137.5 -7612.5 {}
L 2 4135 -7615 4135 -7610 {}
L 2 4000 -7670 4000 -7650 {}
L 2 3990 -7670 4010 -7670 {}
L 2 4130 -7650 4130 -7620 {}
L 2 3890 -7650 4130 -7650 {}
L 2 3890 -7650 3890 -7470 {}
L 2 4130 -7560 4130 -7530 {}
L 2 4190 -6710 4190 -6700 {}
L 2 4190 -6710 4197.5 -6712.5 {}
L 2 4182.5 -6717.5 4197.5 -6712.5 {}
L 2 4182.5 -6717.5 4197.5 -6722.5 {}
L 2 4182.5 -6727.5 4197.5 -6722.5 {}
L 2 4182.5 -6727.5 4197.5 -6732.5 {}
L 2 4182.5 -6737.5 4197.5 -6732.5 {}
L 2 4182.5 -6737.5 4197.5 -6742.5 {}
L 2 4182.5 -6747.5 4197.5 -6742.5 {}
L 2 4182.5 -6747.5 4190 -6750 {}
L 2 4190 -6760 4190 -6750 {}
L 2 4192.5 -6752.5 4197.5 -6752.5 {}
L 2 4195 -6755 4195 -6750 {}
L 2 4730 -6740 4730 -6700 {}
L 2 4190 -7090 4190 -7080 {}
L 2 4190 -7090 4197.5 -7092.5 {}
L 2 4182.5 -7097.5 4197.5 -7092.5 {}
L 2 4182.5 -7097.5 4197.5 -7102.5 {}
L 2 4182.5 -7107.5 4197.5 -7102.5 {}
L 2 4182.5 -7107.5 4197.5 -7112.5 {}
L 2 4182.5 -7117.5 4197.5 -7112.5 {}
L 2 4182.5 -7117.5 4197.5 -7122.5 {}
L 2 4182.5 -7127.5 4197.5 -7122.5 {}
L 2 4182.5 -7127.5 4190 -7130 {}
L 2 4190 -7140 4190 -7130 {}
L 2 4192.5 -7132.5 4197.5 -7132.5 {}
L 2 4195 -7135 4195 -7130 {}
L 2 4190 -7150 4190 -7140 {}
L 2 4610 -7140 4730 -7140 {}
L 2 4610 -7080 4730 -7080 {}
L 2 4610 -7090 4610 -7080 {}
L 2 4610 -7090 4617.5 -7092.5 {}
L 2 4602.5 -7097.5 4617.5 -7092.5 {}
L 2 4602.5 -7097.5 4617.5 -7102.5 {}
L 2 4602.5 -7107.5 4617.5 -7102.5 {}
L 2 4602.5 -7107.5 4617.5 -7112.5 {}
L 2 4602.5 -7117.5 4617.5 -7112.5 {}
L 2 4602.5 -7117.5 4617.5 -7122.5 {}
L 2 4602.5 -7127.5 4617.5 -7122.5 {}
L 2 4602.5 -7127.5 4610 -7130 {}
L 2 4610 -7140 4610 -7130 {}
L 2 4612.5 -7132.5 4617.5 -7132.5 {}
L 2 4615 -7135 4615 -7130 {}
L 2 4190 -6030 4190 -5930 {}
L 2 4080 -6030 4080 -5930 {}
L 2 4300 -6030 4300 -5930 {}
L 2 4730 -6030 4730 -5930 {}
L 2 4620 -6030 4620 -5930 {}
L 2 4840 -6030 4840 -5930 {}
L 2 5260 -6130 5260 -5930 {}
L 2 5150 -6130 5150 -5930 {}
L 2 5370 -6130 5370 -5930 {}
L 2 5210 -7140 5330 -7140 {}
L 2 5210 -7080 5330 -7080 {}
L 2 5210 -7090 5210 -7080 {}
L 2 5210 -7090 5217.5 -7092.5 {}
L 2 5202.5 -7097.5 5217.5 -7092.5 {}
L 2 5202.5 -7097.5 5217.5 -7102.5 {}
L 2 5202.5 -7107.5 5217.5 -7102.5 {}
L 2 5202.5 -7107.5 5217.5 -7112.5 {}
L 2 5202.5 -7117.5 5217.5 -7112.5 {}
L 2 5202.5 -7117.5 5217.5 -7122.5 {}
L 2 5202.5 -7127.5 5217.5 -7122.5 {}
L 2 5202.5 -7127.5 5210 -7130 {}
L 2 5210 -7140 5210 -7130 {}
L 2 5212.5 -7132.5 5217.5 -7132.5 {}
L 2 5215 -7135 5215 -7130 {}
L 2 7020 -7170 7020 -7070 {}
L 2 6910 -7170 6910 -7070 {}
L 2 7130 -7170 7130 -7070 {}
L 2 6910 -7020 6910 -7010 {}
L 2 6910 -7020 6917.5 -7022.5 {}
L 2 6902.5 -7027.5 6917.5 -7022.5 {}
L 2 6902.5 -7027.5 6917.5 -7032.5 {}
L 2 6902.5 -7037.5 6917.5 -7032.5 {}
L 2 6902.5 -7037.5 6917.5 -7042.5 {}
L 2 6902.5 -7047.5 6917.5 -7042.5 {}
L 2 6902.5 -7047.5 6917.5 -7052.5 {}
L 2 6902.5 -7057.5 6917.5 -7052.5 {}
L 2 6902.5 -7057.5 6910 -7060 {}
L 2 6910 -7070 6910 -7060 {}
L 2 6912.5 -7062.5 6917.5 -7062.5 {}
L 2 6915 -7065 6915 -7060 {}
L 2 7020 -7020 7020 -7010 {}
L 2 7020 -7020 7027.5 -7022.5 {}
L 2 7012.5 -7027.5 7027.5 -7022.5 {}
L 2 7012.5 -7027.5 7027.5 -7032.5 {}
L 2 7012.5 -7037.5 7027.5 -7032.5 {}
L 2 7012.5 -7037.5 7027.5 -7042.5 {}
L 2 7012.5 -7047.5 7027.5 -7042.5 {}
L 2 7012.5 -7047.5 7027.5 -7052.5 {}
L 2 7012.5 -7057.5 7027.5 -7052.5 {}
L 2 7012.5 -7057.5 7020 -7060 {}
L 2 7020 -7070 7020 -7060 {}
L 2 7022.5 -7062.5 7027.5 -7062.5 {}
L 2 7025 -7065 7025 -7060 {}
L 2 7130 -7020 7130 -7010 {}
L 2 7130 -7020 7137.5 -7022.5 {}
L 2 7122.5 -7027.5 7137.5 -7022.5 {}
L 2 7122.5 -7027.5 7137.5 -7032.5 {}
L 2 7122.5 -7037.5 7137.5 -7032.5 {}
L 2 7122.5 -7037.5 7137.5 -7042.5 {}
L 2 7122.5 -7047.5 7137.5 -7042.5 {}
L 2 7122.5 -7047.5 7137.5 -7052.5 {}
L 2 7122.5 -7057.5 7137.5 -7052.5 {}
L 2 7122.5 -7057.5 7130 -7060 {}
L 2 7130 -7070 7130 -7060 {}
L 2 7132.5 -7062.5 7137.5 -7062.5 {}
L 2 7135 -7065 7135 -7060 {}
L 2 7020 -7010 7020 -6980 {}
L 2 6910 -7010 6910 -6980 {}
L 2 7130 -7010 7130 -6980 {}
L 2 7560 -7170 7560 -7120 {}
L 2 7450 -7170 7450 -7120 {}
L 2 7670 -7170 7670 -7120 {}
L 2 7450 -7070 7450 -7060 {}
L 2 7450 -7070 7457.5 -7072.5 {}
L 2 7442.5 -7077.5 7457.5 -7072.5 {}
L 2 7442.5 -7077.5 7457.5 -7082.5 {}
L 2 7442.5 -7087.5 7457.5 -7082.5 {}
L 2 7442.5 -7087.5 7457.5 -7092.5 {}
L 2 7442.5 -7097.5 7457.5 -7092.5 {}
L 2 7442.5 -7097.5 7457.5 -7102.5 {}
L 2 7442.5 -7107.5 7457.5 -7102.5 {}
L 2 7442.5 -7107.5 7450 -7110 {}
L 2 7450 -7120 7450 -7110 {}
L 2 7452.5 -7112.5 7457.5 -7112.5 {}
L 2 7455 -7115 7455 -7110 {}
L 2 7560 -7070 7560 -7060 {}
L 2 7560 -7070 7567.5 -7072.5 {}
L 2 7552.5 -7077.5 7567.5 -7072.5 {}
L 2 7552.5 -7077.5 7567.5 -7082.5 {}
L 2 7552.5 -7087.5 7567.5 -7082.5 {}
L 2 7552.5 -7087.5 7567.5 -7092.5 {}
L 2 7552.5 -7097.5 7567.5 -7092.5 {}
L 2 7552.5 -7097.5 7567.5 -7102.5 {}
L 2 7552.5 -7107.5 7567.5 -7102.5 {}
L 2 7552.5 -7107.5 7560 -7110 {}
L 2 7560 -7120 7560 -7110 {}
L 2 7562.5 -7112.5 7567.5 -7112.5 {}
L 2 7565 -7115 7565 -7110 {}
L 2 7670 -7070 7670 -7060 {}
L 2 7670 -7070 7677.5 -7072.5 {}
L 2 7662.5 -7077.5 7677.5 -7072.5 {}
L 2 7662.5 -7077.5 7677.5 -7082.5 {}
L 2 7662.5 -7087.5 7677.5 -7082.5 {}
L 2 7662.5 -7087.5 7677.5 -7092.5 {}
L 2 7662.5 -7097.5 7677.5 -7092.5 {}
L 2 7662.5 -7097.5 7677.5 -7102.5 {}
L 2 7662.5 -7107.5 7677.5 -7102.5 {}
L 2 7662.5 -7107.5 7670 -7110 {}
L 2 7670 -7120 7670 -7110 {}
L 2 7672.5 -7112.5 7677.5 -7112.5 {}
L 2 7675 -7115 7675 -7110 {}
L 2 7560 -7060 7560 -6980 {}
L 2 7450 -7060 7450 -6980 {}
L 2 7670 -7060 7670 -6980 {}
L 2 6295 -8740 6295 -8680 {}
L 2 6295 -8730 6310 -8730 {}
L 2 6310 -8740 6310 -8730 {}
L 2 6295 -8690 6310 -8690 {}
L 2 6310 -8690 6310 -8680 {}
L 2 6285 -8725 6285 -8695 {}
L 2 6285 -8710 6285 -8705 {}
L 2 6270 -8710 6277.5 -8710 {}
L 2 6270 -8710 6285 -8710 {}
L 2 6300 -8710 6310 -8710 {}
L 2 6295 -8715 6300 -8710 {}
L 2 6295 -8705 6300 -8710 {}
L 2 6875 -8740 6875 -8680 {}
L 2 6875 -8730 6890 -8730 {}
L 2 6890 -8740 6890 -8730 {}
L 2 6875 -8690 6890 -8690 {}
L 2 6890 -8690 6890 -8680 {}
L 2 6865 -8725 6865 -8695 {}
L 2 6865 -8710 6865 -8705 {}
L 2 6850 -8710 6857.5 -8710 {}
L 2 6850 -8710 6865 -8710 {}
L 2 6880 -8710 6890 -8710 {}
L 2 6875 -8715 6880 -8710 {}
L 2 6875 -8705 6880 -8710 {}
L 2 1255 -8720 1255 -8660 {}
L 2 1255 -8710 1270 -8710 {}
L 2 1270 -8720 1270 -8710 {}
L 2 1255 -8670 1270 -8670 {}
L 2 1270 -8670 1270 -8660 {}
L 2 1245 -8705 1245 -8675 {}
L 2 1245 -8690 1245 -8685 {}
L 2 1230 -8690 1237.5 -8690 {}
L 2 1230 -8690 1245 -8690 {}
L 2 1260 -8690 1270 -8690 {}
L 2 1255 -8695 1260 -8690 {}
L 2 1255 -8685 1260 -8690 {}
L 2 1270 -8760 1270 -8750 {}
L 2 1270 -8760 1277.5 -8762.5 {}
L 2 1262.5 -8767.5 1277.5 -8762.5 {}
L 2 1262.5 -8767.5 1277.5 -8772.5 {}
L 2 1262.5 -8777.5 1277.5 -8772.5 {}
L 2 1262.5 -8777.5 1277.5 -8782.5 {}
L 2 1262.5 -8787.5 1277.5 -8782.5 {}
L 2 1262.5 -8787.5 1277.5 -8792.5 {}
L 2 1262.5 -8797.5 1277.5 -8792.5 {}
L 2 1262.5 -8797.5 1270 -8800 {}
L 2 1270 -8810 1270 -8800 {}
L 2 1272.5 -8802.5 1277.5 -8802.5 {}
L 2 1275 -8805 1275 -8800 {}
L 2 1360 -8685 1360 -8660 {}
L 2 1360 -8720 1360 -8695 {}
L 2 1350 -8695 1370 -8695 {}
L 2 1350 -8685 1370 -8685 {}
L 2 1362.5 -8712.5 1367.5 -8712.5 {}
L 2 1365 -8715 1365 -8710 {}
L 2 1270 -8750 1270 -8720 {}
L 2 1270 -8840 1270 -8810 {}
L 2 1360 -8660 1360 -8580 {}
L 2 1270 -8690 1270 -8580 {}
L 2 1270 -8580 1360 -8580 {}
L 2 7020 -6790 7020 -6690 {}
L 2 6910 -6790 6910 -6690 {}
L 2 7130 -6790 7130 -6690 {}
L 2 6910 -6640 6910 -6630 {}
L 2 6910 -6640 6917.5 -6642.5 {}
L 2 6902.5 -6647.5 6917.5 -6642.5 {}
L 2 6902.5 -6647.5 6917.5 -6652.5 {}
L 2 6902.5 -6657.5 6917.5 -6652.5 {}
L 2 6902.5 -6657.5 6917.5 -6662.5 {}
L 2 6902.5 -6667.5 6917.5 -6662.5 {}
L 2 6902.5 -6667.5 6917.5 -6672.5 {}
L 2 6902.5 -6677.5 6917.5 -6672.5 {}
L 2 6902.5 -6677.5 6910 -6680 {}
L 2 6910 -6690 6910 -6680 {}
L 2 6912.5 -6682.5 6917.5 -6682.5 {}
L 2 6915 -6685 6915 -6680 {}
L 2 7020 -6640 7020 -6630 {}
L 2 7020 -6640 7027.5 -6642.5 {}
L 2 7012.5 -6647.5 7027.5 -6642.5 {}
L 2 7012.5 -6647.5 7027.5 -6652.5 {}
L 2 7012.5 -6657.5 7027.5 -6652.5 {}
L 2 7012.5 -6657.5 7027.5 -6662.5 {}
L 2 7012.5 -6667.5 7027.5 -6662.5 {}
L 2 7012.5 -6667.5 7027.5 -6672.5 {}
L 2 7012.5 -6677.5 7027.5 -6672.5 {}
L 2 7012.5 -6677.5 7020 -6680 {}
L 2 7020 -6690 7020 -6680 {}
L 2 7022.5 -6682.5 7027.5 -6682.5 {}
L 2 7025 -6685 7025 -6680 {}
L 2 7130 -6640 7130 -6630 {}
L 2 7130 -6640 7137.5 -6642.5 {}
L 2 7122.5 -6647.5 7137.5 -6642.5 {}
L 2 7122.5 -6647.5 7137.5 -6652.5 {}
L 2 7122.5 -6657.5 7137.5 -6652.5 {}
L 2 7122.5 -6657.5 7137.5 -6662.5 {}
L 2 7122.5 -6667.5 7137.5 -6662.5 {}
L 2 7122.5 -6667.5 7137.5 -6672.5 {}
L 2 7122.5 -6677.5 7137.5 -6672.5 {}
L 2 7122.5 -6677.5 7130 -6680 {}
L 2 7130 -6690 7130 -6680 {}
L 2 7132.5 -6682.5 7137.5 -6682.5 {}
L 2 7135 -6685 7135 -6680 {}
L 2 7560 -6790 7560 -6740 {}
L 2 7450 -6790 7450 -6740 {}
L 2 7670 -6790 7670 -6740 {}
L 2 7450 -6690 7450 -6680 {}
L 2 7450 -6690 7457.5 -6692.5 {}
L 2 7442.5 -6697.5 7457.5 -6692.5 {}
L 2 7442.5 -6697.5 7457.5 -6702.5 {}
L 2 7442.5 -6707.5 7457.5 -6702.5 {}
L 2 7442.5 -6707.5 7457.5 -6712.5 {}
L 2 7442.5 -6717.5 7457.5 -6712.5 {}
L 2 7442.5 -6717.5 7457.5 -6722.5 {}
L 2 7442.5 -6727.5 7457.5 -6722.5 {}
L 2 7442.5 -6727.5 7450 -6730 {}
L 2 7450 -6740 7450 -6730 {}
L 2 7452.5 -6732.5 7457.5 -6732.5 {}
L 2 7455 -6735 7455 -6730 {}
L 2 7560 -6690 7560 -6680 {}
L 2 7560 -6690 7567.5 -6692.5 {}
L 2 7552.5 -6697.5 7567.5 -6692.5 {}
L 2 7552.5 -6697.5 7567.5 -6702.5 {}
L 2 7552.5 -6707.5 7567.5 -6702.5 {}
L 2 7552.5 -6707.5 7567.5 -6712.5 {}
L 2 7552.5 -6717.5 7567.5 -6712.5 {}
L 2 7552.5 -6717.5 7567.5 -6722.5 {}
L 2 7552.5 -6727.5 7567.5 -6722.5 {}
L 2 7552.5 -6727.5 7560 -6730 {}
L 2 7560 -6740 7560 -6730 {}
L 2 7562.5 -6732.5 7567.5 -6732.5 {}
L 2 7565 -6735 7565 -6730 {}
L 2 7670 -6690 7670 -6680 {}
L 2 7670 -6690 7677.5 -6692.5 {}
L 2 7662.5 -6697.5 7677.5 -6692.5 {}
L 2 7662.5 -6697.5 7677.5 -6702.5 {}
L 2 7662.5 -6707.5 7677.5 -6702.5 {}
L 2 7662.5 -6707.5 7677.5 -6712.5 {}
L 2 7662.5 -6717.5 7677.5 -6712.5 {}
L 2 7662.5 -6717.5 7677.5 -6722.5 {}
L 2 7662.5 -6727.5 7677.5 -6722.5 {}
L 2 7662.5 -6727.5 7670 -6730 {}
L 2 7670 -6740 7670 -6730 {}
L 2 7672.5 -6732.5 7677.5 -6732.5 {}
L 2 7675 -6735 7675 -6730 {}
L 2 7560 -6680 7560 -6600 {}
L 2 7450 -6680 7450 -6600 {}
L 2 7670 -6680 7670 -6600 {}
L 2 6260 -8460 6380 -8460 {}
L 2 6880 -8370 7000 -8370 {}
L 2 6400 -8240 6400 -8120 {}
L 2 6940 -8210 6940 -8090 {}
L 2 7940 -8130 8070 -8130 {}
L 2 5190 -6550 5270 -6380 {}
L 2 4730 -6550 4730 -6380 {}
L 2 7420 -7410 7540 -7410 {}
L 2 6340 -7460 6340 -7450 {}
L 2 6340 -7460 6347.5 -7462.5 {}
L 2 6332.5 -7467.5 6347.5 -7462.5 {}
L 2 6332.5 -7467.5 6347.5 -7472.5 {}
L 2 6332.5 -7477.5 6347.5 -7472.5 {}
L 2 6332.5 -7477.5 6347.5 -7482.5 {}
L 2 6332.5 -7487.5 6347.5 -7482.5 {}
L 2 6332.5 -7487.5 6347.5 -7492.5 {}
L 2 6332.5 -7497.5 6347.5 -7492.5 {}
L 2 6332.5 -7497.5 6340 -7500 {}
L 2 6340 -7510 6340 -7500 {}
L 2 6342.5 -7502.5 6347.5 -7502.5 {}
L 2 6345 -7505 6345 -7500 {}
L 2 6460 -7460 6460 -7450 {}
L 2 6460 -7460 6467.5 -7462.5 {}
L 2 6452.5 -7467.5 6467.5 -7462.5 {}
L 2 6452.5 -7467.5 6467.5 -7472.5 {}
L 2 6452.5 -7477.5 6467.5 -7472.5 {}
L 2 6452.5 -7477.5 6467.5 -7482.5 {}
L 2 6452.5 -7487.5 6467.5 -7482.5 {}
L 2 6452.5 -7487.5 6467.5 -7492.5 {}
L 2 6452.5 -7497.5 6467.5 -7492.5 {}
L 2 6452.5 -7497.5 6460 -7500 {}
L 2 6460 -7510 6460 -7500 {}
L 2 6462.5 -7502.5 6467.5 -7502.5 {}
L 2 6465 -7505 6465 -7500 {}
L 2 6880 -7460 6880 -7450 {}
L 2 6880 -7460 6887.5 -7462.5 {}
L 2 6872.5 -7467.5 6887.5 -7462.5 {}
L 2 6872.5 -7467.5 6887.5 -7472.5 {}
L 2 6872.5 -7477.5 6887.5 -7472.5 {}
L 2 6872.5 -7477.5 6887.5 -7482.5 {}
L 2 6872.5 -7487.5 6887.5 -7482.5 {}
L 2 6872.5 -7487.5 6887.5 -7492.5 {}
L 2 6872.5 -7497.5 6887.5 -7492.5 {}
L 2 6872.5 -7497.5 6880 -7500 {}
L 2 6880 -7510 6880 -7500 {}
L 2 6882.5 -7502.5 6887.5 -7502.5 {}
L 2 6885 -7505 6885 -7500 {}
L 2 7000 -7460 7000 -7450 {}
L 2 7000 -7460 7007.5 -7462.5 {}
L 2 6992.5 -7467.5 7007.5 -7462.5 {}
L 2 6992.5 -7467.5 7007.5 -7472.5 {}
L 2 6992.5 -7477.5 7007.5 -7472.5 {}
L 2 6992.5 -7477.5 7007.5 -7482.5 {}
L 2 6992.5 -7487.5 7007.5 -7482.5 {}
L 2 6992.5 -7487.5 7007.5 -7492.5 {}
L 2 6992.5 -7497.5 7007.5 -7492.5 {}
L 2 6992.5 -7497.5 7000 -7500 {}
L 2 7000 -7510 7000 -7500 {}
L 2 7002.5 -7502.5 7007.5 -7502.5 {}
L 2 7005 -7505 7005 -7500 {}
L 2 7220 -6195 7220 -6170 {}
L 2 7220 -6230 7220 -6205 {}
L 2 7210 -6205 7230 -6205 {}
L 2 7210 -6195 7230 -6195 {}
L 2 7222.5 -6222.5 7227.5 -6222.5 {}
L 2 7225 -6225 7225 -6220 {}
L 2 7220 -6170 7220 -6090 {}
L 2 6890 -6110 6890 -6090 {}
L 2 7130 -6200 7130 -6090 {}
L 2 7130 -6090 7220 -6090 {}
L 2 6890 -6090 7130 -6090 {}
L 2 7130 -6230 7270 -6230 {}
L 2 6400 -7810 6400 -7690 {}
L 2 6860 -7860 6860 -7740 {}
L 2 3890 -8480 3890 -8300 {}
L 2 5350 -8270 5350 -8220 {}
L 2 8020 -7770 8270 -7770 {}
L 2 8090 -6375 8090 -6350 {}
L 2 8090 -6410 8090 -6385 {}
L 2 8080 -6385 8100 -6385 {}
L 2 8080 -6375 8100 -6375 {}
L 2 8092.5 -6402.5 8097.5 -6402.5 {}
L 2 8095 -6405 8095 -6400 {}
L 2 8090 -6350 8090 -6270 {}
L 2 7760 -6290 7760 -6270 {}
L 2 8000 -6380 8000 -6270 {}
L 2 8000 -6270 8090 -6270 {}
L 2 7760 -6270 8000 -6270 {}
L 2 8000 -6410 8140 -6410 {}
L 4 1032.5 -8182.5 1037.5 -8182.5 {}
L 4 1035 -8185 1035 -8180 {}
L 4 1030 -8190 1030 -8130 {}
L 4 1140 -8110 1140 -8097.5 {}
L 4 1135 -8097.5 1145 -8097.5 {}
L 4 1140 -8092.5 1145 -8097.5 {}
L 4 1135 -8097.5 1140 -8092.5 {}
L 4 1140 -8390 1140 -8370 {}
L 4 1130 -8390 1150 -8390 {}
L 4 1572.5 -8182.5 1577.5 -8182.5 {}
L 4 1575 -8185 1575 -8180 {}
L 4 1570 -8190 1570 -8130 {}
L 4 1680 -8110 1680 -8097.5 {}
L 4 1675 -8097.5 1685 -8097.5 {}
L 4 1680 -8092.5 1685 -8097.5 {}
L 4 1675 -8097.5 1680 -8092.5 {}
L 4 1680 -8390 1680 -8370 {}
L 4 1670 -8390 1690 -8390 {}
L 4 502.5 -8182.5 507.5 -8182.5 {}
L 4 505 -8185 505 -8180 {}
L 4 500 -8190 500 -8130 {}
L 4 610 -8110 610 -8097.5 {}
L 4 605 -8097.5 615 -8097.5 {}
L 4 610 -8092.5 615 -8097.5 {}
L 4 605 -8097.5 610 -8092.5 {}
L 4 610 -8390 610 -8370 {}
L 4 600 -8390 620 -8390 {}
L 4 725 -7790 725 -7730 {}
L 4 725 -7780 740 -7780 {}
L 4 740 -7790 740 -7780 {}
L 4 725 -7740 740 -7740 {}
L 4 740 -7740 740 -7730 {}
L 4 715 -7775 715 -7745 {}
L 4 715 -7760 715 -7755 {}
L 4 700 -7760 707.5 -7760 {}
L 4 700 -7760 715 -7760 {}
L 4 730 -7760 740 -7760 {}
L 4 725 -7765 730 -7760 {}
L 4 725 -7755 730 -7760 {}
L 4 740 -7830 740 -7820 {}
L 4 740 -7830 747.5 -7832.5 {}
L 4 732.5 -7837.5 747.5 -7832.5 {}
L 4 732.5 -7837.5 747.5 -7842.5 {}
L 4 732.5 -7847.5 747.5 -7842.5 {}
L 4 732.5 -7847.5 747.5 -7852.5 {}
L 4 732.5 -7857.5 747.5 -7852.5 {}
L 4 732.5 -7857.5 747.5 -7862.5 {}
L 4 732.5 -7867.5 747.5 -7862.5 {}
L 4 732.5 -7867.5 740 -7870 {}
L 4 740 -7880 740 -7870 {}
L 4 742.5 -7872.5 747.5 -7872.5 {}
L 4 745 -7875 745 -7870 {}
L 4 830 -7755 830 -7730 {}
L 4 830 -7790 830 -7765 {}
L 4 820 -7765 840 -7765 {}
L 4 820 -7755 840 -7755 {}
L 4 832.5 -7782.5 837.5 -7782.5 {}
L 4 835 -7785 835 -7780 {}
L 4 502.5 -7722.5 507.5 -7722.5 {}
L 4 505 -7725 505 -7720 {}
L 4 500 -7730 500 -7670 {}
L 4 610 -7650 610 -7637.5 {}
L 4 605 -7637.5 615 -7637.5 {}
L 4 610 -7632.5 615 -7637.5 {}
L 4 605 -7637.5 610 -7632.5 {}
L 4 610 -7930 610 -7910 {}
L 4 600 -7930 620 -7930 {}
L 4 1265 -7790 1265 -7730 {}
L 4 1265 -7780 1280 -7780 {}
L 4 1280 -7790 1280 -7780 {}
L 4 1265 -7740 1280 -7740 {}
L 4 1280 -7740 1280 -7730 {}
L 4 1255 -7775 1255 -7745 {}
L 4 1255 -7760 1255 -7755 {}
L 4 1240 -7760 1247.5 -7760 {}
L 4 1240 -7760 1255 -7760 {}
L 4 1270 -7760 1280 -7760 {}
L 4 1265 -7765 1270 -7760 {}
L 4 1265 -7755 1270 -7760 {}
L 4 1370 -7755 1370 -7730 {}
L 4 1370 -7790 1370 -7765 {}
L 4 1360 -7765 1380 -7765 {}
L 4 1360 -7755 1380 -7755 {}
L 4 1372.5 -7782.5 1377.5 -7782.5 {}
L 4 1375 -7785 1375 -7780 {}
L 4 1042.5 -7722.5 1047.5 -7722.5 {}
L 4 1045 -7725 1045 -7720 {}
L 4 1040 -7730 1040 -7670 {}
L 4 1150 -7650 1150 -7637.5 {}
L 4 1145 -7637.5 1155 -7637.5 {}
L 4 1150 -7632.5 1155 -7637.5 {}
L 4 1145 -7637.5 1150 -7632.5 {}
L 4 1150 -7930 1150 -7910 {}
L 4 1140 -7930 1160 -7930 {}
L 4 725 -6960 725 -6900 {}
L 4 725 -6950 740 -6950 {}
L 4 740 -6960 740 -6950 {}
L 4 725 -6910 740 -6910 {}
L 4 740 -6910 740 -6900 {}
L 4 715 -6945 715 -6915 {}
L 4 715 -6930 715 -6925 {}
L 4 700 -6930 707.5 -6930 {}
L 4 700 -6930 715 -6930 {}
L 4 730 -6930 740 -6930 {}
L 4 725 -6935 730 -6930 {}
L 4 725 -6925 730 -6930 {}
L 4 740 -7000 740 -6990 {}
L 4 740 -7000 747.5 -7002.5 {}
L 4 732.5 -7007.5 747.5 -7002.5 {}
L 4 732.5 -7007.5 747.5 -7012.5 {}
L 4 732.5 -7017.5 747.5 -7012.5 {}
L 4 732.5 -7017.5 747.5 -7022.5 {}
L 4 732.5 -7027.5 747.5 -7022.5 {}
L 4 732.5 -7027.5 747.5 -7032.5 {}
L 4 732.5 -7037.5 747.5 -7032.5 {}
L 4 732.5 -7037.5 740 -7040 {}
L 4 740 -7050 740 -7040 {}
L 4 742.5 -7042.5 747.5 -7042.5 {}
L 4 745 -7045 745 -7040 {}
L 4 830 -6925 830 -6900 {}
L 4 830 -6960 830 -6935 {}
L 4 820 -6935 840 -6935 {}
L 4 820 -6925 840 -6925 {}
L 4 832.5 -6952.5 837.5 -6952.5 {}
L 4 835 -6955 835 -6950 {}
L 4 502.5 -6892.5 507.5 -6892.5 {}
L 4 505 -6895 505 -6890 {}
L 4 500 -6900 500 -6840 {}
L 4 610 -6820 610 -6807.5 {}
L 4 605 -6807.5 615 -6807.5 {}
L 4 610 -6802.5 615 -6807.5 {}
L 4 605 -6807.5 610 -6802.5 {}
L 4 610 -7100 610 -7080 {}
L 4 600 -7100 620 -7100 {}
L 4 1265 -6960 1265 -6900 {}
L 4 1265 -6950 1280 -6950 {}
L 4 1280 -6960 1280 -6950 {}
L 4 1265 -6910 1280 -6910 {}
L 4 1280 -6910 1280 -6900 {}
L 4 1255 -6945 1255 -6915 {}
L 4 1255 -6930 1255 -6925 {}
L 4 1240 -6930 1247.5 -6930 {}
L 4 1240 -6930 1255 -6930 {}
L 4 1270 -6930 1280 -6930 {}
L 4 1265 -6935 1270 -6930 {}
L 4 1265 -6925 1270 -6930 {}
L 4 1370 -6925 1370 -6900 {}
L 4 1370 -6960 1370 -6935 {}
L 4 1360 -6935 1380 -6935 {}
L 4 1360 -6925 1380 -6925 {}
L 4 1372.5 -6952.5 1377.5 -6952.5 {}
L 4 1375 -6955 1375 -6950 {}
L 4 1042.5 -6892.5 1047.5 -6892.5 {}
L 4 1045 -6895 1045 -6890 {}
L 4 1040 -6900 1040 -6840 {}
L 4 1150 -6820 1150 -6807.5 {}
L 4 1145 -6807.5 1155 -6807.5 {}
L 4 1150 -6802.5 1155 -6807.5 {}
L 4 1145 -6807.5 1150 -6802.5 {}
L 4 1150 -7100 1150 -7080 {}
L 4 1140 -7100 1160 -7100 {}
L 4 725 -6470 725 -6410 {}
L 4 725 -6460 740 -6460 {}
L 4 740 -6470 740 -6460 {}
L 4 725 -6420 740 -6420 {}
L 4 740 -6420 740 -6410 {}
L 4 715 -6455 715 -6425 {}
L 4 715 -6440 715 -6435 {}
L 4 700 -6440 707.5 -6440 {}
L 4 700 -6440 715 -6440 {}
L 4 730 -6440 740 -6440 {}
L 4 725 -6445 730 -6440 {}
L 4 725 -6435 730 -6440 {}
L 4 740 -6510 740 -6500 {}
L 4 740 -6510 747.5 -6512.5 {}
L 4 732.5 -6517.5 747.5 -6512.5 {}
L 4 732.5 -6517.5 747.5 -6522.5 {}
L 4 732.5 -6527.5 747.5 -6522.5 {}
L 4 732.5 -6527.5 747.5 -6532.5 {}
L 4 732.5 -6537.5 747.5 -6532.5 {}
L 4 732.5 -6537.5 747.5 -6542.5 {}
L 4 732.5 -6547.5 747.5 -6542.5 {}
L 4 732.5 -6547.5 740 -6550 {}
L 4 740 -6560 740 -6550 {}
L 4 742.5 -6552.5 747.5 -6552.5 {}
L 4 745 -6555 745 -6550 {}
L 4 830 -6435 830 -6410 {}
L 4 830 -6470 830 -6445 {}
L 4 820 -6445 840 -6445 {}
L 4 820 -6435 840 -6435 {}
L 4 832.5 -6462.5 837.5 -6462.5 {}
L 4 835 -6465 835 -6460 {}
L 4 502.5 -6402.5 507.5 -6402.5 {}
L 4 505 -6405 505 -6400 {}
L 4 500 -6410 500 -6350 {}
L 4 610 -6330 610 -6317.5 {}
L 4 605 -6317.5 615 -6317.5 {}
L 4 610 -6312.5 615 -6317.5 {}
L 4 605 -6317.5 610 -6312.5 {}
L 4 610 -6610 610 -6590 {}
L 4 600 -6610 620 -6610 {}
L 4 1265 -6470 1265 -6410 {}
L 4 1265 -6460 1280 -6460 {}
L 4 1280 -6470 1280 -6460 {}
L 4 1265 -6420 1280 -6420 {}
L 4 1280 -6420 1280 -6410 {}
L 4 1255 -6455 1255 -6425 {}
L 4 1255 -6440 1255 -6435 {}
L 4 1240 -6440 1247.5 -6440 {}
L 4 1240 -6440 1255 -6440 {}
L 4 1270 -6440 1280 -6440 {}
L 4 1265 -6445 1270 -6440 {}
L 4 1265 -6435 1270 -6440 {}
L 4 1370 -6435 1370 -6410 {}
L 4 1370 -6470 1370 -6445 {}
L 4 1360 -6445 1380 -6445 {}
L 4 1360 -6435 1380 -6435 {}
L 4 1372.5 -6462.5 1377.5 -6462.5 {}
L 4 1375 -6465 1375 -6460 {}
L 4 1042.5 -6402.5 1047.5 -6402.5 {}
L 4 1045 -6405 1045 -6400 {}
L 4 1040 -6410 1040 -6350 {}
L 4 1150 -6330 1150 -6317.5 {}
L 4 1145 -6317.5 1155 -6317.5 {}
L 4 1150 -6312.5 1155 -6317.5 {}
L 4 1145 -6317.5 1150 -6312.5 {}
L 4 1150 -6610 1150 -6590 {}
L 4 1140 -6610 1160 -6610 {}
L 4 502.5 -5912.5 507.5 -5912.5 {}
L 4 505 -5915 505 -5910 {}
L 4 500 -5920 500 -5860 {}
L 4 610 -5840 610 -5827.5 {}
L 4 605 -5827.5 615 -5827.5 {}
L 4 610 -5822.5 615 -5827.5 {}
L 4 605 -5827.5 610 -5822.5 {}
L 4 610 -6120 610 -6100 {}
L 4 600 -6120 620 -6120 {}
L 4 1692.5 -5912.5 1697.5 -5912.5 {}
L 4 1695 -5915 1695 -5910 {}
L 4 1690 -5920 1690 -5860 {}
L 4 1800 -5840 1800 -5827.5 {}
L 4 1795 -5827.5 1805 -5827.5 {}
L 4 1800 -5822.5 1805 -5827.5 {}
L 4 1795 -5827.5 1800 -5822.5 {}
L 4 1800 -6120 1800 -6100 {}
L 4 1790 -6120 1810 -6120 {}
L 4 1042.5 -5912.5 1047.5 -5912.5 {}
L 4 1045 -5915 1045 -5910 {}
L 4 1040 -5920 1040 -5860 {}
L 4 1150 -5840 1150 -5827.5 {}
L 4 1145 -5827.5 1155 -5827.5 {}
L 4 1150 -5822.5 1155 -5827.5 {}
L 4 1145 -5827.5 1150 -5822.5 {}
L 4 1150 -6120 1150 -6100 {}
L 4 1140 -6120 1160 -6120 {}
L 4 1032.5 -7352.5 1037.5 -7352.5 {}
L 4 1035 -7355 1035 -7350 {}
L 4 1030 -7360 1030 -7300 {}
L 4 1140 -7280 1140 -7267.5 {}
L 4 1135 -7267.5 1145 -7267.5 {}
L 4 1140 -7262.5 1145 -7267.5 {}
L 4 1135 -7267.5 1140 -7262.5 {}
L 4 1140 -7560 1140 -7540 {}
L 4 1130 -7560 1150 -7560 {}
L 4 502.5 -7352.5 507.5 -7352.5 {}
L 4 505 -7355 505 -7350 {}
L 4 500 -7360 500 -7300 {}
L 4 610 -7280 610 -7267.5 {}
L 4 605 -7267.5 615 -7267.5 {}
L 4 610 -7262.5 615 -7267.5 {}
L 4 605 -7267.5 610 -7262.5 {}
L 4 610 -7560 610 -7540 {}
L 4 600 -7560 620 -7560 {}
L 4 1755 -7420 1755 -7360 {}
L 4 1755 -7410 1770 -7410 {}
L 4 1770 -7420 1770 -7410 {}
L 4 1755 -7370 1770 -7370 {}
L 4 1770 -7370 1770 -7360 {}
L 4 1745 -7405 1745 -7375 {}
L 4 1745 -7390 1745 -7385 {}
L 4 1730 -7390 1737.5 -7390 {}
L 4 1730 -7390 1745 -7390 {}
L 4 1760 -7390 1770 -7390 {}
L 4 1755 -7395 1760 -7390 {}
L 4 1755 -7385 1760 -7390 {}
L 4 1770 -7460 1770 -7450 {}
L 4 1770 -7460 1777.5 -7462.5 {}
L 4 1762.5 -7467.5 1777.5 -7462.5 {}
L 4 1762.5 -7467.5 1777.5 -7472.5 {}
L 4 1762.5 -7477.5 1777.5 -7472.5 {}
L 4 1762.5 -7477.5 1777.5 -7482.5 {}
L 4 1762.5 -7487.5 1777.5 -7482.5 {}
L 4 1762.5 -7487.5 1777.5 -7492.5 {}
L 4 1762.5 -7497.5 1777.5 -7492.5 {}
L 4 1762.5 -7497.5 1770 -7500 {}
L 4 1770 -7510 1770 -7500 {}
L 4 1772.5 -7502.5 1777.5 -7502.5 {}
L 4 1775 -7505 1775 -7500 {}
L 4 1860 -7385 1860 -7360 {}
L 4 1860 -7420 1860 -7395 {}
L 4 1850 -7395 1870 -7395 {}
L 4 1850 -7385 1870 -7385 {}
L 4 1862.5 -7412.5 1867.5 -7412.5 {}
L 4 1865 -7415 1865 -7410 {}
L 4 1532.5 -7352.5 1537.5 -7352.5 {}
L 4 1535 -7355 1535 -7350 {}
L 4 1530 -7360 1530 -7300 {}
L 4 1640 -7280 1640 -7267.5 {}
L 4 1635 -7267.5 1645 -7267.5 {}
L 4 1640 -7262.5 1645 -7267.5 {}
L 4 1635 -7267.5 1640 -7262.5 {}
L 4 1640 -7560 1640 -7540 {}
L 4 1630 -7560 1650 -7560 {}
L 4 1680 -8580 1680 -8567.5 {}
L 4 1675 -8567.5 1685 -8567.5 {}
L 4 1680 -8562.5 1685 -8567.5 {}
L 4 1675 -8567.5 1680 -8562.5 {}
L 4 1680 -8860 1680 -8840 {}
L 4 1670 -8860 1690 -8860 {}
L 4 502.5 -8652.5 507.5 -8652.5 {}
L 4 505 -8655 505 -8650 {}
L 4 500 -8660 500 -8600 {}
L 4 610 -8580 610 -8567.5 {}
L 4 605 -8567.5 615 -8567.5 {}
L 4 610 -8562.5 615 -8567.5 {}
L 4 605 -8567.5 610 -8562.5 {}
L 4 610 -8860 610 -8840 {}
L 4 600 -8860 620 -8860 {}
L 4 2140 -8580 2140 -8567.5 {}
L 4 2135 -8567.5 2145 -8567.5 {}
L 4 2140 -8562.5 2145 -8567.5 {}
L 4 2135 -8567.5 2140 -8562.5 {}
L 4 2140 -8860 2140 -8840 {}
L 4 2130 -8860 2150 -8860 {}
L 4 2360 -8685 2360 -8660 {}
L 4 2360 -8720 2360 -8695 {}
L 4 2350 -8695 2370 -8695 {}
L 4 2350 -8685 2370 -8685 {}
L 4 2362.5 -8712.5 2367.5 -8712.5 {}
L 4 2365 -8715 2365 -8710 {}
L 4 3575 -8740 3575 -8680 {}
L 4 3575 -8730 3590 -8730 {}
L 4 3590 -8740 3590 -8730 {}
L 4 3575 -8690 3590 -8690 {}
L 4 3590 -8690 3590 -8680 {}
L 4 3565 -8725 3565 -8695 {}
L 4 3565 -8710 3565 -8705 {}
L 4 3550 -8710 3557.5 -8710 {}
L 4 3550 -8710 3565 -8710 {}
L 4 3580 -8710 3590 -8710 {}
L 4 3575 -8715 3580 -8710 {}
L 4 3575 -8705 3580 -8710 {}
L 4 3590 -8780 3590 -8770 {}
L 4 3590 -8780 3597.5 -8782.5 {}
L 4 3582.5 -8787.5 3597.5 -8782.5 {}
L 4 3582.5 -8787.5 3597.5 -8792.5 {}
L 4 3582.5 -8797.5 3597.5 -8792.5 {}
L 4 3582.5 -8797.5 3597.5 -8802.5 {}
L 4 3582.5 -8807.5 3597.5 -8802.5 {}
L 4 3582.5 -8807.5 3597.5 -8812.5 {}
L 4 3582.5 -8817.5 3597.5 -8812.5 {}
L 4 3582.5 -8817.5 3590 -8820 {}
L 4 3590 -8830 3590 -8820 {}
L 4 3592.5 -8822.5 3597.5 -8822.5 {}
L 4 3595 -8825 3595 -8820 {}
L 4 3680 -8705 3680 -8680 {}
L 4 3680 -8740 3680 -8715 {}
L 4 3670 -8715 3690 -8715 {}
L 4 3670 -8705 3690 -8705 {}
L 4 3682.5 -8732.5 3687.5 -8732.5 {}
L 4 3685 -8735 3685 -8730 {}
L 4 3352.5 -8672.5 3357.5 -8672.5 {}
L 4 3355 -8675 3355 -8670 {}
L 4 3350 -8680 3350 -8620 {}
L 4 3460 -8600 3460 -8587.5 {}
L 4 3455 -8587.5 3465 -8587.5 {}
L 4 3460 -8582.5 3465 -8587.5 {}
L 4 3455 -8587.5 3460 -8582.5 {}
L 4 3460 -8880 3460 -8860 {}
L 4 3450 -8880 3470 -8880 {}
L 4 4115 -8740 4115 -8680 {}
L 4 4115 -8730 4130 -8730 {}
L 4 4130 -8740 4130 -8730 {}
L 4 4115 -8690 4130 -8690 {}
L 4 4130 -8690 4130 -8680 {}
L 4 4105 -8725 4105 -8695 {}
L 4 4105 -8710 4105 -8705 {}
L 4 4090 -8710 4097.5 -8710 {}
L 4 4090 -8710 4105 -8710 {}
L 4 4120 -8710 4130 -8710 {}
L 4 4115 -8715 4120 -8710 {}
L 4 4115 -8705 4120 -8710 {}
L 4 4130 -8780 4130 -8770 {}
L 4 4130 -8780 4137.5 -8782.5 {}
L 4 4122.5 -8787.5 4137.5 -8782.5 {}
L 4 4122.5 -8787.5 4137.5 -8792.5 {}
L 4 4122.5 -8797.5 4137.5 -8792.5 {}
L 4 4122.5 -8797.5 4137.5 -8802.5 {}
L 4 4122.5 -8807.5 4137.5 -8802.5 {}
L 4 4122.5 -8807.5 4137.5 -8812.5 {}
L 4 4122.5 -8817.5 4137.5 -8812.5 {}
L 4 4122.5 -8817.5 4130 -8820 {}
L 4 4130 -8830 4130 -8820 {}
L 4 4132.5 -8822.5 4137.5 -8822.5 {}
L 4 4135 -8825 4135 -8820 {}
L 4 4220 -8705 4220 -8680 {}
L 4 4220 -8740 4220 -8715 {}
L 4 4210 -8715 4230 -8715 {}
L 4 4210 -8705 4230 -8705 {}
L 4 4222.5 -8732.5 4227.5 -8732.5 {}
L 4 4225 -8735 4225 -8730 {}
L 4 3892.5 -8672.5 3897.5 -8672.5 {}
L 4 3895 -8675 3895 -8670 {}
L 4 3890 -8680 3890 -8620 {}
L 4 4000 -8600 4000 -8587.5 {}
L 4 3995 -8587.5 4005 -8587.5 {}
L 4 4000 -8582.5 4005 -8587.5 {}
L 4 3995 -8587.5 4000 -8582.5 {}
L 4 4000 -8880 4000 -8860 {}
L 4 3990 -8880 4010 -8880 {}
L 4 4675 -8740 4675 -8680 {}
L 4 4675 -8730 4690 -8730 {}
L 4 4690 -8740 4690 -8730 {}
L 4 4675 -8690 4690 -8690 {}
L 4 4690 -8690 4690 -8680 {}
L 4 4665 -8725 4665 -8695 {}
L 4 4665 -8710 4665 -8705 {}
L 4 4650 -8710 4657.5 -8710 {}
L 4 4650 -8710 4665 -8710 {}
L 4 4680 -8710 4690 -8710 {}
L 4 4675 -8715 4680 -8710 {}
L 4 4675 -8705 4680 -8710 {}
L 4 4690 -8780 4690 -8770 {}
L 4 4690 -8780 4697.5 -8782.5 {}
L 4 4682.5 -8787.5 4697.5 -8782.5 {}
L 4 4682.5 -8787.5 4697.5 -8792.5 {}
L 4 4682.5 -8797.5 4697.5 -8792.5 {}
L 4 4682.5 -8797.5 4697.5 -8802.5 {}
L 4 4682.5 -8807.5 4697.5 -8802.5 {}
L 4 4682.5 -8807.5 4697.5 -8812.5 {}
L 4 4682.5 -8817.5 4697.5 -8812.5 {}
L 4 4682.5 -8817.5 4690 -8820 {}
L 4 4690 -8830 4690 -8820 {}
L 4 4692.5 -8822.5 4697.5 -8822.5 {}
L 4 4695 -8825 4695 -8820 {}
L 4 4780 -8705 4780 -8680 {}
L 4 4780 -8740 4780 -8715 {}
L 4 4770 -8715 4790 -8715 {}
L 4 4770 -8705 4790 -8705 {}
L 4 4782.5 -8732.5 4787.5 -8732.5 {}
L 4 4785 -8735 4785 -8730 {}
L 4 4452.5 -8672.5 4457.5 -8672.5 {}
L 4 4455 -8675 4455 -8670 {}
L 4 4450 -8680 4450 -8620 {}
L 4 4560 -8600 4560 -8587.5 {}
L 4 4555 -8587.5 4565 -8587.5 {}
L 4 4560 -8582.5 4565 -8587.5 {}
L 4 4555 -8587.5 4560 -8582.5 {}
L 4 4560 -8880 4560 -8860 {}
L 4 4550 -8880 4570 -8880 {}
L 4 5245 -8740 5245 -8680 {}
L 4 5245 -8730 5260 -8730 {}
L 4 5260 -8740 5260 -8730 {}
L 4 5245 -8690 5260 -8690 {}
L 4 5260 -8690 5260 -8680 {}
L 4 5235 -8725 5235 -8695 {}
L 4 5235 -8710 5235 -8705 {}
L 4 5220 -8710 5227.5 -8710 {}
L 4 5220 -8710 5235 -8710 {}
L 4 5250 -8710 5260 -8710 {}
L 4 5245 -8715 5250 -8710 {}
L 4 5245 -8705 5250 -8710 {}
L 4 5260 -8780 5260 -8770 {}
L 4 5260 -8780 5267.5 -8782.5 {}
L 4 5252.5 -8787.5 5267.5 -8782.5 {}
L 4 5252.5 -8787.5 5267.5 -8792.5 {}
L 4 5252.5 -8797.5 5267.5 -8792.5 {}
L 4 5252.5 -8797.5 5267.5 -8802.5 {}
L 4 5252.5 -8807.5 5267.5 -8802.5 {}
L 4 5252.5 -8807.5 5267.5 -8812.5 {}
L 4 5252.5 -8817.5 5267.5 -8812.5 {}
L 4 5252.5 -8817.5 5260 -8820 {}
L 4 5260 -8830 5260 -8820 {}
L 4 5262.5 -8822.5 5267.5 -8822.5 {}
L 4 5265 -8825 5265 -8820 {}
L 4 5350 -8705 5350 -8680 {}
L 4 5350 -8740 5350 -8715 {}
L 4 5340 -8715 5360 -8715 {}
L 4 5340 -8705 5360 -8705 {}
L 4 5352.5 -8732.5 5357.5 -8732.5 {}
L 4 5355 -8735 5355 -8730 {}
L 4 5022.5 -8672.5 5027.5 -8672.5 {}
L 4 5025 -8675 5025 -8670 {}
L 4 5020 -8680 5020 -8620 {}
L 4 5130 -8600 5130 -8587.5 {}
L 4 5125 -8587.5 5135 -8587.5 {}
L 4 5130 -8582.5 5135 -8587.5 {}
L 4 5125 -8587.5 5130 -8582.5 {}
L 4 5130 -8880 5130 -8860 {}
L 4 5120 -8880 5140 -8880 {}
L 4 3575 -7940 3575 -7880 {}
L 4 3575 -7930 3590 -7930 {}
L 4 3590 -7940 3590 -7930 {}
L 4 3575 -7890 3590 -7890 {}
L 4 3590 -7890 3590 -7880 {}
L 4 3565 -7925 3565 -7895 {}
L 4 3565 -7910 3565 -7905 {}
L 4 3550 -7910 3557.5 -7910 {}
L 4 3550 -7910 3565 -7910 {}
L 4 3580 -7910 3590 -7910 {}
L 4 3575 -7915 3580 -7910 {}
L 4 3575 -7905 3580 -7910 {}
L 4 3590 -7980 3590 -7970 {}
L 4 3590 -7980 3597.5 -7982.5 {}
L 4 3582.5 -7987.5 3597.5 -7982.5 {}
L 4 3582.5 -7987.5 3597.5 -7992.5 {}
L 4 3582.5 -7997.5 3597.5 -7992.5 {}
L 4 3582.5 -7997.5 3597.5 -8002.5 {}
L 4 3582.5 -8007.5 3597.5 -8002.5 {}
L 4 3582.5 -8007.5 3597.5 -8012.5 {}
L 4 3582.5 -8017.5 3597.5 -8012.5 {}
L 4 3582.5 -8017.5 3590 -8020 {}
L 4 3590 -8030 3590 -8020 {}
L 4 3592.5 -8022.5 3597.5 -8022.5 {}
L 4 3595 -8025 3595 -8020 {}
L 4 3680 -7905 3680 -7880 {}
L 4 3680 -7940 3680 -7915 {}
L 4 3670 -7915 3690 -7915 {}
L 4 3670 -7905 3690 -7905 {}
L 4 3682.5 -7932.5 3687.5 -7932.5 {}
L 4 3685 -7935 3685 -7930 {}
L 4 3352.5 -7872.5 3357.5 -7872.5 {}
L 4 3355 -7875 3355 -7870 {}
L 4 3350 -7880 3350 -7820 {}
L 4 3460 -7800 3460 -7787.5 {}
L 4 3455 -7787.5 3465 -7787.5 {}
L 4 3460 -7782.5 3465 -7787.5 {}
L 4 3455 -7787.5 3460 -7782.5 {}
L 4 3460 -8080 3460 -8060 {}
L 4 3450 -8080 3470 -8080 {}
L 4 4115 -7940 4115 -7880 {}
L 4 4115 -7930 4130 -7930 {}
L 4 4130 -7940 4130 -7930 {}
L 4 4115 -7890 4130 -7890 {}
L 4 4130 -7890 4130 -7880 {}
L 4 4105 -7925 4105 -7895 {}
L 4 4105 -7910 4105 -7905 {}
L 4 4090 -7910 4097.5 -7910 {}
L 4 4090 -7910 4105 -7910 {}
L 4 4120 -7910 4130 -7910 {}
L 4 4115 -7915 4120 -7910 {}
L 4 4115 -7905 4120 -7910 {}
L 4 4130 -7980 4130 -7970 {}
L 4 4130 -7980 4137.5 -7982.5 {}
L 4 4122.5 -7987.5 4137.5 -7982.5 {}
L 4 4122.5 -7987.5 4137.5 -7992.5 {}
L 4 4122.5 -7997.5 4137.5 -7992.5 {}
L 4 4122.5 -7997.5 4137.5 -8002.5 {}
L 4 4122.5 -8007.5 4137.5 -8002.5 {}
L 4 4122.5 -8007.5 4137.5 -8012.5 {}
L 4 4122.5 -8017.5 4137.5 -8012.5 {}
L 4 4122.5 -8017.5 4130 -8020 {}
L 4 4130 -8030 4130 -8020 {}
L 4 4132.5 -8022.5 4137.5 -8022.5 {}
L 4 4135 -8025 4135 -8020 {}
L 4 4220 -7905 4220 -7880 {}
L 4 4220 -7940 4220 -7915 {}
L 4 4210 -7915 4230 -7915 {}
L 4 4210 -7905 4230 -7905 {}
L 4 4222.5 -7932.5 4227.5 -7932.5 {}
L 4 4225 -7935 4225 -7930 {}
L 4 3892.5 -7872.5 3897.5 -7872.5 {}
L 4 3895 -7875 3895 -7870 {}
L 4 3890 -7880 3890 -7820 {}
L 4 4000 -7800 4000 -7787.5 {}
L 4 3995 -7787.5 4005 -7787.5 {}
L 4 4000 -7782.5 4005 -7787.5 {}
L 4 3995 -7787.5 4000 -7782.5 {}
L 4 4000 -8080 4000 -8060 {}
L 4 3990 -8080 4010 -8080 {}
L 4 5245 -7940 5245 -7880 {}
L 4 5245 -7930 5260 -7930 {}
L 4 5260 -7940 5260 -7930 {}
L 4 5245 -7890 5260 -7890 {}
L 4 5260 -7890 5260 -7880 {}
L 4 5235 -7925 5235 -7895 {}
L 4 5235 -7910 5235 -7905 {}
L 4 5220 -7910 5227.5 -7910 {}
L 4 5220 -7910 5235 -7910 {}
L 4 5250 -7910 5260 -7910 {}
L 4 5245 -7915 5250 -7910 {}
L 4 5245 -7905 5250 -7910 {}
L 4 5260 -7980 5260 -7970 {}
L 4 5260 -7980 5267.5 -7982.5 {}
L 4 5252.5 -7987.5 5267.5 -7982.5 {}
L 4 5252.5 -7987.5 5267.5 -7992.5 {}
L 4 5252.5 -7997.5 5267.5 -7992.5 {}
L 4 5252.5 -7997.5 5267.5 -8002.5 {}
L 4 5252.5 -8007.5 5267.5 -8002.5 {}
L 4 5252.5 -8007.5 5267.5 -8012.5 {}
L 4 5252.5 -8017.5 5267.5 -8012.5 {}
L 4 5252.5 -8017.5 5260 -8020 {}
L 4 5260 -8030 5260 -8020 {}
L 4 5262.5 -8022.5 5267.5 -8022.5 {}
L 4 5265 -8025 5265 -8020 {}
L 4 5350 -7905 5350 -7880 {}
L 4 5350 -7940 5350 -7915 {}
L 4 5340 -7915 5360 -7915 {}
L 4 5340 -7905 5360 -7905 {}
L 4 5352.5 -7932.5 5357.5 -7932.5 {}
L 4 5355 -7935 5355 -7930 {}
L 4 5022.5 -7872.5 5027.5 -7872.5 {}
L 4 5025 -7875 5025 -7870 {}
L 4 5020 -7880 5020 -7820 {}
L 4 5130 -7800 5130 -7787.5 {}
L 4 5125 -7787.5 5135 -7787.5 {}
L 4 5130 -7782.5 5135 -7787.5 {}
L 4 5125 -7787.5 5130 -7782.5 {}
L 4 5130 -8080 5130 -8060 {}
L 4 5120 -8080 5140 -8080 {}
L 4 3575 -8360 3575 -8300 {}
L 4 3575 -8350 3590 -8350 {}
L 4 3590 -8360 3590 -8350 {}
L 4 3575 -8310 3590 -8310 {}
L 4 3590 -8310 3590 -8300 {}
L 4 3565 -8345 3565 -8315 {}
L 4 3565 -8330 3565 -8325 {}
L 4 3550 -8330 3557.5 -8330 {}
L 4 3550 -8330 3565 -8330 {}
L 4 3580 -8330 3590 -8330 {}
L 4 3575 -8335 3580 -8330 {}
L 4 3575 -8325 3580 -8330 {}
L 4 3590 -8400 3590 -8390 {}
L 4 3590 -8400 3597.5 -8402.5 {}
L 4 3582.5 -8407.5 3597.5 -8402.5 {}
L 4 3582.5 -8407.5 3597.5 -8412.5 {}
L 4 3582.5 -8417.5 3597.5 -8412.5 {}
L 4 3582.5 -8417.5 3597.5 -8422.5 {}
L 4 3582.5 -8427.5 3597.5 -8422.5 {}
L 4 3582.5 -8427.5 3597.5 -8432.5 {}
L 4 3582.5 -8437.5 3597.5 -8432.5 {}
L 4 3582.5 -8437.5 3590 -8440 {}
L 4 3590 -8450 3590 -8440 {}
L 4 3592.5 -8442.5 3597.5 -8442.5 {}
L 4 3595 -8445 3595 -8440 {}
L 4 3680 -8325 3680 -8300 {}
L 4 3680 -8360 3680 -8335 {}
L 4 3670 -8335 3690 -8335 {}
L 4 3670 -8325 3690 -8325 {}
L 4 3682.5 -8352.5 3687.5 -8352.5 {}
L 4 3685 -8355 3685 -8350 {}
L 4 3352.5 -8292.5 3357.5 -8292.5 {}
L 4 3355 -8295 3355 -8290 {}
L 4 3350 -8300 3350 -8240 {}
L 4 3460 -8220 3460 -8207.5 {}
L 4 3455 -8207.5 3465 -8207.5 {}
L 4 3460 -8202.5 3465 -8207.5 {}
L 4 3455 -8207.5 3460 -8202.5 {}
L 4 3460 -8500 3460 -8480 {}
L 4 3450 -8500 3470 -8500 {}
L 4 3575 -7530 3575 -7470 {}
L 4 3575 -7520 3590 -7520 {}
L 4 3590 -7530 3590 -7520 {}
L 4 3575 -7480 3590 -7480 {}
L 4 3590 -7480 3590 -7470 {}
L 4 3565 -7515 3565 -7485 {}
L 4 3565 -7500 3565 -7495 {}
L 4 3550 -7500 3557.5 -7500 {}
L 4 3550 -7500 3565 -7500 {}
L 4 3580 -7500 3590 -7500 {}
L 4 3575 -7505 3580 -7500 {}
L 4 3575 -7495 3580 -7500 {}
L 4 3680 -7495 3680 -7470 {}
L 4 3680 -7530 3680 -7505 {}
L 4 3670 -7505 3690 -7505 {}
L 4 3670 -7495 3690 -7495 {}
L 4 3682.5 -7522.5 3687.5 -7522.5 {}
L 4 3685 -7525 3685 -7520 {}
L 4 3352.5 -7462.5 3357.5 -7462.5 {}
L 4 3355 -7465 3355 -7460 {}
L 4 3350 -7470 3350 -7410 {}
L 4 3460 -7390 3460 -7377.5 {}
L 4 3455 -7377.5 3465 -7377.5 {}
L 4 3460 -7372.5 3465 -7377.5 {}
L 4 3455 -7377.5 3460 -7372.5 {}
L 4 4675 -7530 4675 -7470 {}
L 4 4675 -7520 4690 -7520 {}
L 4 4690 -7530 4690 -7520 {}
L 4 4675 -7480 4690 -7480 {}
L 4 4690 -7480 4690 -7470 {}
L 4 4665 -7515 4665 -7485 {}
L 4 4665 -7500 4665 -7495 {}
L 4 4650 -7500 4657.5 -7500 {}
L 4 4650 -7500 4665 -7500 {}
L 4 4680 -7500 4690 -7500 {}
L 4 4675 -7505 4680 -7500 {}
L 4 4675 -7495 4680 -7500 {}
L 4 4780 -7495 4780 -7470 {}
L 4 4780 -7530 4780 -7505 {}
L 4 4770 -7505 4790 -7505 {}
L 4 4770 -7495 4790 -7495 {}
L 4 4782.5 -7522.5 4787.5 -7522.5 {}
L 4 4785 -7525 4785 -7520 {}
L 4 4452.5 -7462.5 4457.5 -7462.5 {}
L 4 4455 -7465 4455 -7460 {}
L 4 4450 -7470 4450 -7410 {}
L 4 4560 -7390 4560 -7377.5 {}
L 4 4555 -7377.5 4565 -7377.5 {}
L 4 4560 -7372.5 4565 -7377.5 {}
L 4 4555 -7377.5 4560 -7372.5 {}
L 4 4115 -7530 4115 -7470 {}
L 4 4115 -7520 4130 -7520 {}
L 4 4130 -7530 4130 -7520 {}
L 4 4115 -7480 4130 -7480 {}
L 4 4130 -7480 4130 -7470 {}
L 4 4105 -7515 4105 -7485 {}
L 4 4105 -7500 4105 -7495 {}
L 4 4090 -7500 4097.5 -7500 {}
L 4 4090 -7500 4105 -7500 {}
L 4 4120 -7500 4130 -7500 {}
L 4 4115 -7505 4120 -7500 {}
L 4 4115 -7495 4120 -7500 {}
L 4 4220 -7495 4220 -7470 {}
L 4 4220 -7530 4220 -7505 {}
L 4 4210 -7505 4230 -7505 {}
L 4 4210 -7495 4230 -7495 {}
L 4 4222.5 -7522.5 4227.5 -7522.5 {}
L 4 4225 -7525 4225 -7520 {}
L 4 3892.5 -7462.5 3897.5 -7462.5 {}
L 4 3895 -7465 3895 -7460 {}
L 4 3890 -7470 3890 -7410 {}
L 4 4000 -7390 4000 -7377.5 {}
L 4 3995 -7377.5 4005 -7377.5 {}
L 4 4000 -7372.5 4005 -7377.5 {}
L 4 3995 -7377.5 4000 -7372.5 {}
L 4 3650 -6710 3650 -6700 {}
L 4 3650 -6710 3657.5 -6712.5 {}
L 4 3642.5 -6717.5 3657.5 -6712.5 {}
L 4 3642.5 -6717.5 3657.5 -6722.5 {}
L 4 3642.5 -6727.5 3657.5 -6722.5 {}
L 4 3642.5 -6727.5 3657.5 -6732.5 {}
L 4 3642.5 -6737.5 3657.5 -6732.5 {}
L 4 3642.5 -6737.5 3657.5 -6742.5 {}
L 4 3642.5 -6747.5 3657.5 -6742.5 {}
L 4 3642.5 -6747.5 3650 -6750 {}
L 4 3650 -6760 3650 -6750 {}
L 4 3652.5 -6752.5 3657.5 -6752.5 {}
L 4 3655 -6755 3655 -6750 {}
L 4 3650 -6650 3650 -6640 {}
L 4 3650 -6650 3657.5 -6652.5 {}
L 4 3642.5 -6657.5 3657.5 -6652.5 {}
L 4 3642.5 -6657.5 3657.5 -6662.5 {}
L 4 3642.5 -6667.5 3657.5 -6662.5 {}
L 4 3642.5 -6667.5 3657.5 -6672.5 {}
L 4 3642.5 -6677.5 3657.5 -6672.5 {}
L 4 3642.5 -6677.5 3657.5 -6682.5 {}
L 4 3642.5 -6687.5 3657.5 -6682.5 {}
L 4 3642.5 -6687.5 3650 -6690 {}
L 4 3650 -6700 3650 -6690 {}
L 4 3652.5 -6692.5 3657.5 -6692.5 {}
L 4 3655 -6695 3655 -6690 {}
L 4 4190 -6650 4190 -6640 {}
L 4 4190 -6650 4197.5 -6652.5 {}
L 4 4182.5 -6657.5 4197.5 -6652.5 {}
L 4 4182.5 -6657.5 4197.5 -6662.5 {}
L 4 4182.5 -6667.5 4197.5 -6662.5 {}
L 4 4182.5 -6667.5 4197.5 -6672.5 {}
L 4 4182.5 -6677.5 4197.5 -6672.5 {}
L 4 4182.5 -6677.5 4197.5 -6682.5 {}
L 4 4182.5 -6687.5 4197.5 -6682.5 {}
L 4 4182.5 -6687.5 4190 -6690 {}
L 4 4190 -6700 4190 -6690 {}
L 4 4192.5 -6692.5 4197.5 -6692.5 {}
L 4 4195 -6695 4195 -6690 {}
L 4 4730 -6750 4730 -6740 {}
L 4 4730 -6750 4737.5 -6752.5 {}
L 4 4722.5 -6757.5 4737.5 -6752.5 {}
L 4 4722.5 -6757.5 4737.5 -6762.5 {}
L 4 4722.5 -6767.5 4737.5 -6762.5 {}
L 4 4722.5 -6767.5 4737.5 -6772.5 {}
L 4 4722.5 -6777.5 4737.5 -6772.5 {}
L 4 4722.5 -6777.5 4737.5 -6782.5 {}
L 4 4722.5 -6787.5 4737.5 -6782.5 {}
L 4 4722.5 -6787.5 4730 -6790 {}
L 4 4730 -6800 4730 -6790 {}
L 4 4732.5 -6792.5 4737.5 -6792.5 {}
L 4 4735 -6795 4735 -6790 {}
L 4 4730 -6650 4730 -6640 {}
L 4 4730 -6650 4737.5 -6652.5 {}
L 4 4722.5 -6657.5 4737.5 -6652.5 {}
L 4 4722.5 -6657.5 4737.5 -6662.5 {}
L 4 4722.5 -6667.5 4737.5 -6662.5 {}
L 4 4722.5 -6667.5 4737.5 -6672.5 {}
L 4 4722.5 -6677.5 4737.5 -6672.5 {}
L 4 4722.5 -6677.5 4737.5 -6682.5 {}
L 4 4722.5 -6687.5 4737.5 -6682.5 {}
L 4 4722.5 -6687.5 4730 -6690 {}
L 4 4730 -6700 4730 -6690 {}
L 4 4732.5 -6692.5 4737.5 -6692.5 {}
L 4 4735 -6695 4735 -6690 {}
L 4 3650 -7030 3650 -7020 {}
L 4 3650 -7030 3657.5 -7032.5 {}
L 4 3642.5 -7037.5 3657.5 -7032.5 {}
L 4 3642.5 -7037.5 3657.5 -7042.5 {}
L 4 3642.5 -7047.5 3657.5 -7042.5 {}
L 4 3642.5 -7047.5 3657.5 -7052.5 {}
L 4 3642.5 -7057.5 3657.5 -7052.5 {}
L 4 3642.5 -7057.5 3657.5 -7062.5 {}
L 4 3642.5 -7067.5 3657.5 -7062.5 {}
L 4 3642.5 -7067.5 3650 -7070 {}
L 4 3650 -7080 3650 -7070 {}
L 4 3652.5 -7072.5 3657.5 -7072.5 {}
L 4 3655 -7075 3655 -7070 {}
L 4 3650 -7090 3650 -7080 {}
L 4 3650 -7090 3657.5 -7092.5 {}
L 4 3642.5 -7097.5 3657.5 -7092.5 {}
L 4 3642.5 -7097.5 3657.5 -7102.5 {}
L 4 3642.5 -7107.5 3657.5 -7102.5 {}
L 4 3642.5 -7107.5 3657.5 -7112.5 {}
L 4 3642.5 -7117.5 3657.5 -7112.5 {}
L 4 3642.5 -7117.5 3657.5 -7122.5 {}
L 4 3642.5 -7127.5 3657.5 -7122.5 {}
L 4 3642.5 -7127.5 3650 -7130 {}
L 4 3650 -7140 3650 -7130 {}
L 4 3652.5 -7132.5 3657.5 -7132.5 {}
L 4 3655 -7135 3655 -7130 {}
L 4 3650 -7150 3650 -7140 {}
L 4 3650 -7150 3657.5 -7152.5 {}
L 4 3642.5 -7157.5 3657.5 -7152.5 {}
L 4 3642.5 -7157.5 3657.5 -7162.5 {}
L 4 3642.5 -7167.5 3657.5 -7162.5 {}
L 4 3642.5 -7167.5 3657.5 -7172.5 {}
L 4 3642.5 -7177.5 3657.5 -7172.5 {}
L 4 3642.5 -7177.5 3657.5 -7182.5 {}
L 4 3642.5 -7187.5 3657.5 -7182.5 {}
L 4 3642.5 -7187.5 3650 -7190 {}
L 4 3650 -7200 3650 -7190 {}
L 4 3652.5 -7192.5 3657.5 -7192.5 {}
L 4 3655 -7195 3655 -7190 {}
L 4 4190 -7030 4190 -7020 {}
L 4 4190 -7030 4197.5 -7032.5 {}
L 4 4182.5 -7037.5 4197.5 -7032.5 {}
L 4 4182.5 -7037.5 4197.5 -7042.5 {}
L 4 4182.5 -7047.5 4197.5 -7042.5 {}
L 4 4182.5 -7047.5 4197.5 -7052.5 {}
L 4 4182.5 -7057.5 4197.5 -7052.5 {}
L 4 4182.5 -7057.5 4197.5 -7062.5 {}
L 4 4182.5 -7067.5 4197.5 -7062.5 {}
L 4 4182.5 -7067.5 4190 -7070 {}
L 4 4190 -7080 4190 -7070 {}
L 4 4192.5 -7072.5 4197.5 -7072.5 {}
L 4 4195 -7075 4195 -7070 {}
L 4 4190 -7150 4197.5 -7152.5 {}
L 4 4182.5 -7157.5 4197.5 -7152.5 {}
L 4 4182.5 -7157.5 4197.5 -7162.5 {}
L 4 4182.5 -7167.5 4197.5 -7162.5 {}
L 4 4182.5 -7167.5 4197.5 -7172.5 {}
L 4 4182.5 -7177.5 4197.5 -7172.5 {}
L 4 4182.5 -7177.5 4197.5 -7182.5 {}
L 4 4182.5 -7187.5 4197.5 -7182.5 {}
L 4 4182.5 -7187.5 4190 -7190 {}
L 4 4190 -7200 4190 -7190 {}
L 4 4192.5 -7192.5 4197.5 -7192.5 {}
L 4 4195 -7195 4195 -7190 {}
L 4 4730 -7030 4730 -7020 {}
L 4 4730 -7030 4737.5 -7032.5 {}
L 4 4722.5 -7037.5 4737.5 -7032.5 {}
L 4 4722.5 -7037.5 4737.5 -7042.5 {}
L 4 4722.5 -7047.5 4737.5 -7042.5 {}
L 4 4722.5 -7047.5 4737.5 -7052.5 {}
L 4 4722.5 -7057.5 4737.5 -7052.5 {}
L 4 4722.5 -7057.5 4737.5 -7062.5 {}
L 4 4722.5 -7067.5 4737.5 -7062.5 {}
L 4 4722.5 -7067.5 4730 -7070 {}
L 4 4730 -7080 4730 -7070 {}
L 4 4732.5 -7072.5 4737.5 -7072.5 {}
L 4 4735 -7075 4735 -7070 {}
L 4 4730 -7150 4730 -7140 {}
L 4 4730 -7150 4737.5 -7152.5 {}
L 4 4722.5 -7157.5 4737.5 -7152.5 {}
L 4 4722.5 -7157.5 4737.5 -7162.5 {}
L 4 4722.5 -7167.5 4737.5 -7162.5 {}
L 4 4722.5 -7167.5 4737.5 -7172.5 {}
L 4 4722.5 -7177.5 4737.5 -7172.5 {}
L 4 4722.5 -7177.5 4737.5 -7182.5 {}
L 4 4722.5 -7187.5 4737.5 -7182.5 {}
L 4 4722.5 -7187.5 4730 -7190 {}
L 4 4730 -7200 4730 -7190 {}
L 4 4732.5 -7192.5 4737.5 -7192.5 {}
L 4 4735 -7195 4735 -7190 {}
L 4 3540 -5880 3540 -5870 {}
L 4 3540 -5880 3547.5 -5882.5 {}
L 4 3532.5 -5887.5 3547.5 -5882.5 {}
L 4 3532.5 -5887.5 3547.5 -5892.5 {}
L 4 3532.5 -5897.5 3547.5 -5892.5 {}
L 4 3532.5 -5897.5 3547.5 -5902.5 {}
L 4 3532.5 -5907.5 3547.5 -5902.5 {}
L 4 3532.5 -5907.5 3547.5 -5912.5 {}
L 4 3532.5 -5917.5 3547.5 -5912.5 {}
L 4 3532.5 -5917.5 3540 -5920 {}
L 4 3540 -5930 3540 -5920 {}
L 4 3542.5 -5922.5 3547.5 -5922.5 {}
L 4 3545 -5925 3545 -5920 {}
L 4 3650 -5880 3650 -5870 {}
L 4 3650 -5880 3657.5 -5882.5 {}
L 4 3642.5 -5887.5 3657.5 -5882.5 {}
L 4 3642.5 -5887.5 3657.5 -5892.5 {}
L 4 3642.5 -5897.5 3657.5 -5892.5 {}
L 4 3642.5 -5897.5 3657.5 -5902.5 {}
L 4 3642.5 -5907.5 3657.5 -5902.5 {}
L 4 3642.5 -5907.5 3657.5 -5912.5 {}
L 4 3642.5 -5917.5 3657.5 -5912.5 {}
L 4 3642.5 -5917.5 3650 -5920 {}
L 4 3650 -5930 3650 -5920 {}
L 4 3652.5 -5922.5 3657.5 -5922.5 {}
L 4 3655 -5925 3655 -5920 {}
L 4 3760 -5880 3760 -5870 {}
L 4 3760 -5880 3767.5 -5882.5 {}
L 4 3752.5 -5887.5 3767.5 -5882.5 {}
L 4 3752.5 -5887.5 3767.5 -5892.5 {}
L 4 3752.5 -5897.5 3767.5 -5892.5 {}
L 4 3752.5 -5897.5 3767.5 -5902.5 {}
L 4 3752.5 -5907.5 3767.5 -5902.5 {}
L 4 3752.5 -5907.5 3767.5 -5912.5 {}
L 4 3752.5 -5917.5 3767.5 -5912.5 {}
L 4 3752.5 -5917.5 3760 -5920 {}
L 4 3760 -5930 3760 -5920 {}
L 4 3762.5 -5922.5 3767.5 -5922.5 {}
L 4 3765 -5925 3765 -5920 {}
L 4 4080 -5880 4080 -5870 {}
L 4 4080 -5880 4087.5 -5882.5 {}
L 4 4072.5 -5887.5 4087.5 -5882.5 {}
L 4 4072.5 -5887.5 4087.5 -5892.5 {}
L 4 4072.5 -5897.5 4087.5 -5892.5 {}
L 4 4072.5 -5897.5 4087.5 -5902.5 {}
L 4 4072.5 -5907.5 4087.5 -5902.5 {}
L 4 4072.5 -5907.5 4087.5 -5912.5 {}
L 4 4072.5 -5917.5 4087.5 -5912.5 {}
L 4 4072.5 -5917.5 4080 -5920 {}
L 4 4080 -5930 4080 -5920 {}
L 4 4082.5 -5922.5 4087.5 -5922.5 {}
L 4 4085 -5925 4085 -5920 {}
L 4 4190 -5880 4190 -5870 {}
L 4 4190 -5880 4197.5 -5882.5 {}
L 4 4182.5 -5887.5 4197.5 -5882.5 {}
L 4 4182.5 -5887.5 4197.5 -5892.5 {}
L 4 4182.5 -5897.5 4197.5 -5892.5 {}
L 4 4182.5 -5897.5 4197.5 -5902.5 {}
L 4 4182.5 -5907.5 4197.5 -5902.5 {}
L 4 4182.5 -5907.5 4197.5 -5912.5 {}
L 4 4182.5 -5917.5 4197.5 -5912.5 {}
L 4 4182.5 -5917.5 4190 -5920 {}
L 4 4190 -5930 4190 -5920 {}
L 4 4192.5 -5922.5 4197.5 -5922.5 {}
L 4 4195 -5925 4195 -5920 {}
L 4 4300 -5880 4300 -5870 {}
L 4 4300 -5880 4307.5 -5882.5 {}
L 4 4292.5 -5887.5 4307.5 -5882.5 {}
L 4 4292.5 -5887.5 4307.5 -5892.5 {}
L 4 4292.5 -5897.5 4307.5 -5892.5 {}
L 4 4292.5 -5897.5 4307.5 -5902.5 {}
L 4 4292.5 -5907.5 4307.5 -5902.5 {}
L 4 4292.5 -5907.5 4307.5 -5912.5 {}
L 4 4292.5 -5917.5 4307.5 -5912.5 {}
L 4 4292.5 -5917.5 4300 -5920 {}
L 4 4300 -5930 4300 -5920 {}
L 4 4302.5 -5922.5 4307.5 -5922.5 {}
L 4 4305 -5925 4305 -5920 {}
L 4 4620 -5880 4620 -5870 {}
L 4 4620 -5880 4627.5 -5882.5 {}
L 4 4612.5 -5887.5 4627.5 -5882.5 {}
L 4 4612.5 -5887.5 4627.5 -5892.5 {}
L 4 4612.5 -5897.5 4627.5 -5892.5 {}
L 4 4612.5 -5897.5 4627.5 -5902.5 {}
L 4 4612.5 -5907.5 4627.5 -5902.5 {}
L 4 4612.5 -5907.5 4627.5 -5912.5 {}
L 4 4612.5 -5917.5 4627.5 -5912.5 {}
L 4 4612.5 -5917.5 4620 -5920 {}
L 4 4620 -5930 4620 -5920 {}
L 4 4622.5 -5922.5 4627.5 -5922.5 {}
L 4 4625 -5925 4625 -5920 {}
L 4 4730 -5880 4730 -5870 {}
L 4 4730 -5880 4737.5 -5882.5 {}
L 4 4722.5 -5887.5 4737.5 -5882.5 {}
L 4 4722.5 -5887.5 4737.5 -5892.5 {}
L 4 4722.5 -5897.5 4737.5 -5892.5 {}
L 4 4722.5 -5897.5 4737.5 -5902.5 {}
L 4 4722.5 -5907.5 4737.5 -5902.5 {}
L 4 4722.5 -5907.5 4737.5 -5912.5 {}
L 4 4722.5 -5917.5 4737.5 -5912.5 {}
L 4 4722.5 -5917.5 4730 -5920 {}
L 4 4730 -5930 4730 -5920 {}
L 4 4732.5 -5922.5 4737.5 -5922.5 {}
L 4 4735 -5925 4735 -5920 {}
L 4 4840 -5880 4840 -5870 {}
L 4 4840 -5880 4847.5 -5882.5 {}
L 4 4832.5 -5887.5 4847.5 -5882.5 {}
L 4 4832.5 -5887.5 4847.5 -5892.5 {}
L 4 4832.5 -5897.5 4847.5 -5892.5 {}
L 4 4832.5 -5897.5 4847.5 -5902.5 {}
L 4 4832.5 -5907.5 4847.5 -5902.5 {}
L 4 4832.5 -5907.5 4847.5 -5912.5 {}
L 4 4832.5 -5917.5 4847.5 -5912.5 {}
L 4 4832.5 -5917.5 4840 -5920 {}
L 4 4840 -5930 4840 -5920 {}
L 4 4842.5 -5922.5 4847.5 -5922.5 {}
L 4 4845 -5925 4845 -5920 {}
L 4 5150 -5880 5150 -5870 {}
L 4 5150 -5880 5157.5 -5882.5 {}
L 4 5142.5 -5887.5 5157.5 -5882.5 {}
L 4 5142.5 -5887.5 5157.5 -5892.5 {}
L 4 5142.5 -5897.5 5157.5 -5892.5 {}
L 4 5142.5 -5897.5 5157.5 -5902.5 {}
L 4 5142.5 -5907.5 5157.5 -5902.5 {}
L 4 5142.5 -5907.5 5157.5 -5912.5 {}
L 4 5142.5 -5917.5 5157.5 -5912.5 {}
L 4 5142.5 -5917.5 5150 -5920 {}
L 4 5150 -5930 5150 -5920 {}
L 4 5152.5 -5922.5 5157.5 -5922.5 {}
L 4 5155 -5925 5155 -5920 {}
L 4 5260 -5880 5260 -5870 {}
L 4 5260 -5880 5267.5 -5882.5 {}
L 4 5252.5 -5887.5 5267.5 -5882.5 {}
L 4 5252.5 -5887.5 5267.5 -5892.5 {}
L 4 5252.5 -5897.5 5267.5 -5892.5 {}
L 4 5252.5 -5897.5 5267.5 -5902.5 {}
L 4 5252.5 -5907.5 5267.5 -5902.5 {}
L 4 5252.5 -5907.5 5267.5 -5912.5 {}
L 4 5252.5 -5917.5 5267.5 -5912.5 {}
L 4 5252.5 -5917.5 5260 -5920 {}
L 4 5260 -5930 5260 -5920 {}
L 4 5262.5 -5922.5 5267.5 -5922.5 {}
L 4 5265 -5925 5265 -5920 {}
L 4 5370 -5880 5370 -5870 {}
L 4 5370 -5880 5377.5 -5882.5 {}
L 4 5362.5 -5887.5 5377.5 -5882.5 {}
L 4 5362.5 -5887.5 5377.5 -5892.5 {}
L 4 5362.5 -5897.5 5377.5 -5892.5 {}
L 4 5362.5 -5897.5 5377.5 -5902.5 {}
L 4 5362.5 -5907.5 5377.5 -5902.5 {}
L 4 5362.5 -5907.5 5377.5 -5912.5 {}
L 4 5362.5 -5917.5 5377.5 -5912.5 {}
L 4 5362.5 -5917.5 5370 -5920 {}
L 4 5370 -5930 5370 -5920 {}
L 4 5372.5 -5922.5 5377.5 -5922.5 {}
L 4 5375 -5925 5375 -5920 {}
L 4 5330 -7030 5330 -7020 {}
L 4 5330 -7030 5337.5 -7032.5 {}
L 4 5322.5 -7037.5 5337.5 -7032.5 {}
L 4 5322.5 -7037.5 5337.5 -7042.5 {}
L 4 5322.5 -7047.5 5337.5 -7042.5 {}
L 4 5322.5 -7047.5 5337.5 -7052.5 {}
L 4 5322.5 -7057.5 5337.5 -7052.5 {}
L 4 5322.5 -7057.5 5337.5 -7062.5 {}
L 4 5322.5 -7067.5 5337.5 -7062.5 {}
L 4 5322.5 -7067.5 5330 -7070 {}
L 4 5330 -7080 5330 -7070 {}
L 4 5332.5 -7072.5 5337.5 -7072.5 {}
L 4 5335 -7075 5335 -7070 {}
L 4 5330 -7150 5330 -7140 {}
L 4 5330 -7150 5337.5 -7152.5 {}
L 4 5322.5 -7157.5 5337.5 -7152.5 {}
L 4 5322.5 -7157.5 5337.5 -7162.5 {}
L 4 5322.5 -7167.5 5337.5 -7162.5 {}
L 4 5322.5 -7167.5 5337.5 -7172.5 {}
L 4 5322.5 -7177.5 5337.5 -7172.5 {}
L 4 5322.5 -7177.5 5337.5 -7182.5 {}
L 4 5322.5 -7187.5 5337.5 -7182.5 {}
L 4 5322.5 -7187.5 5330 -7190 {}
L 4 5330 -7200 5330 -7190 {}
L 4 5332.5 -7192.5 5337.5 -7192.5 {}
L 4 5335 -7195 5335 -7190 {}
L 4 6370 -7020 6370 -7010 {}
L 4 6370 -7020 6377.5 -7022.5 {}
L 4 6362.5 -7027.5 6377.5 -7022.5 {}
L 4 6362.5 -7027.5 6377.5 -7032.5 {}
L 4 6362.5 -7037.5 6377.5 -7032.5 {}
L 4 6362.5 -7037.5 6377.5 -7042.5 {}
L 4 6362.5 -7047.5 6377.5 -7042.5 {}
L 4 6362.5 -7047.5 6377.5 -7052.5 {}
L 4 6362.5 -7057.5 6377.5 -7052.5 {}
L 4 6362.5 -7057.5 6370 -7060 {}
L 4 6370 -7070 6370 -7060 {}
L 4 6372.5 -7062.5 6377.5 -7062.5 {}
L 4 6375 -7065 6375 -7060 {}
L 4 6480 -7020 6480 -7010 {}
L 4 6480 -7020 6487.5 -7022.5 {}
L 4 6472.5 -7027.5 6487.5 -7022.5 {}
L 4 6472.5 -7027.5 6487.5 -7032.5 {}
L 4 6472.5 -7037.5 6487.5 -7032.5 {}
L 4 6472.5 -7037.5 6487.5 -7042.5 {}
L 4 6472.5 -7047.5 6487.5 -7042.5 {}
L 4 6472.5 -7047.5 6487.5 -7052.5 {}
L 4 6472.5 -7057.5 6487.5 -7052.5 {}
L 4 6472.5 -7057.5 6480 -7060 {}
L 4 6480 -7070 6480 -7060 {}
L 4 6482.5 -7062.5 6487.5 -7062.5 {}
L 4 6485 -7065 6485 -7060 {}
L 4 6590 -7020 6590 -7010 {}
L 4 6590 -7020 6597.5 -7022.5 {}
L 4 6582.5 -7027.5 6597.5 -7022.5 {}
L 4 6582.5 -7027.5 6597.5 -7032.5 {}
L 4 6582.5 -7037.5 6597.5 -7032.5 {}
L 4 6582.5 -7037.5 6597.5 -7042.5 {}
L 4 6582.5 -7047.5 6597.5 -7042.5 {}
L 4 6582.5 -7047.5 6597.5 -7052.5 {}
L 4 6582.5 -7057.5 6597.5 -7052.5 {}
L 4 6582.5 -7057.5 6590 -7060 {}
L 4 6590 -7070 6590 -7060 {}
L 4 6592.5 -7062.5 6597.5 -7062.5 {}
L 4 6595 -7065 6595 -7060 {}
L 4 6370 -6930 6370 -6920 {}
L 4 6370 -6930 6377.5 -6932.5 {}
L 4 6362.5 -6937.5 6377.5 -6932.5 {}
L 4 6362.5 -6937.5 6377.5 -6942.5 {}
L 4 6362.5 -6947.5 6377.5 -6942.5 {}
L 4 6362.5 -6947.5 6377.5 -6952.5 {}
L 4 6362.5 -6957.5 6377.5 -6952.5 {}
L 4 6362.5 -6957.5 6377.5 -6962.5 {}
L 4 6362.5 -6967.5 6377.5 -6962.5 {}
L 4 6362.5 -6967.5 6370 -6970 {}
L 4 6370 -6980 6370 -6970 {}
L 4 6372.5 -6972.5 6377.5 -6972.5 {}
L 4 6375 -6975 6375 -6970 {}
L 4 6480 -6930 6480 -6920 {}
L 4 6480 -6930 6487.5 -6932.5 {}
L 4 6472.5 -6937.5 6487.5 -6932.5 {}
L 4 6472.5 -6937.5 6487.5 -6942.5 {}
L 4 6472.5 -6947.5 6487.5 -6942.5 {}
L 4 6472.5 -6947.5 6487.5 -6952.5 {}
L 4 6472.5 -6957.5 6487.5 -6952.5 {}
L 4 6472.5 -6957.5 6487.5 -6962.5 {}
L 4 6472.5 -6967.5 6487.5 -6962.5 {}
L 4 6472.5 -6967.5 6480 -6970 {}
L 4 6480 -6980 6480 -6970 {}
L 4 6482.5 -6972.5 6487.5 -6972.5 {}
L 4 6485 -6975 6485 -6970 {}
L 4 6590 -6930 6590 -6920 {}
L 4 6590 -6930 6597.5 -6932.5 {}
L 4 6582.5 -6937.5 6597.5 -6932.5 {}
L 4 6582.5 -6937.5 6597.5 -6942.5 {}
L 4 6582.5 -6947.5 6597.5 -6942.5 {}
L 4 6582.5 -6947.5 6597.5 -6952.5 {}
L 4 6582.5 -6957.5 6597.5 -6952.5 {}
L 4 6582.5 -6957.5 6597.5 -6962.5 {}
L 4 6582.5 -6967.5 6597.5 -6962.5 {}
L 4 6582.5 -6967.5 6590 -6970 {}
L 4 6590 -6980 6590 -6970 {}
L 4 6592.5 -6972.5 6597.5 -6972.5 {}
L 4 6595 -6975 6595 -6970 {}
L 4 6910 -6930 6910 -6920 {}
L 4 6910 -6930 6917.5 -6932.5 {}
L 4 6902.5 -6937.5 6917.5 -6932.5 {}
L 4 6902.5 -6937.5 6917.5 -6942.5 {}
L 4 6902.5 -6947.5 6917.5 -6942.5 {}
L 4 6902.5 -6947.5 6917.5 -6952.5 {}
L 4 6902.5 -6957.5 6917.5 -6952.5 {}
L 4 6902.5 -6957.5 6917.5 -6962.5 {}
L 4 6902.5 -6967.5 6917.5 -6962.5 {}
L 4 6902.5 -6967.5 6910 -6970 {}
L 4 6910 -6980 6910 -6970 {}
L 4 6912.5 -6972.5 6917.5 -6972.5 {}
L 4 6915 -6975 6915 -6970 {}
L 4 7020 -6930 7020 -6920 {}
L 4 7020 -6930 7027.5 -6932.5 {}
L 4 7012.5 -6937.5 7027.5 -6932.5 {}
L 4 7012.5 -6937.5 7027.5 -6942.5 {}
L 4 7012.5 -6947.5 7027.5 -6942.5 {}
L 4 7012.5 -6947.5 7027.5 -6952.5 {}
L 4 7012.5 -6957.5 7027.5 -6952.5 {}
L 4 7012.5 -6957.5 7027.5 -6962.5 {}
L 4 7012.5 -6967.5 7027.5 -6962.5 {}
L 4 7012.5 -6967.5 7020 -6970 {}
L 4 7020 -6980 7020 -6970 {}
L 4 7022.5 -6972.5 7027.5 -6972.5 {}
L 4 7025 -6975 7025 -6970 {}
L 4 7130 -6930 7130 -6920 {}
L 4 7130 -6930 7137.5 -6932.5 {}
L 4 7122.5 -6937.5 7137.5 -6932.5 {}
L 4 7122.5 -6937.5 7137.5 -6942.5 {}
L 4 7122.5 -6947.5 7137.5 -6942.5 {}
L 4 7122.5 -6947.5 7137.5 -6952.5 {}
L 4 7122.5 -6957.5 7137.5 -6952.5 {}
L 4 7122.5 -6957.5 7137.5 -6962.5 {}
L 4 7122.5 -6967.5 7137.5 -6962.5 {}
L 4 7122.5 -6967.5 7130 -6970 {}
L 4 7130 -6980 7130 -6970 {}
L 4 7132.5 -6972.5 7137.5 -6972.5 {}
L 4 7135 -6975 7135 -6970 {}
L 4 7450 -6930 7450 -6920 {}
L 4 7450 -6930 7457.5 -6932.5 {}
L 4 7442.5 -6937.5 7457.5 -6932.5 {}
L 4 7442.5 -6937.5 7457.5 -6942.5 {}
L 4 7442.5 -6947.5 7457.5 -6942.5 {}
L 4 7442.5 -6947.5 7457.5 -6952.5 {}
L 4 7442.5 -6957.5 7457.5 -6952.5 {}
L 4 7442.5 -6957.5 7457.5 -6962.5 {}
L 4 7442.5 -6967.5 7457.5 -6962.5 {}
L 4 7442.5 -6967.5 7450 -6970 {}
L 4 7450 -6980 7450 -6970 {}
L 4 7452.5 -6972.5 7457.5 -6972.5 {}
L 4 7455 -6975 7455 -6970 {}
L 4 7560 -6930 7560 -6920 {}
L 4 7560 -6930 7567.5 -6932.5 {}
L 4 7552.5 -6937.5 7567.5 -6932.5 {}
L 4 7552.5 -6937.5 7567.5 -6942.5 {}
L 4 7552.5 -6947.5 7567.5 -6942.5 {}
L 4 7552.5 -6947.5 7567.5 -6952.5 {}
L 4 7552.5 -6957.5 7567.5 -6952.5 {}
L 4 7552.5 -6957.5 7567.5 -6962.5 {}
L 4 7552.5 -6967.5 7567.5 -6962.5 {}
L 4 7552.5 -6967.5 7560 -6970 {}
L 4 7560 -6980 7560 -6970 {}
L 4 7562.5 -6972.5 7567.5 -6972.5 {}
L 4 7565 -6975 7565 -6970 {}
L 4 7670 -6930 7670 -6920 {}
L 4 7670 -6930 7677.5 -6932.5 {}
L 4 7662.5 -6937.5 7677.5 -6932.5 {}
L 4 7662.5 -6937.5 7677.5 -6942.5 {}
L 4 7662.5 -6947.5 7677.5 -6942.5 {}
L 4 7662.5 -6947.5 7677.5 -6952.5 {}
L 4 7662.5 -6957.5 7677.5 -6952.5 {}
L 4 7662.5 -6957.5 7677.5 -6962.5 {}
L 4 7662.5 -6967.5 7677.5 -6962.5 {}
L 4 7662.5 -6967.5 7670 -6970 {}
L 4 7670 -6980 7670 -6970 {}
L 4 7672.5 -6972.5 7677.5 -6972.5 {}
L 4 7675 -6975 7675 -6970 {}
L 4 7525 -8740 7525 -8680 {}
L 4 7525 -8730 7540 -8730 {}
L 4 7540 -8740 7540 -8730 {}
L 4 7525 -8690 7540 -8690 {}
L 4 7540 -8690 7540 -8680 {}
L 4 7515 -8725 7515 -8695 {}
L 4 7515 -8710 7515 -8705 {}
L 4 7500 -8710 7507.5 -8710 {}
L 4 7500 -8710 7515 -8710 {}
L 4 7530 -8710 7540 -8710 {}
L 4 7525 -8715 7530 -8710 {}
L 4 7525 -8705 7530 -8710 {}
L 4 1140 -8580 1140 -8567.5 {}
L 4 1135 -8567.5 1145 -8567.5 {}
L 4 1140 -8562.5 1145 -8567.5 {}
L 4 1135 -8567.5 1140 -8562.5 {}
L 4 1140 -8860 1140 -8840 {}
L 4 1130 -8860 1150 -8860 {}
L 4 1032.5 -8652.5 1037.5 -8652.5 {}
L 4 1035 -8655 1035 -8650 {}
L 4 1030 -8660 1030 -8600 {}
L 4 6370 -6640 6370 -6630 {}
L 4 6370 -6640 6377.5 -6642.5 {}
L 4 6362.5 -6647.5 6377.5 -6642.5 {}
L 4 6362.5 -6647.5 6377.5 -6652.5 {}
L 4 6362.5 -6657.5 6377.5 -6652.5 {}
L 4 6362.5 -6657.5 6377.5 -6662.5 {}
L 4 6362.5 -6667.5 6377.5 -6662.5 {}
L 4 6362.5 -6667.5 6377.5 -6672.5 {}
L 4 6362.5 -6677.5 6377.5 -6672.5 {}
L 4 6362.5 -6677.5 6370 -6680 {}
L 4 6370 -6690 6370 -6680 {}
L 4 6372.5 -6682.5 6377.5 -6682.5 {}
L 4 6375 -6685 6375 -6680 {}
L 4 6480 -6640 6480 -6630 {}
L 4 6480 -6640 6487.5 -6642.5 {}
L 4 6472.5 -6647.5 6487.5 -6642.5 {}
L 4 6472.5 -6647.5 6487.5 -6652.5 {}
L 4 6472.5 -6657.5 6487.5 -6652.5 {}
L 4 6472.5 -6657.5 6487.5 -6662.5 {}
L 4 6472.5 -6667.5 6487.5 -6662.5 {}
L 4 6472.5 -6667.5 6487.5 -6672.5 {}
L 4 6472.5 -6677.5 6487.5 -6672.5 {}
L 4 6472.5 -6677.5 6480 -6680 {}
L 4 6480 -6690 6480 -6680 {}
L 4 6482.5 -6682.5 6487.5 -6682.5 {}
L 4 6485 -6685 6485 -6680 {}
L 4 6590 -6640 6590 -6630 {}
L 4 6590 -6640 6597.5 -6642.5 {}
L 4 6582.5 -6647.5 6597.5 -6642.5 {}
L 4 6582.5 -6647.5 6597.5 -6652.5 {}
L 4 6582.5 -6657.5 6597.5 -6652.5 {}
L 4 6582.5 -6657.5 6597.5 -6662.5 {}
L 4 6582.5 -6667.5 6597.5 -6662.5 {}
L 4 6582.5 -6667.5 6597.5 -6672.5 {}
L 4 6582.5 -6677.5 6597.5 -6672.5 {}
L 4 6582.5 -6677.5 6590 -6680 {}
L 4 6590 -6690 6590 -6680 {}
L 4 6592.5 -6682.5 6597.5 -6682.5 {}
L 4 6595 -6685 6595 -6680 {}
L 4 6370 -6580 6370 -6570 {}
L 4 6370 -6580 6377.5 -6582.5 {}
L 4 6362.5 -6587.5 6377.5 -6582.5 {}
L 4 6362.5 -6587.5 6377.5 -6592.5 {}
L 4 6362.5 -6597.5 6377.5 -6592.5 {}
L 4 6362.5 -6597.5 6377.5 -6602.5 {}
L 4 6362.5 -6607.5 6377.5 -6602.5 {}
L 4 6362.5 -6607.5 6377.5 -6612.5 {}
L 4 6362.5 -6617.5 6377.5 -6612.5 {}
L 4 6362.5 -6617.5 6370 -6620 {}
L 4 6370 -6630 6370 -6620 {}
L 4 6372.5 -6622.5 6377.5 -6622.5 {}
L 4 6375 -6625 6375 -6620 {}
L 4 6480 -6580 6480 -6570 {}
L 4 6480 -6580 6487.5 -6582.5 {}
L 4 6472.5 -6587.5 6487.5 -6582.5 {}
L 4 6472.5 -6587.5 6487.5 -6592.5 {}
L 4 6472.5 -6597.5 6487.5 -6592.5 {}
L 4 6472.5 -6597.5 6487.5 -6602.5 {}
L 4 6472.5 -6607.5 6487.5 -6602.5 {}
L 4 6472.5 -6607.5 6487.5 -6612.5 {}
L 4 6472.5 -6617.5 6487.5 -6612.5 {}
L 4 6472.5 -6617.5 6480 -6620 {}
L 4 6480 -6630 6480 -6620 {}
L 4 6482.5 -6622.5 6487.5 -6622.5 {}
L 4 6485 -6625 6485 -6620 {}
L 4 6590 -6580 6590 -6570 {}
L 4 6590 -6580 6597.5 -6582.5 {}
L 4 6582.5 -6587.5 6597.5 -6582.5 {}
L 4 6582.5 -6587.5 6597.5 -6592.5 {}
L 4 6582.5 -6597.5 6597.5 -6592.5 {}
L 4 6582.5 -6597.5 6597.5 -6602.5 {}
L 4 6582.5 -6607.5 6597.5 -6602.5 {}
L 4 6582.5 -6607.5 6597.5 -6612.5 {}
L 4 6582.5 -6617.5 6597.5 -6612.5 {}
L 4 6582.5 -6617.5 6590 -6620 {}
L 4 6590 -6630 6590 -6620 {}
L 4 6592.5 -6622.5 6597.5 -6622.5 {}
L 4 6595 -6625 6595 -6620 {}
L 4 6910 -6580 6910 -6570 {}
L 4 6910 -6580 6917.5 -6582.5 {}
L 4 6902.5 -6587.5 6917.5 -6582.5 {}
L 4 6902.5 -6587.5 6917.5 -6592.5 {}
L 4 6902.5 -6597.5 6917.5 -6592.5 {}
L 4 6902.5 -6597.5 6917.5 -6602.5 {}
L 4 6902.5 -6607.5 6917.5 -6602.5 {}
L 4 6902.5 -6607.5 6917.5 -6612.5 {}
L 4 6902.5 -6617.5 6917.5 -6612.5 {}
L 4 6902.5 -6617.5 6910 -6620 {}
L 4 6910 -6630 6910 -6620 {}
L 4 6912.5 -6622.5 6917.5 -6622.5 {}
L 4 6915 -6625 6915 -6620 {}
L 4 7020 -6580 7020 -6570 {}
L 4 7020 -6580 7027.5 -6582.5 {}
L 4 7012.5 -6587.5 7027.5 -6582.5 {}
L 4 7012.5 -6587.5 7027.5 -6592.5 {}
L 4 7012.5 -6597.5 7027.5 -6592.5 {}
L 4 7012.5 -6597.5 7027.5 -6602.5 {}
L 4 7012.5 -6607.5 7027.5 -6602.5 {}
L 4 7012.5 -6607.5 7027.5 -6612.5 {}
L 4 7012.5 -6617.5 7027.5 -6612.5 {}
L 4 7012.5 -6617.5 7020 -6620 {}
L 4 7020 -6630 7020 -6620 {}
L 4 7022.5 -6622.5 7027.5 -6622.5 {}
L 4 7025 -6625 7025 -6620 {}
L 4 7130 -6580 7130 -6570 {}
L 4 7130 -6580 7137.5 -6582.5 {}
L 4 7122.5 -6587.5 7137.5 -6582.5 {}
L 4 7122.5 -6587.5 7137.5 -6592.5 {}
L 4 7122.5 -6597.5 7137.5 -6592.5 {}
L 4 7122.5 -6597.5 7137.5 -6602.5 {}
L 4 7122.5 -6607.5 7137.5 -6602.5 {}
L 4 7122.5 -6607.5 7137.5 -6612.5 {}
L 4 7122.5 -6617.5 7137.5 -6612.5 {}
L 4 7122.5 -6617.5 7130 -6620 {}
L 4 7130 -6630 7130 -6620 {}
L 4 7132.5 -6622.5 7137.5 -6622.5 {}
L 4 7135 -6625 7135 -6620 {}
L 4 7450 -6550 7450 -6540 {}
L 4 7450 -6550 7457.5 -6552.5 {}
L 4 7442.5 -6557.5 7457.5 -6552.5 {}
L 4 7442.5 -6557.5 7457.5 -6562.5 {}
L 4 7442.5 -6567.5 7457.5 -6562.5 {}
L 4 7442.5 -6567.5 7457.5 -6572.5 {}
L 4 7442.5 -6577.5 7457.5 -6572.5 {}
L 4 7442.5 -6577.5 7457.5 -6582.5 {}
L 4 7442.5 -6587.5 7457.5 -6582.5 {}
L 4 7442.5 -6587.5 7450 -6590 {}
L 4 7450 -6600 7450 -6590 {}
L 4 7452.5 -6592.5 7457.5 -6592.5 {}
L 4 7455 -6595 7455 -6590 {}
L 4 7560 -6550 7560 -6540 {}
L 4 7560 -6550 7567.5 -6552.5 {}
L 4 7552.5 -6557.5 7567.5 -6552.5 {}
L 4 7552.5 -6557.5 7567.5 -6562.5 {}
L 4 7552.5 -6567.5 7567.5 -6562.5 {}
L 4 7552.5 -6567.5 7567.5 -6572.5 {}
L 4 7552.5 -6577.5 7567.5 -6572.5 {}
L 4 7552.5 -6577.5 7567.5 -6582.5 {}
L 4 7552.5 -6587.5 7567.5 -6582.5 {}
L 4 7552.5 -6587.5 7560 -6590 {}
L 4 7560 -6600 7560 -6590 {}
L 4 7562.5 -6592.5 7567.5 -6592.5 {}
L 4 7565 -6595 7565 -6590 {}
L 4 7670 -6550 7670 -6540 {}
L 4 7670 -6550 7677.5 -6552.5 {}
L 4 7662.5 -6557.5 7677.5 -6552.5 {}
L 4 7662.5 -6557.5 7677.5 -6562.5 {}
L 4 7662.5 -6567.5 7677.5 -6562.5 {}
L 4 7662.5 -6567.5 7677.5 -6572.5 {}
L 4 7662.5 -6577.5 7677.5 -6572.5 {}
L 4 7662.5 -6577.5 7677.5 -6582.5 {}
L 4 7662.5 -6587.5 7677.5 -6582.5 {}
L 4 7662.5 -6587.5 7670 -6590 {}
L 4 7670 -6600 7670 -6590 {}
L 4 7672.5 -6592.5 7677.5 -6592.5 {}
L 4 7675 -6595 7675 -6590 {}
L 4 7420 -7330 7420 -7320 {}
L 4 7420 -7330 7427.5 -7332.5 {}
L 4 7412.5 -7337.5 7427.5 -7332.5 {}
L 4 7412.5 -7337.5 7427.5 -7342.5 {}
L 4 7412.5 -7347.5 7427.5 -7342.5 {}
L 4 7412.5 -7347.5 7427.5 -7352.5 {}
L 4 7412.5 -7357.5 7427.5 -7352.5 {}
L 4 7412.5 -7357.5 7427.5 -7362.5 {}
L 4 7412.5 -7367.5 7427.5 -7362.5 {}
L 4 7412.5 -7367.5 7420 -7370 {}
L 4 7420 -7380 7420 -7370 {}
L 4 7422.5 -7372.5 7427.5 -7372.5 {}
L 4 7425 -7375 7425 -7370 {}
L 4 7540 -7330 7540 -7320 {}
L 4 7540 -7330 7547.5 -7332.5 {}
L 4 7532.5 -7337.5 7547.5 -7332.5 {}
L 4 7532.5 -7337.5 7547.5 -7342.5 {}
L 4 7532.5 -7347.5 7547.5 -7342.5 {}
L 4 7532.5 -7347.5 7547.5 -7352.5 {}
L 4 7532.5 -7357.5 7547.5 -7352.5 {}
L 4 7532.5 -7357.5 7547.5 -7362.5 {}
L 4 7532.5 -7367.5 7547.5 -7362.5 {}
L 4 7532.5 -7367.5 7540 -7370 {}
L 4 7540 -7380 7540 -7370 {}
L 4 7542.5 -7372.5 7547.5 -7372.5 {}
L 4 7545 -7375 7545 -7370 {}
L 4 6465 -6230 6465 -6170 {}
L 4 6465 -6220 6480 -6220 {}
L 4 6480 -6230 6480 -6220 {}
L 4 6465 -6180 6480 -6180 {}
L 4 6480 -6180 6480 -6170 {}
L 4 6455 -6215 6455 -6185 {}
L 4 6455 -6200 6455 -6195 {}
L 4 6440 -6200 6447.5 -6200 {}
L 4 6440 -6200 6455 -6200 {}
L 4 6470 -6200 6480 -6200 {}
L 4 6465 -6205 6470 -6200 {}
L 4 6465 -6195 6470 -6200 {}
L 4 6480 -6270 6480 -6260 {}
L 4 6480 -6270 6487.5 -6272.5 {}
L 4 6472.5 -6277.5 6487.5 -6272.5 {}
L 4 6472.5 -6277.5 6487.5 -6282.5 {}
L 4 6472.5 -6287.5 6487.5 -6282.5 {}
L 4 6472.5 -6287.5 6487.5 -6292.5 {}
L 4 6472.5 -6297.5 6487.5 -6292.5 {}
L 4 6472.5 -6297.5 6487.5 -6302.5 {}
L 4 6472.5 -6307.5 6487.5 -6302.5 {}
L 4 6472.5 -6307.5 6480 -6310 {}
L 4 6480 -6320 6480 -6310 {}
L 4 6482.5 -6312.5 6487.5 -6312.5 {}
L 4 6485 -6315 6485 -6310 {}
L 4 6570 -6195 6570 -6170 {}
L 4 6570 -6230 6570 -6205 {}
L 4 6560 -6205 6580 -6205 {}
L 4 6560 -6195 6580 -6195 {}
L 4 6572.5 -6222.5 6577.5 -6222.5 {}
L 4 6575 -6225 6575 -6220 {}
L 4 6242.5 -6162.5 6247.5 -6162.5 {}
L 4 6245 -6165 6245 -6160 {}
L 4 6240 -6170 6240 -6110 {}
L 4 6350 -6090 6350 -6077.5 {}
L 4 6345 -6077.5 6355 -6077.5 {}
L 4 6350 -6072.5 6355 -6077.5 {}
L 4 6345 -6077.5 6350 -6072.5 {}
L 4 6350 -6370 6350 -6350 {}
L 4 6340 -6370 6360 -6370 {}
L 4 7115 -6230 7115 -6170 {}
L 4 7115 -6220 7130 -6220 {}
L 4 7130 -6230 7130 -6220 {}
L 4 7115 -6180 7130 -6180 {}
L 4 7130 -6180 7130 -6170 {}
L 4 7105 -6215 7105 -6185 {}
L 4 7105 -6200 7105 -6195 {}
L 4 7090 -6200 7097.5 -6200 {}
L 4 7090 -6200 7105 -6200 {}
L 4 7120 -6200 7130 -6200 {}
L 4 7115 -6205 7120 -6200 {}
L 4 7115 -6195 7120 -6200 {}
L 4 7130 -6270 7130 -6260 {}
L 4 7130 -6270 7137.5 -6272.5 {}
L 4 7122.5 -6277.5 7137.5 -6272.5 {}
L 4 7122.5 -6277.5 7137.5 -6282.5 {}
L 4 7122.5 -6287.5 7137.5 -6282.5 {}
L 4 7122.5 -6287.5 7137.5 -6292.5 {}
L 4 7122.5 -6297.5 7137.5 -6292.5 {}
L 4 7122.5 -6297.5 7137.5 -6302.5 {}
L 4 7122.5 -6307.5 7137.5 -6302.5 {}
L 4 7122.5 -6307.5 7130 -6310 {}
L 4 7130 -6320 7130 -6310 {}
L 4 7132.5 -6312.5 7137.5 -6312.5 {}
L 4 7135 -6315 7135 -6310 {}
L 4 6892.5 -6162.5 6897.5 -6162.5 {}
L 4 6895 -6165 6895 -6160 {}
L 4 6890 -6170 6890 -6110 {}
L 4 7000 -6090 7000 -6077.5 {}
L 4 6995 -6077.5 7005 -6077.5 {}
L 4 7000 -6072.5 7005 -6077.5 {}
L 4 6995 -6077.5 7000 -6072.5 {}
L 4 7000 -6370 7000 -6350 {}
L 4 6990 -6370 7010 -6370 {}
L 4 4115 -8360 4115 -8300 {}
L 4 4115 -8350 4130 -8350 {}
L 4 4130 -8360 4130 -8350 {}
L 4 4115 -8310 4130 -8310 {}
L 4 4130 -8310 4130 -8300 {}
L 4 4105 -8345 4105 -8315 {}
L 4 4105 -8330 4105 -8325 {}
L 4 4090 -8330 4097.5 -8330 {}
L 4 4090 -8330 4105 -8330 {}
L 4 4120 -8330 4130 -8330 {}
L 4 4115 -8335 4120 -8330 {}
L 4 4115 -8325 4120 -8330 {}
L 4 4130 -8400 4130 -8390 {}
L 4 4130 -8400 4137.5 -8402.5 {}
L 4 4122.5 -8407.5 4137.5 -8402.5 {}
L 4 4122.5 -8407.5 4137.5 -8412.5 {}
L 4 4122.5 -8417.5 4137.5 -8412.5 {}
L 4 4122.5 -8417.5 4137.5 -8422.5 {}
L 4 4122.5 -8427.5 4137.5 -8422.5 {}
L 4 4122.5 -8427.5 4137.5 -8432.5 {}
L 4 4122.5 -8437.5 4137.5 -8432.5 {}
L 4 4122.5 -8437.5 4130 -8440 {}
L 4 4130 -8450 4130 -8440 {}
L 4 4132.5 -8442.5 4137.5 -8442.5 {}
L 4 4135 -8445 4135 -8440 {}
L 4 4220 -8325 4220 -8300 {}
L 4 4220 -8360 4220 -8335 {}
L 4 4210 -8335 4230 -8335 {}
L 4 4210 -8325 4230 -8325 {}
L 4 4222.5 -8352.5 4227.5 -8352.5 {}
L 4 4225 -8355 4225 -8350 {}
L 4 3892.5 -8292.5 3897.5 -8292.5 {}
L 4 3895 -8295 3895 -8290 {}
L 4 3890 -8300 3890 -8240 {}
L 4 4000 -8220 4000 -8207.5 {}
L 4 3995 -8207.5 4005 -8207.5 {}
L 4 4000 -8202.5 4005 -8207.5 {}
L 4 3995 -8207.5 4000 -8202.5 {}
L 4 4000 -8500 4000 -8480 {}
L 4 3990 -8500 4010 -8500 {}
L 4 4675 -8360 4675 -8300 {}
L 4 4675 -8350 4690 -8350 {}
L 4 4690 -8360 4690 -8350 {}
L 4 4675 -8310 4690 -8310 {}
L 4 4690 -8310 4690 -8300 {}
L 4 4665 -8345 4665 -8315 {}
L 4 4665 -8330 4665 -8325 {}
L 4 4650 -8330 4657.5 -8330 {}
L 4 4650 -8330 4665 -8330 {}
L 4 4680 -8330 4690 -8330 {}
L 4 4675 -8335 4680 -8330 {}
L 4 4675 -8325 4680 -8330 {}
L 4 4690 -8400 4690 -8390 {}
L 4 4690 -8400 4697.5 -8402.5 {}
L 4 4682.5 -8407.5 4697.5 -8402.5 {}
L 4 4682.5 -8407.5 4697.5 -8412.5 {}
L 4 4682.5 -8417.5 4697.5 -8412.5 {}
L 4 4682.5 -8417.5 4697.5 -8422.5 {}
L 4 4682.5 -8427.5 4697.5 -8422.5 {}
L 4 4682.5 -8427.5 4697.5 -8432.5 {}
L 4 4682.5 -8437.5 4697.5 -8432.5 {}
L 4 4682.5 -8437.5 4690 -8440 {}
L 4 4690 -8450 4690 -8440 {}
L 4 4692.5 -8442.5 4697.5 -8442.5 {}
L 4 4695 -8445 4695 -8440 {}
L 4 4780 -8325 4780 -8300 {}
L 4 4780 -8360 4780 -8335 {}
L 4 4770 -8335 4790 -8335 {}
L 4 4770 -8325 4790 -8325 {}
L 4 4782.5 -8352.5 4787.5 -8352.5 {}
L 4 4785 -8355 4785 -8350 {}
L 4 4452.5 -8292.5 4457.5 -8292.5 {}
L 4 4455 -8295 4455 -8290 {}
L 4 4450 -8300 4450 -8240 {}
L 4 4560 -8220 4560 -8207.5 {}
L 4 4555 -8207.5 4565 -8207.5 {}
L 4 4560 -8202.5 4565 -8207.5 {}
L 4 4555 -8207.5 4560 -8202.5 {}
L 4 4560 -8500 4560 -8480 {}
L 4 4550 -8500 4570 -8500 {}
L 4 5245 -8360 5245 -8300 {}
L 4 5245 -8350 5260 -8350 {}
L 4 5260 -8360 5260 -8350 {}
L 4 5245 -8310 5260 -8310 {}
L 4 5260 -8310 5260 -8300 {}
L 4 5235 -8345 5235 -8315 {}
L 4 5235 -8330 5235 -8325 {}
L 4 5220 -8330 5227.5 -8330 {}
L 4 5220 -8330 5235 -8330 {}
L 4 5250 -8330 5260 -8330 {}
L 4 5245 -8335 5250 -8330 {}
L 4 5245 -8325 5250 -8330 {}
L 4 5260 -8400 5260 -8390 {}
L 4 5260 -8400 5267.5 -8402.5 {}
L 4 5252.5 -8407.5 5267.5 -8402.5 {}
L 4 5252.5 -8407.5 5267.5 -8412.5 {}
L 4 5252.5 -8417.5 5267.5 -8412.5 {}
L 4 5252.5 -8417.5 5267.5 -8422.5 {}
L 4 5252.5 -8427.5 5267.5 -8422.5 {}
L 4 5252.5 -8427.5 5267.5 -8432.5 {}
L 4 5252.5 -8437.5 5267.5 -8432.5 {}
L 4 5252.5 -8437.5 5260 -8440 {}
L 4 5260 -8450 5260 -8440 {}
L 4 5262.5 -8442.5 5267.5 -8442.5 {}
L 4 5265 -8445 5265 -8440 {}
L 4 5350 -8325 5350 -8300 {}
L 4 5350 -8360 5350 -8335 {}
L 4 5340 -8335 5360 -8335 {}
L 4 5340 -8325 5360 -8325 {}
L 4 5352.5 -8352.5 5357.5 -8352.5 {}
L 4 5355 -8355 5355 -8350 {}
L 4 5022.5 -8292.5 5027.5 -8292.5 {}
L 4 5025 -8295 5025 -8290 {}
L 4 5020 -8300 5020 -8240 {}
L 4 5130 -8220 5130 -8207.5 {}
L 4 5125 -8207.5 5135 -8207.5 {}
L 4 5130 -8202.5 5135 -8207.5 {}
L 4 5125 -8207.5 5130 -8202.5 {}
L 4 5130 -8500 5130 -8480 {}
L 4 5120 -8500 5140 -8500 {}
L 4 7675 -6230 7675 -6170 {}
L 4 7675 -6220 7690 -6220 {}
L 4 7690 -6230 7690 -6220 {}
L 4 7675 -6180 7690 -6180 {}
L 4 7690 -6180 7690 -6170 {}
L 4 7665 -6215 7665 -6185 {}
L 4 7665 -6200 7665 -6195 {}
L 4 7650 -6200 7657.5 -6200 {}
L 4 7650 -6200 7665 -6200 {}
L 4 7680 -6200 7690 -6200 {}
L 4 7675 -6205 7680 -6200 {}
L 4 7675 -6195 7680 -6200 {}
L 4 7690 -6270 7690 -6260 {}
L 4 7690 -6270 7697.5 -6272.5 {}
L 4 7682.5 -6277.5 7697.5 -6272.5 {}
L 4 7682.5 -6277.5 7697.5 -6282.5 {}
L 4 7682.5 -6287.5 7697.5 -6282.5 {}
L 4 7682.5 -6287.5 7697.5 -6292.5 {}
L 4 7682.5 -6297.5 7697.5 -6292.5 {}
L 4 7682.5 -6297.5 7697.5 -6302.5 {}
L 4 7682.5 -6307.5 7697.5 -6302.5 {}
L 4 7682.5 -6307.5 7690 -6310 {}
L 4 7690 -6320 7690 -6310 {}
L 4 7692.5 -6312.5 7697.5 -6312.5 {}
L 4 7695 -6315 7695 -6310 {}
L 4 7452.5 -6162.5 7457.5 -6162.5 {}
L 4 7455 -6165 7455 -6160 {}
L 4 7450 -6170 7450 -6110 {}
L 4 7560 -6090 7560 -6077.5 {}
L 4 7555 -6077.5 7565 -6077.5 {}
L 4 7560 -6072.5 7565 -6077.5 {}
L 4 7555 -6077.5 7560 -6072.5 {}
L 4 7560 -6370 7560 -6350 {}
L 4 7550 -6370 7570 -6370 {}
L 5 1105 -8220 1110 -8220 {}
L 5 1410 -8250 1418.75 -8250 {}
L 5 1645 -8220 1650 -8220 {}
L 5 1950 -8250 1958.75 -8250 {}
L 5 575 -8220 580 -8220 {}
L 5 880 -8250 888.75 -8250 {}
L 5 575 -7760 580 -7760 {}
L 5 880 -7790 888.75 -7790 {}
L 5 1115 -7760 1120 -7760 {}
L 5 1420 -7790 1428.75 -7790 {}
L 5 575 -6930 580 -6930 {}
L 5 880 -6960 888.75 -6960 {}
L 5 1115 -6930 1120 -6930 {}
L 5 1420 -6960 1428.75 -6960 {}
L 5 575 -6440 580 -6440 {}
L 5 880 -6470 888.75 -6470 {}
L 5 1115 -6440 1120 -6440 {}
L 5 1420 -6470 1428.75 -6470 {}
L 5 575 -5950 580 -5950 {}
L 5 1765 -5950 1770 -5950 {}
L 5 1115 -5950 1120 -5950 {}
L 5 1105 -7390 1110 -7390 {}
L 5 1410 -7420 1418.75 -7420 {}
L 5 575 -7390 580 -7390 {}
L 5 880 -7420 888.75 -7420 {}
L 5 1605 -7390 1610 -7390 {}
L 5 1910 -7420 1918.75 -7420 {}
L 5 1645 -8690 1650 -8690 {}
L 5 1950 -8720 1958.75 -8720 {}
L 5 575 -8690 580 -8690 {}
L 5 880 -8720 888.75 -8720 {}
L 5 2105 -8690 2110 -8690 {}
L 5 2410 -8720 2418.75 -8720 {}
L 5 3425 -8710 3430 -8710 {}
L 5 3730 -8740 3738.75 -8740 {}
L 5 3965 -8710 3970 -8710 {}
L 5 4270 -8740 4278.75 -8740 {}
L 5 4525 -8710 4530 -8710 {}
L 5 4830 -8740 4838.75 -8740 {}
L 5 5095 -8710 5100 -8710 {}
L 5 5400 -8740 5408.75 -8740 {}
L 5 3425 -7910 3430 -7910 {}
L 5 3730 -7940 3738.75 -7940 {}
L 5 3965 -7910 3970 -7910 {}
L 5 4270 -7940 4278.75 -7940 {}
L 5 5095 -7910 5100 -7910 {}
L 5 5400 -7940 5408.75 -7940 {}
L 5 3425 -8330 3430 -8330 {}
L 5 3730 -8360 3738.75 -8360 {}
L 5 3425 -7500 3430 -7500 {}
L 5 3730 -7530 3738.75 -7530 {}
L 5 4525 -7500 4530 -7500 {}
L 5 4830 -7530 4838.75 -7530 {}
L 5 3965 -7500 3970 -7500 {}
L 5 4270 -7530 4278.75 -7530 {}
L 5 1105 -8690 1110 -8690 {}
L 5 1410 -8720 1418.75 -8720 {}
L 5 6315 -6200 6320 -6200 {}
L 5 6620 -6230 6628.75 -6230 {}
L 5 6965 -6200 6970 -6200 {}
L 5 7270 -6230 7278.75 -6230 {}
L 5 3965 -8330 3970 -8330 {}
L 5 4270 -8360 4278.75 -8360 {}
L 5 4525 -8330 4530 -8330 {}
L 5 4830 -8360 4838.75 -8360 {}
L 5 5095 -8330 5100 -8330 {}
L 5 5400 -8360 5408.75 -8360 {}
L 5 7525 -6200 7530 -6200 {}
L 5 7830 -6230 7838.75 -6230 {}
L 6 1110 -8220 1230 -8220 {}
L 6 1030 -8370 1270 -8370 {}
L 6 1270 -8250 1410 -8250 {}
L 6 1030 -8130 1030 -8110 {}
L 6 1030 -8370 1030 -8190 {}
L 6 1030 -8110 1270 -8110 {}
L 6 1650 -8220 1770 -8220 {}
L 6 1570 -8370 1810 -8370 {}
L 6 1810 -8250 1950 -8250 {}
L 6 1570 -8130 1570 -8110 {}
L 6 1570 -8370 1570 -8190 {}
L 6 1570 -8110 1810 -8110 {}
L 6 580 -8220 700 -8220 {}
L 6 500 -8370 740 -8370 {}
L 6 740 -8250 880 -8250 {}
L 6 500 -8130 500 -8110 {}
L 6 500 -8370 500 -8190 {}
L 6 500 -8110 740 -8110 {}
L 6 580 -7760 700 -7760 {}
L 6 740 -7820 740 -7790 {}
L 6 740 -7910 740 -7880 {}
L 6 500 -7910 740 -7910 {}
L 6 740 -7790 880 -7790 {}
L 6 830 -7730 830 -7650 {}
L 6 500 -7670 500 -7650 {}
L 6 500 -7910 500 -7730 {}
L 6 740 -7760 740 -7650 {}
L 6 740 -7650 830 -7650 {}
L 6 500 -7650 740 -7650 {}
L 6 1120 -7760 1240 -7760 {}
L 6 1280 -7820 1280 -7790 {}
L 6 1280 -7910 1280 -7880 {}
L 6 1040 -7910 1280 -7910 {}
L 6 1280 -7790 1420 -7790 {}
L 6 1370 -7730 1370 -7650 {}
L 6 1040 -7670 1040 -7650 {}
L 6 1040 -7910 1040 -7730 {}
L 6 1280 -7760 1280 -7650 {}
L 6 1280 -7650 1370 -7650 {}
L 6 1040 -7650 1280 -7650 {}
L 6 580 -6930 700 -6930 {}
L 6 740 -6990 740 -6960 {}
L 6 740 -7080 740 -7050 {}
L 6 500 -7080 740 -7080 {}
L 6 740 -6960 880 -6960 {}
L 6 830 -6900 830 -6820 {}
L 6 500 -6840 500 -6820 {}
L 6 500 -7080 500 -6900 {}
L 6 740 -6930 740 -6820 {}
L 6 740 -6820 830 -6820 {}
L 6 500 -6820 740 -6820 {}
L 6 1120 -6930 1240 -6930 {}
L 6 1280 -6990 1280 -6960 {}
L 6 1280 -7080 1280 -7050 {}
L 6 1040 -7080 1280 -7080 {}
L 6 1280 -6960 1420 -6960 {}
L 6 1370 -6900 1370 -6820 {}
L 6 1040 -6840 1040 -6820 {}
L 6 1040 -7080 1040 -6900 {}
L 6 1280 -6930 1280 -6820 {}
L 6 1280 -6820 1370 -6820 {}
L 6 1040 -6820 1280 -6820 {}
L 6 580 -6440 700 -6440 {}
L 6 740 -6500 740 -6470 {}
L 6 740 -6590 740 -6560 {}
L 6 500 -6590 740 -6590 {}
L 6 740 -6470 880 -6470 {}
L 6 830 -6410 830 -6330 {}
L 6 500 -6350 500 -6330 {}
L 6 500 -6590 500 -6410 {}
L 6 740 -6440 740 -6330 {}
L 6 740 -6330 830 -6330 {}
L 6 500 -6330 740 -6330 {}
L 6 1120 -6440 1240 -6440 {}
L 6 1040 -6590 1280 -6590 {}
L 6 1280 -6470 1420 -6470 {}
L 6 1370 -6410 1370 -6330 {}
L 6 1040 -6350 1040 -6330 {}
L 6 1040 -6590 1040 -6410 {}
L 6 1280 -6440 1280 -6330 {}
L 6 1280 -6330 1370 -6330 {}
L 6 1040 -6330 1280 -6330 {}
L 6 580 -5950 700 -5950 {}
L 6 500 -6100 740 -6100 {}
L 6 500 -5860 500 -5840 {}
L 6 500 -6100 500 -5920 {}
L 6 500 -5840 740 -5840 {}
L 6 1690 -5860 1690 -5840 {}
L 6 1690 -6100 1690 -5920 {}
L 6 1120 -5950 1240 -5950 {}
L 6 1040 -5860 1040 -5840 {}
L 6 1040 -6100 1040 -5920 {}
L 6 1110 -7390 1230 -7390 {}
L 6 1030 -7540 1270 -7540 {}
L 6 1270 -7420 1410 -7420 {}
L 6 1030 -7300 1030 -7280 {}
L 6 1030 -7540 1030 -7360 {}
L 6 1030 -7280 1270 -7280 {}
L 6 580 -7390 700 -7390 {}
L 6 500 -7540 740 -7540 {}
L 6 740 -7420 880 -7420 {}
L 6 500 -7300 500 -7280 {}
L 6 500 -7540 500 -7360 {}
L 6 500 -7280 740 -7280 {}
L 6 1610 -7390 1730 -7390 {}
L 6 1770 -7450 1770 -7420 {}
L 6 1770 -7540 1770 -7510 {}
L 6 1530 -7540 1770 -7540 {}
L 6 1770 -7420 1910 -7420 {}
L 6 1860 -7360 1860 -7280 {}
L 6 1530 -7300 1530 -7280 {}
L 6 1530 -7540 1530 -7360 {}
L 6 1770 -7390 1770 -7280 {}
L 6 1770 -7280 1860 -7280 {}
L 6 1530 -7280 1770 -7280 {}
L 6 1650 -8690 1770 -8690 {}
L 6 1570 -8840 1810 -8840 {}
L 6 1810 -8720 1950 -8720 {}
L 6 1570 -8580 1810 -8580 {}
L 6 580 -8690 700 -8690 {}
L 6 500 -8840 740 -8840 {}
L 6 740 -8720 880 -8720 {}
L 6 500 -8600 500 -8580 {}
L 6 500 -8840 500 -8660 {}
L 6 500 -8580 740 -8580 {}
L 6 2110 -8690 2230 -8690 {}
L 6 2030 -8840 2270 -8840 {}
L 6 2270 -8720 2410 -8720 {}
L 6 2030 -8580 2270 -8580 {}
L 6 2360 -8660 2360 -8580 {}
L 6 3430 -8710 3550 -8710 {}
L 6 3590 -8770 3590 -8740 {}
L 6 3590 -8860 3590 -8830 {}
L 6 3350 -8860 3590 -8860 {}
L 6 3590 -8740 3730 -8740 {}
L 6 3680 -8680 3680 -8600 {}
L 6 3350 -8620 3350 -8600 {}
L 6 3350 -8860 3350 -8680 {}
L 6 3590 -8710 3590 -8600 {}
L 6 3590 -8600 3680 -8600 {}
L 6 3350 -8600 3590 -8600 {}
L 6 3970 -8710 4090 -8710 {}
L 6 4130 -8770 4130 -8740 {}
L 6 4130 -8860 4130 -8830 {}
L 6 3890 -8860 4130 -8860 {}
L 6 4130 -8740 4270 -8740 {}
L 6 4220 -8680 4220 -8600 {}
L 6 3890 -8620 3890 -8600 {}
L 6 3890 -8860 3890 -8680 {}
L 6 4130 -8710 4130 -8600 {}
L 6 4130 -8600 4220 -8600 {}
L 6 3890 -8600 4130 -8600 {}
L 6 4530 -8710 4650 -8710 {}
L 6 4690 -8770 4690 -8740 {}
L 6 4690 -8860 4690 -8830 {}
L 6 4450 -8860 4690 -8860 {}
L 6 4690 -8740 4830 -8740 {}
L 6 4780 -8680 4780 -8600 {}
L 6 4450 -8620 4450 -8600 {}
L 6 4450 -8860 4450 -8680 {}
L 6 4690 -8710 4690 -8600 {}
L 6 4690 -8600 4780 -8600 {}
L 6 4450 -8600 4690 -8600 {}
L 6 5100 -8710 5220 -8710 {}
L 6 5260 -8770 5260 -8740 {}
L 6 5260 -8860 5260 -8830 {}
L 6 5020 -8860 5260 -8860 {}
L 6 5260 -8740 5400 -8740 {}
L 6 5350 -8680 5350 -8600 {}
L 6 5020 -8620 5020 -8600 {}
L 6 5020 -8860 5020 -8680 {}
L 6 5260 -8710 5260 -8600 {}
L 6 5260 -8600 5350 -8600 {}
L 6 5020 -8600 5260 -8600 {}
L 6 3430 -7910 3550 -7910 {}
L 6 3590 -7970 3590 -7940 {}
L 6 3590 -8060 3590 -8030 {}
L 6 3590 -7940 3730 -7940 {}
L 6 3680 -7880 3680 -7800 {}
L 6 3350 -7820 3350 -7800 {}
L 6 3350 -8060 3350 -7880 {}
L 6 3590 -7910 3590 -7800 {}
L 6 3590 -7800 3680 -7800 {}
L 6 3350 -7800 3590 -7800 {}
L 6 3970 -7910 4090 -7910 {}
L 6 4130 -7970 4130 -7940 {}
L 6 4130 -8060 4130 -8030 {}
L 6 4130 -7940 4270 -7940 {}
L 6 4220 -7880 4220 -7800 {}
L 6 3890 -7820 3890 -7800 {}
L 6 3890 -8060 3890 -7880 {}
L 6 4130 -7910 4130 -7800 {}
L 6 4130 -7800 4220 -7800 {}
L 6 3890 -7800 4130 -7800 {}
L 6 5100 -7910 5220 -7910 {}
L 6 5260 -7970 5260 -7940 {}
L 6 5260 -8060 5260 -8030 {}
L 6 5260 -7940 5400 -7940 {}
L 6 5350 -7880 5350 -7800 {}
L 6 5020 -7820 5020 -7800 {}
L 6 5020 -8060 5020 -7880 {}
L 6 5260 -7910 5260 -7800 {}
L 6 5260 -7800 5350 -7800 {}
L 6 5020 -7800 5260 -7800 {}
L 6 3430 -8330 3550 -8330 {}
L 6 3590 -8390 3590 -8360 {}
L 6 3590 -8480 3590 -8450 {}
L 6 3590 -8360 3730 -8360 {}
L 6 3350 -8240 3350 -8220 {}
L 6 3590 -8330 3590 -8220 {}
L 6 3590 -8220 3680 -8220 {}
L 6 3350 -8220 3590 -8220 {}
L 6 3430 -7500 3550 -7500 {}
L 6 3590 -7530 3730 -7530 {}
L 6 3680 -7470 3680 -7390 {}
L 6 3350 -7410 3350 -7390 {}
L 6 3590 -7500 3590 -7390 {}
L 6 3590 -7390 3680 -7390 {}
L 6 3350 -7390 3590 -7390 {}
L 6 4530 -7500 4650 -7500 {}
L 6 4690 -7530 4830 -7530 {}
L 6 4780 -7470 4780 -7390 {}
L 6 4450 -7410 4450 -7390 {}
L 6 4690 -7500 4690 -7390 {}
L 6 4690 -7390 4780 -7390 {}
L 6 4450 -7390 4690 -7390 {}
L 6 3970 -7500 4090 -7500 {}
L 6 4130 -7530 4270 -7530 {}
L 6 4220 -7470 4220 -7390 {}
L 6 3890 -7410 3890 -7390 {}
L 6 4130 -7500 4130 -7390 {}
L 6 4130 -7390 4220 -7390 {}
L 6 3890 -7390 4130 -7390 {}
L 6 6350 -8800 6350 -8620 {}
L 6 6890 -8800 6890 -8620 {}
L 6 7540 -8800 7540 -8740 {}
L 6 7540 -8680 7540 -8620 {}
L 6 1110 -8690 1230 -8690 {}
L 6 1030 -8840 1270 -8840 {}
L 6 1270 -8720 1410 -8720 {}
L 6 1030 -8580 1270 -8580 {}
L 6 1030 -8600 1030 -8580 {}
L 6 1030 -8840 1030 -8660 {}
L 6 6320 -6200 6440 -6200 {}
L 6 6480 -6260 6480 -6230 {}
L 6 6480 -6350 6480 -6320 {}
L 6 6240 -6350 6480 -6350 {}
L 6 6480 -6230 6620 -6230 {}
L 6 6570 -6170 6570 -6090 {}
L 6 6240 -6110 6240 -6090 {}
L 6 6240 -6350 6240 -6170 {}
L 6 6480 -6200 6480 -6090 {}
L 6 6480 -6090 6570 -6090 {}
L 6 6240 -6090 6480 -6090 {}
L 6 6970 -6200 7090 -6200 {}
L 6 7130 -6260 7130 -6230 {}
L 6 7130 -6350 7130 -6320 {}
L 6 6890 -6350 7130 -6350 {}
L 6 6890 -6350 6890 -6170 {}
L 6 3970 -8330 4090 -8330 {}
L 6 4130 -8390 4130 -8360 {}
L 6 4130 -8480 4130 -8450 {}
L 6 4130 -8360 4270 -8360 {}
L 6 3890 -8240 3890 -8220 {}
L 6 4130 -8330 4130 -8220 {}
L 6 4130 -8220 4220 -8220 {}
L 6 3890 -8220 4130 -8220 {}
L 6 4530 -8330 4650 -8330 {}
L 6 4690 -8390 4690 -8360 {}
L 6 4690 -8480 4690 -8450 {}
L 6 4690 -8360 4830 -8360 {}
L 6 4450 -8240 4450 -8220 {}
L 6 4690 -8330 4690 -8220 {}
L 6 4690 -8220 4780 -8220 {}
L 6 4450 -8220 4690 -8220 {}
L 6 5100 -8330 5220 -8330 {}
L 6 5260 -8390 5260 -8360 {}
L 6 5260 -8480 5260 -8450 {}
L 6 5260 -8360 5400 -8360 {}
L 6 5020 -8240 5020 -8220 {}
L 6 5260 -8330 5260 -8220 {}
L 6 5260 -8220 5350 -8220 {}
L 6 5020 -8220 5260 -8220 {}
L 6 7530 -6200 7650 -6200 {}
L 6 7690 -6260 7690 -6230 {}
L 6 7690 -6350 7690 -6320 {}
L 6 7450 -6350 7690 -6350 {}
L 6 7450 -6350 7450 -6170 {}
L 9 0 -5760 2670 -5760 {dash=4}
L 9 0 -6290 2670 -6290 {dash=4}
L 9 0 -6770 2670 -6770 {dash=4}
L 9 0 -7170 2670 -7170 {dash=4}
L 9 0 -8000 2670 -8000 {dash=4}
L 9 0 -7610 2670 -7610 {dash=4}
L 9 0 -8450 2670 -8450 {dash=4}
L 9 2830 -6600 5500 -6600 {dash=4}
L 9 2830 -6980 5500 -6980 {dash=4}
L 9 2830 -7330 5500 -7330 {dash=4}
L 9 2830 -7770 5500 -7770 {dash=4}
L 9 2830 -8190 5500 -8190 {dash=4}
L 9 2830 -8560 5500 -8560 {dash=4}
L 9 2830 -6180 5500 -6180 {dash=4}
L 9 2830 -5800 5500 -5800 {dash=4}
L 9 5660 -6840 8330 -6840 {dash=4}
L 9 5660 -8550 8330 -8550 {dash=4}
L 9 5660 -7610 8330 -7610 {dash=4}
L 9 5660 -7240 8330 -7240 {dash=4}
L 9 5660 -6440 8330 -6440 {dash=4}
L 9 5660 -6010 8330 -6010 {dash=4}
L 9 5660 -8320 8330 -8320 {dash=4}
L 9 5660 -7950 8330 -7950 {dash=4}
B 1 4620 -7970 4650 -7820 {}
B 2 660 -8390 860 -8070 {}
B 2 1267.5 -8252.5 1272.5 -8247.5 {name=d dir=inout}
B 2 1227.5 -8222.5 1232.5 -8217.5 {name=g dir=in}
B 2 1267.5 -8192.5 1272.5 -8187.5 {name=s dir=inout}
B 2 1267.5 -8222.5 1272.5 -8217.5 {name=b dir=in}
B 2 1267.5 -8342.5 1272.5 -8337.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -8282.5 1272.5 -8277.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -8252.5 1362.5 -8247.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -8192.5 1362.5 -8187.5 {name=m dir=inout pinnumber=2}
B 2 2047.5 -8262.5 2052.5 -8257.5 {name=d dir=inout}
B 2 2007.5 -8232.5 2012.5 -8227.5 {name=g dir=in}
B 2 2047.5 -8202.5 2052.5 -8197.5 {name=s dir=inout}
B 2 2047.5 -8232.5 2052.5 -8227.5 {name=b dir=in}
B 2 2047.5 -8352.5 2052.5 -8347.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2047.5 -8292.5 2052.5 -8287.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2137.5 -8262.5 2142.5 -8257.5 {name=p dir=inout pinnumber=1}
B 2 2137.5 -8202.5 2142.5 -8197.5 {name=m dir=inout pinnumber=2}
B 2 1357.5 -7882.5 1362.5 -7877.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -7822.5 1362.5 -7817.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -7052.5 1362.5 -7047.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -6992.5 1362.5 -6987.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -6562.5 1362.5 -6557.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -6502.5 1362.5 -6497.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 660 -6130 900 -5810 {}
B 2 737.5 -8252.5 742.5 -8247.5 {name=d dir=inout}
B 2 737.5 -8192.5 742.5 -8187.5 {name=s dir=inout}
B 2 737.5 -8222.5 742.5 -8217.5 {name=b dir=in}
B 2 737.5 -8342.5 742.5 -8337.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -8282.5 742.5 -8277.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -8252.5 832.5 -8247.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -8192.5 832.5 -8187.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -5982.5 742.5 -5977.5 {name=d dir=inout}
B 2 737.5 -5922.5 742.5 -5917.5 {name=s dir=inout}
B 2 737.5 -5952.5 742.5 -5947.5 {name=b dir=in}
B 2 737.5 -6072.5 742.5 -6067.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -6012.5 742.5 -6007.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -5982.5 832.5 -5977.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -5922.5 832.5 -5917.5 {name=m dir=inout pinnumber=2}
B 2 878.75 -5981.25 881.25 -5978.75 {name=p dir=in}
B 2 1277.5 -5982.5 1282.5 -5977.5 {name=d dir=inout}
B 2 1237.5 -5952.5 1242.5 -5947.5 {name=g dir=in}
B 2 1277.5 -5922.5 1282.5 -5917.5 {name=s dir=inout}
B 2 1277.5 -5952.5 1282.5 -5947.5 {name=b dir=in}
B 2 1277.5 -6072.5 1282.5 -6067.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1277.5 -6012.5 1282.5 -6007.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1367.5 -5982.5 1372.5 -5977.5 {name=p dir=inout pinnumber=1}
B 2 1367.5 -5922.5 1372.5 -5917.5 {name=m dir=inout pinnumber=2}
B 2 1418.75 -5981.25 1421.25 -5978.75 {name=p dir=in}
B 2 2117.5 -5982.5 2122.5 -5977.5 {name=d dir=inout}
B 2 2077.5 -5952.5 2082.5 -5947.5 {name=g dir=in}
B 2 2117.5 -5922.5 2122.5 -5917.5 {name=s dir=inout}
B 2 2117.5 -5952.5 2122.5 -5947.5 {name=b dir=in}
B 2 2117.5 -6072.5 2122.5 -6067.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2117.5 -6012.5 2122.5 -6007.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2207.5 -5982.5 2212.5 -5977.5 {name=p dir=inout pinnumber=1}
B 2 2207.5 -5922.5 2212.5 -5917.5 {name=m dir=inout pinnumber=2}
B 2 2258.75 -5981.25 2261.25 -5978.75 {name=p dir=in}
B 2 660 -7560 860 -7240 {}
B 2 1267.5 -7422.5 1272.5 -7417.5 {name=d dir=inout}
B 2 1227.5 -7392.5 1232.5 -7387.5 {name=g dir=in}
B 2 1267.5 -7362.5 1272.5 -7357.5 {name=s dir=inout}
B 2 1267.5 -7392.5 1272.5 -7387.5 {name=b dir=in}
B 2 1267.5 -7512.5 1272.5 -7507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -7452.5 1272.5 -7447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -7422.5 1362.5 -7417.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -7362.5 1362.5 -7357.5 {name=m dir=inout pinnumber=2}
B 2 2047.5 -7432.5 2052.5 -7427.5 {name=d dir=inout}
B 2 2007.5 -7402.5 2012.5 -7397.5 {name=g dir=in}
B 2 2047.5 -7372.5 2052.5 -7367.5 {name=s dir=inout}
B 2 2047.5 -7402.5 2052.5 -7397.5 {name=b dir=in}
B 2 2047.5 -7522.5 2052.5 -7517.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2047.5 -7462.5 2052.5 -7457.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2137.5 -7432.5 2142.5 -7427.5 {name=p dir=inout pinnumber=1}
B 2 2137.5 -7372.5 2142.5 -7367.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -7422.5 742.5 -7417.5 {name=d dir=inout}
B 2 737.5 -7362.5 742.5 -7357.5 {name=s dir=inout}
B 2 737.5 -7392.5 742.5 -7387.5 {name=b dir=in}
B 2 737.5 -7512.5 742.5 -7507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -7452.5 742.5 -7447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -7422.5 832.5 -7417.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -7362.5 832.5 -7357.5 {name=m dir=inout pinnumber=2}
B 2 660 -8860 860 -8540 {}
B 2 1807.5 -8722.5 1812.5 -8717.5 {name=d dir=inout}
B 2 1767.5 -8692.5 1772.5 -8687.5 {name=g dir=in}
B 2 1807.5 -8662.5 1812.5 -8657.5 {name=s dir=inout}
B 2 1807.5 -8692.5 1812.5 -8687.5 {name=b dir=in}
B 2 1807.5 -8812.5 1812.5 -8807.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1807.5 -8752.5 1812.5 -8747.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -8722.5 1902.5 -8717.5 {name=p dir=inout pinnumber=1}
B 2 1897.5 -8662.5 1902.5 -8657.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -8722.5 742.5 -8717.5 {name=d dir=inout}
B 2 737.5 -8662.5 742.5 -8657.5 {name=s dir=inout}
B 2 737.5 -8692.5 742.5 -8687.5 {name=b dir=in}
B 2 737.5 -8812.5 742.5 -8807.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -8752.5 742.5 -8747.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -8722.5 832.5 -8717.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -8662.5 832.5 -8657.5 {name=m dir=inout pinnumber=2}
B 2 1530 -8850 1610 -8570 {}
B 2 1567.5 -8662.5 1572.5 -8657.5 {name=p dir=inout}
B 2 1567.5 -8602.5 1572.5 -8597.5 {name=m dir=inout}
B 2 2267.5 -8722.5 2272.5 -8717.5 {name=d dir=inout}
B 2 2227.5 -8692.5 2232.5 -8687.5 {name=g dir=in}
B 2 2267.5 -8662.5 2272.5 -8657.5 {name=s dir=inout}
B 2 2267.5 -8692.5 2272.5 -8687.5 {name=b dir=in}
B 2 2267.5 -8812.5 2272.5 -8807.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2267.5 -8752.5 2272.5 -8747.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2027.5 -8662.5 2032.5 -8657.5 {name=p dir=inout}
B 2 2027.5 -8602.5 2032.5 -8597.5 {name=m dir=inout}
B 2 2320 -8740 2390 -8560 {}
B 2 4500 -8000 4650 -7970 {}
B 2 3290 -7690 3630 -7540 {}
B 2 3587.5 -7622.5 3592.5 -7617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 3587.5 -7562.5 3592.5 -7557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 3457.5 -7652.5 3462.5 -7647.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 4687.5 -7652.5 4692.5 -7647.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 4687.5 -7592.5 4692.5 -7587.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 4557.5 -7682.5 4562.5 -7677.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 4127.5 -7622.5 4132.5 -7617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 4127.5 -7562.5 4132.5 -7557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 3997.5 -7652.5 4002.5 -7647.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 4187.5 -6762.5 4192.5 -6757.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 4187.5 -6702.5 4192.5 -6697.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 4187.5 -7082.5 4192.5 -7077.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 4187.5 -7142.5 4192.5 -7137.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 4187.5 -7082.5 4192.5 -7077.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 4187.5 -7142.5 4192.5 -7137.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 4607.5 -7082.5 4612.5 -7077.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 4607.5 -7142.5 4612.5 -7137.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 4040 -6090 4330 -6020 {}
B 2 5207.5 -7082.5 5212.5 -7077.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 5207.5 -7142.5 5212.5 -7137.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 6870 -7080 7160 -7000 {}
B 2 6907.5 -7072.5 6912.5 -7067.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 6907.5 -7012.5 6912.5 -7007.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 7017.5 -7072.5 7022.5 -7067.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 7017.5 -7012.5 7022.5 -7007.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 7127.5 -7072.5 7132.5 -7067.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 7127.5 -7012.5 7132.5 -7007.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 7447.5 -7122.5 7452.5 -7117.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 7447.5 -7062.5 7452.5 -7057.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 7557.5 -7122.5 7562.5 -7117.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 7557.5 -7062.5 7562.5 -7057.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 7667.5 -7122.5 7672.5 -7117.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 7667.5 -7062.5 7672.5 -7057.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 6307.5 -8742.5 6312.5 -8737.5 {name=d dir=inout}
B 2 6267.5 -8712.5 6272.5 -8707.5 {name=g dir=in}
B 2 6307.5 -8682.5 6312.5 -8677.5 {name=s dir=inout}
B 2 6307.5 -8712.5 6312.5 -8707.5 {name=b dir=in}
B 2 6887.5 -8742.5 6892.5 -8737.5 {name=d dir=inout}
B 2 6847.5 -8712.5 6852.5 -8707.5 {name=g dir=in}
B 2 6887.5 -8682.5 6892.5 -8677.5 {name=s dir=inout}
B 2 6887.5 -8712.5 6892.5 -8707.5 {name=b dir=in}
B 2 1267.5 -8722.5 1272.5 -8717.5 {name=d dir=inout}
B 2 1227.5 -8692.5 1232.5 -8687.5 {name=g dir=in}
B 2 1267.5 -8662.5 1272.5 -8657.5 {name=s dir=inout}
B 2 1267.5 -8692.5 1272.5 -8687.5 {name=b dir=in}
B 2 1267.5 -8812.5 1272.5 -8807.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -8752.5 1272.5 -8747.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -8722.5 1362.5 -8717.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -8662.5 1362.5 -8657.5 {name=m dir=inout pinnumber=2}
B 2 6870 -6700 7160 -6620 {}
B 2 6907.5 -6692.5 6912.5 -6687.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 6907.5 -6632.5 6912.5 -6627.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 7017.5 -6692.5 7022.5 -6687.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 7017.5 -6632.5 7022.5 -6627.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 7127.5 -6692.5 7132.5 -6687.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 7127.5 -6632.5 7132.5 -6627.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 7447.5 -6742.5 7452.5 -6737.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 7447.5 -6682.5 7452.5 -6677.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 7557.5 -6742.5 7562.5 -6737.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 7557.5 -6682.5 7562.5 -6677.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 7667.5 -6742.5 7672.5 -6737.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 7667.5 -6682.5 7672.5 -6677.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 6337.5 -7512.5 6342.5 -7507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 6337.5 -7452.5 6342.5 -7447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 6457.5 -7512.5 6462.5 -7507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 6877.5 -7512.5 6882.5 -7507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 6877.5 -7452.5 6882.5 -7447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 6997.5 -7512.5 7002.5 -7507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 6997.5 -7452.5 7002.5 -7447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 7217.5 -6232.5 7222.5 -6227.5 {name=p dir=inout pinnumber=1}
B 2 7217.5 -6172.5 7222.5 -6167.5 {name=m dir=inout pinnumber=2}
B 2 8087.5 -6412.5 8092.5 -6407.5 {name=p dir=inout pinnumber=1}
B 2 8087.5 -6352.5 8092.5 -6347.5 {name=m dir=inout pinnumber=2}
B 5 1027.5 -8192.5 1032.5 -8187.5 {name=p dir=inout}
B 5 1027.5 -8132.5 1032.5 -8127.5 {name=m dir=inout}
B 5 1108.75 -8221.25 1111.25 -8218.75 {name=p dir=out}
B 5 1137.5 -8112.5 1142.5 -8107.5 {name=p dir=inout goto=0}
B 5 1137.5 -8372.5 1142.5 -8367.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -8251.25 1411.25 -8248.75 {name=p dir=in}
B 5 1567.5 -8192.5 1572.5 -8187.5 {name=p dir=inout}
B 5 1567.5 -8132.5 1572.5 -8127.5 {name=m dir=inout}
B 5 1648.75 -8221.25 1651.25 -8218.75 {name=p dir=out}
B 5 1677.5 -8112.5 1682.5 -8107.5 {name=p dir=inout goto=0}
B 5 1677.5 -8372.5 1682.5 -8367.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1948.75 -8251.25 1951.25 -8248.75 {name=p dir=in}
B 5 697.5 -8222.5 702.5 -8217.5 {name=g dir=in}
B 5 497.5 -8192.5 502.5 -8187.5 {name=p dir=inout}
B 5 497.5 -8132.5 502.5 -8127.5 {name=m dir=inout}
B 5 578.75 -8221.25 581.25 -8218.75 {name=p dir=out}
B 5 607.5 -8112.5 612.5 -8107.5 {name=p dir=inout goto=0}
B 5 607.5 -8372.5 612.5 -8367.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -8251.25 881.25 -8248.75 {name=p dir=in}
B 5 737.5 -7792.5 742.5 -7787.5 {name=d dir=inout}
B 5 697.5 -7762.5 702.5 -7757.5 {name=g dir=in}
B 5 737.5 -7732.5 742.5 -7727.5 {name=s dir=inout}
B 5 737.5 -7762.5 742.5 -7757.5 {name=b dir=in}
B 5 737.5 -7882.5 742.5 -7877.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -7822.5 742.5 -7817.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -7792.5 832.5 -7787.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -7732.5 832.5 -7727.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -7732.5 502.5 -7727.5 {name=p dir=inout}
B 5 497.5 -7672.5 502.5 -7667.5 {name=m dir=inout}
B 5 578.75 -7761.25 581.25 -7758.75 {name=p dir=out}
B 5 607.5 -7652.5 612.5 -7647.5 {name=p dir=inout goto=0}
B 5 607.5 -7912.5 612.5 -7907.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -7791.25 881.25 -7788.75 {name=p dir=in}
B 5 1277.5 -7792.5 1282.5 -7787.5 {name=d dir=inout}
B 5 1237.5 -7762.5 1242.5 -7757.5 {name=g dir=in}
B 5 1277.5 -7732.5 1282.5 -7727.5 {name=s dir=inout}
B 5 1277.5 -7762.5 1282.5 -7757.5 {name=b dir=in}
B 5 1367.5 -7792.5 1372.5 -7787.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -7732.5 1372.5 -7727.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -7732.5 1042.5 -7727.5 {name=p dir=inout}
B 5 1037.5 -7672.5 1042.5 -7667.5 {name=m dir=inout}
B 5 1118.75 -7761.25 1121.25 -7758.75 {name=p dir=out}
B 5 1147.5 -7652.5 1152.5 -7647.5 {name=p dir=inout goto=0}
B 5 1147.5 -7912.5 1152.5 -7907.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -7791.25 1421.25 -7788.75 {name=p dir=in}
B 5 737.5 -6962.5 742.5 -6957.5 {name=d dir=inout}
B 5 697.5 -6932.5 702.5 -6927.5 {name=g dir=in}
B 5 737.5 -6902.5 742.5 -6897.5 {name=s dir=inout}
B 5 737.5 -6932.5 742.5 -6927.5 {name=b dir=in}
B 5 737.5 -7052.5 742.5 -7047.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -6992.5 742.5 -6987.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -6962.5 832.5 -6957.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -6902.5 832.5 -6897.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -6902.5 502.5 -6897.5 {name=p dir=inout}
B 5 497.5 -6842.5 502.5 -6837.5 {name=m dir=inout}
B 5 578.75 -6931.25 581.25 -6928.75 {name=p dir=out}
B 5 607.5 -6822.5 612.5 -6817.5 {name=p dir=inout goto=0}
B 5 607.5 -7082.5 612.5 -7077.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -6961.25 881.25 -6958.75 {name=p dir=in}
B 5 1277.5 -6962.5 1282.5 -6957.5 {name=d dir=inout}
B 5 1237.5 -6932.5 1242.5 -6927.5 {name=g dir=in}
B 5 1277.5 -6902.5 1282.5 -6897.5 {name=s dir=inout}
B 5 1277.5 -6932.5 1282.5 -6927.5 {name=b dir=in}
B 5 1367.5 -6962.5 1372.5 -6957.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -6902.5 1372.5 -6897.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -6902.5 1042.5 -6897.5 {name=p dir=inout}
B 5 1037.5 -6842.5 1042.5 -6837.5 {name=m dir=inout}
B 5 1118.75 -6931.25 1121.25 -6928.75 {name=p dir=out}
B 5 1147.5 -6822.5 1152.5 -6817.5 {name=p dir=inout goto=0}
B 5 1147.5 -7082.5 1152.5 -7077.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -6961.25 1421.25 -6958.75 {name=p dir=in}
B 5 737.5 -6472.5 742.5 -6467.5 {name=d dir=inout}
B 5 697.5 -6442.5 702.5 -6437.5 {name=g dir=in}
B 5 737.5 -6412.5 742.5 -6407.5 {name=s dir=inout}
B 5 737.5 -6442.5 742.5 -6437.5 {name=b dir=in}
B 5 737.5 -6562.5 742.5 -6557.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -6502.5 742.5 -6497.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -6472.5 832.5 -6467.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -6412.5 832.5 -6407.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -6412.5 502.5 -6407.5 {name=p dir=inout}
B 5 497.5 -6352.5 502.5 -6347.5 {name=m dir=inout}
B 5 578.75 -6441.25 581.25 -6438.75 {name=p dir=out}
B 5 607.5 -6332.5 612.5 -6327.5 {name=p dir=inout goto=0}
B 5 607.5 -6592.5 612.5 -6587.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -6471.25 881.25 -6468.75 {name=p dir=in}
B 5 1277.5 -6472.5 1282.5 -6467.5 {name=d dir=inout}
B 5 1237.5 -6442.5 1242.5 -6437.5 {name=g dir=in}
B 5 1277.5 -6412.5 1282.5 -6407.5 {name=s dir=inout}
B 5 1277.5 -6442.5 1282.5 -6437.5 {name=b dir=in}
B 5 1367.5 -6472.5 1372.5 -6467.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -6412.5 1372.5 -6407.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -6412.5 1042.5 -6407.5 {name=p dir=inout}
B 5 1037.5 -6352.5 1042.5 -6347.5 {name=m dir=inout}
B 5 1118.75 -6441.25 1121.25 -6438.75 {name=p dir=out}
B 5 1147.5 -6332.5 1152.5 -6327.5 {name=p dir=inout goto=0}
B 5 1147.5 -6592.5 1152.5 -6587.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -6471.25 1421.25 -6468.75 {name=p dir=in}
B 5 697.5 -5952.5 702.5 -5947.5 {name=g dir=in}
B 5 497.5 -5922.5 502.5 -5917.5 {name=p dir=inout}
B 5 497.5 -5862.5 502.5 -5857.5 {name=m dir=inout}
B 5 578.75 -5951.25 581.25 -5948.75 {name=p dir=out}
B 5 607.5 -5842.5 612.5 -5837.5 {name=p dir=inout goto=0}
B 5 607.5 -6102.5 612.5 -6097.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1687.5 -5922.5 1692.5 -5917.5 {name=p dir=inout}
B 5 1687.5 -5862.5 1692.5 -5857.5 {name=m dir=inout}
B 5 1768.75 -5951.25 1771.25 -5948.75 {name=p dir=out}
B 5 1797.5 -5842.5 1802.5 -5837.5 {name=p dir=inout goto=0}
B 5 1797.5 -6102.5 1802.5 -6097.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1037.5 -5922.5 1042.5 -5917.5 {name=p dir=inout}
B 5 1037.5 -5862.5 1042.5 -5857.5 {name=m dir=inout}
B 5 1118.75 -5951.25 1121.25 -5948.75 {name=p dir=out}
B 5 1147.5 -5842.5 1152.5 -5837.5 {name=p dir=inout goto=0}
B 5 1147.5 -6102.5 1152.5 -6097.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1027.5 -7362.5 1032.5 -7357.5 {name=p dir=inout}
B 5 1027.5 -7302.5 1032.5 -7297.5 {name=m dir=inout}
B 5 1108.75 -7391.25 1111.25 -7388.75 {name=p dir=out}
B 5 1137.5 -7282.5 1142.5 -7277.5 {name=p dir=inout goto=0}
B 5 1137.5 -7542.5 1142.5 -7537.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -7421.25 1411.25 -7418.75 {name=p dir=in}
B 5 697.5 -7392.5 702.5 -7387.5 {name=g dir=in}
B 5 497.5 -7362.5 502.5 -7357.5 {name=p dir=inout}
B 5 497.5 -7302.5 502.5 -7297.5 {name=m dir=inout}
B 5 578.75 -7391.25 581.25 -7388.75 {name=p dir=out}
B 5 607.5 -7282.5 612.5 -7277.5 {name=p dir=inout goto=0}
B 5 607.5 -7542.5 612.5 -7537.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -7421.25 881.25 -7418.75 {name=p dir=in}
B 5 1767.5 -7422.5 1772.5 -7417.5 {name=d dir=inout}
B 5 1727.5 -7392.5 1732.5 -7387.5 {name=g dir=in}
B 5 1767.5 -7362.5 1772.5 -7357.5 {name=s dir=inout}
B 5 1767.5 -7392.5 1772.5 -7387.5 {name=b dir=in}
B 5 1767.5 -7512.5 1772.5 -7507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1767.5 -7452.5 1772.5 -7447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1857.5 -7422.5 1862.5 -7417.5 {name=p dir=inout pinnumber=1}
B 5 1857.5 -7362.5 1862.5 -7357.5 {name=m dir=inout pinnumber=2}
B 5 1527.5 -7362.5 1532.5 -7357.5 {name=p dir=inout}
B 5 1527.5 -7302.5 1532.5 -7297.5 {name=m dir=inout}
B 5 1608.75 -7391.25 1611.25 -7388.75 {name=p dir=out}
B 5 1637.5 -7282.5 1642.5 -7277.5 {name=p dir=inout goto=0}
B 5 1637.5 -7542.5 1642.5 -7537.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1908.75 -7421.25 1911.25 -7418.75 {name=p dir=in}
B 5 1648.75 -8691.25 1651.25 -8688.75 {name=p dir=out}
B 5 1677.5 -8582.5 1682.5 -8577.5 {name=p dir=inout goto=0}
B 5 1677.5 -8842.5 1682.5 -8837.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1948.75 -8721.25 1951.25 -8718.75 {name=p dir=in}
B 5 697.5 -8692.5 702.5 -8687.5 {name=g dir=in}
B 5 497.5 -8662.5 502.5 -8657.5 {name=p dir=inout}
B 5 497.5 -8602.5 502.5 -8597.5 {name=m dir=inout}
B 5 578.75 -8691.25 581.25 -8688.75 {name=p dir=out}
B 5 607.5 -8582.5 612.5 -8577.5 {name=p dir=inout goto=0}
B 5 607.5 -8842.5 612.5 -8837.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -8721.25 881.25 -8718.75 {name=p dir=in}
B 5 2108.75 -8691.25 2111.25 -8688.75 {name=p dir=out}
B 5 2137.5 -8582.5 2142.5 -8577.5 {name=p dir=inout goto=0}
B 5 2137.5 -8842.5 2142.5 -8837.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2408.75 -8721.25 2411.25 -8718.75 {name=p dir=in}
B 5 2357.5 -8722.5 2362.5 -8717.5 {name=p dir=inout pinnumber=1}
B 5 2357.5 -8662.5 2362.5 -8657.5 {name=m dir=inout pinnumber=2}
B 5 3587.5 -8742.5 3592.5 -8737.5 {name=d dir=inout}
B 5 3547.5 -8712.5 3552.5 -8707.5 {name=g dir=in}
B 5 3587.5 -8682.5 3592.5 -8677.5 {name=s dir=inout}
B 5 3587.5 -8712.5 3592.5 -8707.5 {name=b dir=in}
B 5 3587.5 -8832.5 3592.5 -8827.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 3587.5 -8772.5 3592.5 -8767.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 3677.5 -8742.5 3682.5 -8737.5 {name=p dir=inout pinnumber=1}
B 5 3677.5 -8682.5 3682.5 -8677.5 {name=m dir=inout pinnumber=2}
B 5 3347.5 -8682.5 3352.5 -8677.5 {name=p dir=inout}
B 5 3347.5 -8622.5 3352.5 -8617.5 {name=m dir=inout}
B 5 3428.75 -8711.25 3431.25 -8708.75 {name=p dir=out}
B 5 3457.5 -8602.5 3462.5 -8597.5 {name=p dir=inout goto=0}
B 5 3457.5 -8862.5 3462.5 -8857.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 3728.75 -8741.25 3731.25 -8738.75 {name=p dir=in}
B 5 4127.5 -8742.5 4132.5 -8737.5 {name=d dir=inout}
B 5 4087.5 -8712.5 4092.5 -8707.5 {name=g dir=in}
B 5 4127.5 -8682.5 4132.5 -8677.5 {name=s dir=inout}
B 5 4127.5 -8712.5 4132.5 -8707.5 {name=b dir=in}
B 5 4127.5 -8832.5 4132.5 -8827.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 4127.5 -8772.5 4132.5 -8767.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 4217.5 -8742.5 4222.5 -8737.5 {name=p dir=inout pinnumber=1}
B 5 4217.5 -8682.5 4222.5 -8677.5 {name=m dir=inout pinnumber=2}
B 5 3887.5 -8682.5 3892.5 -8677.5 {name=p dir=inout}
B 5 3887.5 -8622.5 3892.5 -8617.5 {name=m dir=inout}
B 5 3968.75 -8711.25 3971.25 -8708.75 {name=p dir=out}
B 5 3997.5 -8602.5 4002.5 -8597.5 {name=p dir=inout goto=0}
B 5 3997.5 -8862.5 4002.5 -8857.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 4268.75 -8741.25 4271.25 -8738.75 {name=p dir=in}
B 5 4687.5 -8742.5 4692.5 -8737.5 {name=d dir=inout}
B 5 4647.5 -8712.5 4652.5 -8707.5 {name=g dir=in}
B 5 4687.5 -8682.5 4692.5 -8677.5 {name=s dir=inout}
B 5 4687.5 -8712.5 4692.5 -8707.5 {name=b dir=in}
B 5 4687.5 -8832.5 4692.5 -8827.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 4687.5 -8772.5 4692.5 -8767.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 4777.5 -8742.5 4782.5 -8737.5 {name=p dir=inout pinnumber=1}
B 5 4777.5 -8682.5 4782.5 -8677.5 {name=m dir=inout pinnumber=2}
B 5 4447.5 -8682.5 4452.5 -8677.5 {name=p dir=inout}
B 5 4447.5 -8622.5 4452.5 -8617.5 {name=m dir=inout}
B 5 4528.75 -8711.25 4531.25 -8708.75 {name=p dir=out}
B 5 4557.5 -8602.5 4562.5 -8597.5 {name=p dir=inout goto=0}
B 5 4557.5 -8862.5 4562.5 -8857.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 4828.75 -8741.25 4831.25 -8738.75 {name=p dir=in}
B 5 5257.5 -8742.5 5262.5 -8737.5 {name=d dir=inout}
B 5 5217.5 -8712.5 5222.5 -8707.5 {name=g dir=in}
B 5 5257.5 -8682.5 5262.5 -8677.5 {name=s dir=inout}
B 5 5257.5 -8712.5 5262.5 -8707.5 {name=b dir=in}
B 5 5257.5 -8832.5 5262.5 -8827.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 5257.5 -8772.5 5262.5 -8767.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 5347.5 -8742.5 5352.5 -8737.5 {name=p dir=inout pinnumber=1}
B 5 5347.5 -8682.5 5352.5 -8677.5 {name=m dir=inout pinnumber=2}
B 5 5017.5 -8682.5 5022.5 -8677.5 {name=p dir=inout}
B 5 5017.5 -8622.5 5022.5 -8617.5 {name=m dir=inout}
B 5 5098.75 -8711.25 5101.25 -8708.75 {name=p dir=out}
B 5 5127.5 -8602.5 5132.5 -8597.5 {name=p dir=inout goto=0}
B 5 5127.5 -8862.5 5132.5 -8857.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 5398.75 -8741.25 5401.25 -8738.75 {name=p dir=in}
B 5 3587.5 -7942.5 3592.5 -7937.5 {name=d dir=inout}
B 5 3547.5 -7912.5 3552.5 -7907.5 {name=g dir=in}
B 5 3587.5 -7882.5 3592.5 -7877.5 {name=s dir=inout}
B 5 3587.5 -7912.5 3592.5 -7907.5 {name=b dir=in}
B 5 3587.5 -8032.5 3592.5 -8027.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 3587.5 -7972.5 3592.5 -7967.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 3677.5 -7942.5 3682.5 -7937.5 {name=p dir=inout pinnumber=1}
B 5 3677.5 -7882.5 3682.5 -7877.5 {name=m dir=inout pinnumber=2}
B 5 3347.5 -7882.5 3352.5 -7877.5 {name=p dir=inout}
B 5 3347.5 -7822.5 3352.5 -7817.5 {name=m dir=inout}
B 5 3428.75 -7911.25 3431.25 -7908.75 {name=p dir=out}
B 5 3457.5 -7802.5 3462.5 -7797.5 {name=p dir=inout goto=0}
B 5 3457.5 -8062.5 3462.5 -8057.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 3728.75 -7941.25 3731.25 -7938.75 {name=p dir=in}
B 5 4127.5 -7942.5 4132.5 -7937.5 {name=d dir=inout}
B 5 4087.5 -7912.5 4092.5 -7907.5 {name=g dir=in}
B 5 4127.5 -7882.5 4132.5 -7877.5 {name=s dir=inout}
B 5 4127.5 -7912.5 4132.5 -7907.5 {name=b dir=in}
B 5 4127.5 -8032.5 4132.5 -8027.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 4127.5 -7972.5 4132.5 -7967.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 4217.5 -7942.5 4222.5 -7937.5 {name=p dir=inout pinnumber=1}
B 5 4217.5 -7882.5 4222.5 -7877.5 {name=m dir=inout pinnumber=2}
B 5 3887.5 -7882.5 3892.5 -7877.5 {name=p dir=inout}
B 5 3887.5 -7822.5 3892.5 -7817.5 {name=m dir=inout}
B 5 3968.75 -7911.25 3971.25 -7908.75 {name=p dir=out}
B 5 3997.5 -7802.5 4002.5 -7797.5 {name=p dir=inout goto=0}
B 5 3997.5 -8062.5 4002.5 -8057.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 4268.75 -7941.25 4271.25 -7938.75 {name=p dir=in}
B 5 5257.5 -7942.5 5262.5 -7937.5 {name=d dir=inout}
B 5 5217.5 -7912.5 5222.5 -7907.5 {name=g dir=in}
B 5 5257.5 -7882.5 5262.5 -7877.5 {name=s dir=inout}
B 5 5257.5 -7912.5 5262.5 -7907.5 {name=b dir=in}
B 5 5257.5 -8032.5 5262.5 -8027.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 5257.5 -7972.5 5262.5 -7967.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 5347.5 -7942.5 5352.5 -7937.5 {name=p dir=inout pinnumber=1}
B 5 5347.5 -7882.5 5352.5 -7877.5 {name=m dir=inout pinnumber=2}
B 5 5017.5 -7882.5 5022.5 -7877.5 {name=p dir=inout}
B 5 5017.5 -7822.5 5022.5 -7817.5 {name=m dir=inout}
B 5 5098.75 -7911.25 5101.25 -7908.75 {name=p dir=out}
B 5 5127.5 -7802.5 5132.5 -7797.5 {name=p dir=inout goto=0}
B 5 5127.5 -8062.5 5132.5 -8057.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 5398.75 -7941.25 5401.25 -7938.75 {name=p dir=in}
B 5 3587.5 -8362.5 3592.5 -8357.5 {name=d dir=inout}
B 5 3547.5 -8332.5 3552.5 -8327.5 {name=g dir=in}
B 5 3587.5 -8302.5 3592.5 -8297.5 {name=s dir=inout}
B 5 3587.5 -8332.5 3592.5 -8327.5 {name=b dir=in}
B 5 3587.5 -8452.5 3592.5 -8447.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 3587.5 -8392.5 3592.5 -8387.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 3677.5 -8362.5 3682.5 -8357.5 {name=p dir=inout pinnumber=1}
B 5 3677.5 -8302.5 3682.5 -8297.5 {name=m dir=inout pinnumber=2}
B 5 3347.5 -8302.5 3352.5 -8297.5 {name=p dir=inout}
B 5 3347.5 -8242.5 3352.5 -8237.5 {name=m dir=inout}
B 5 3428.75 -8331.25 3431.25 -8328.75 {name=p dir=out}
B 5 3457.5 -8222.5 3462.5 -8217.5 {name=p dir=inout goto=0}
B 5 3457.5 -8482.5 3462.5 -8477.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 3728.75 -8361.25 3731.25 -8358.75 {name=p dir=in}
B 5 3587.5 -7532.5 3592.5 -7527.5 {name=d dir=inout}
B 5 3547.5 -7502.5 3552.5 -7497.5 {name=g dir=in}
B 5 3587.5 -7472.5 3592.5 -7467.5 {name=s dir=inout}
B 5 3587.5 -7502.5 3592.5 -7497.5 {name=b dir=in}
B 5 3677.5 -7532.5 3682.5 -7527.5 {name=p dir=inout pinnumber=1}
B 5 3677.5 -7472.5 3682.5 -7467.5 {name=m dir=inout pinnumber=2}
B 5 3347.5 -7472.5 3352.5 -7467.5 {name=p dir=inout}
B 5 3347.5 -7412.5 3352.5 -7407.5 {name=m dir=inout}
B 5 3428.75 -7501.25 3431.25 -7498.75 {name=p dir=out}
B 5 3457.5 -7392.5 3462.5 -7387.5 {name=p dir=inout goto=0}
B 5 3728.75 -7531.25 3731.25 -7528.75 {name=p dir=in}
B 5 4687.5 -7532.5 4692.5 -7527.5 {name=d dir=inout}
B 5 4647.5 -7502.5 4652.5 -7497.5 {name=g dir=in}
B 5 4687.5 -7472.5 4692.5 -7467.5 {name=s dir=inout}
B 5 4687.5 -7502.5 4692.5 -7497.5 {name=b dir=in}
B 5 4777.5 -7532.5 4782.5 -7527.5 {name=p dir=inout pinnumber=1}
B 5 4777.5 -7472.5 4782.5 -7467.5 {name=m dir=inout pinnumber=2}
B 5 4447.5 -7472.5 4452.5 -7467.5 {name=p dir=inout}
B 5 4447.5 -7412.5 4452.5 -7407.5 {name=m dir=inout}
B 5 4528.75 -7501.25 4531.25 -7498.75 {name=p dir=out}
B 5 4557.5 -7392.5 4562.5 -7387.5 {name=p dir=inout goto=0}
B 5 4828.75 -7531.25 4831.25 -7528.75 {name=p dir=in}
B 5 4127.5 -7532.5 4132.5 -7527.5 {name=d dir=inout}
B 5 4087.5 -7502.5 4092.5 -7497.5 {name=g dir=in}
B 5 4127.5 -7472.5 4132.5 -7467.5 {name=s dir=inout}
B 5 4127.5 -7502.5 4132.5 -7497.5 {name=b dir=in}
B 5 4217.5 -7532.5 4222.5 -7527.5 {name=p dir=inout pinnumber=1}
B 5 4217.5 -7472.5 4222.5 -7467.5 {name=m dir=inout pinnumber=2}
B 5 3887.5 -7472.5 3892.5 -7467.5 {name=p dir=inout}
B 5 3887.5 -7412.5 3892.5 -7407.5 {name=m dir=inout}
B 5 3968.75 -7501.25 3971.25 -7498.75 {name=p dir=out}
B 5 3997.5 -7392.5 4002.5 -7387.5 {name=p dir=inout goto=0}
B 5 4268.75 -7531.25 4271.25 -7528.75 {name=p dir=in}
B 5 3647.5 -6762.5 3652.5 -6757.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 3647.5 -6702.5 3652.5 -6697.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 3647.5 -6702.5 3652.5 -6697.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 3647.5 -6642.5 3652.5 -6637.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 4187.5 -6642.5 4192.5 -6637.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 4727.5 -6802.5 4732.5 -6797.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 4727.5 -6742.5 4732.5 -6737.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 4727.5 -6702.5 4732.5 -6697.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 4727.5 -6642.5 4732.5 -6637.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 3647.5 -7082.5 3652.5 -7077.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 3647.5 -7022.5 3652.5 -7017.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 3647.5 -7142.5 3652.5 -7137.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 3647.5 -7082.5 3652.5 -7077.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 3647.5 -7202.5 3652.5 -7197.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 3647.5 -7142.5 3652.5 -7137.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 4187.5 -7022.5 4192.5 -7017.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 4187.5 -7202.5 4192.5 -7197.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 4727.5 -7022.5 4732.5 -7017.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 4727.5 -7082.5 4732.5 -7077.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 4727.5 -7202.5 4732.5 -7197.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 4727.5 -7142.5 4732.5 -7137.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 3537.5 -5932.5 3542.5 -5927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 3537.5 -5872.5 3542.5 -5867.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 3647.5 -5932.5 3652.5 -5927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 3647.5 -5872.5 3652.5 -5867.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 3757.5 -5932.5 3762.5 -5927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 3757.5 -5872.5 3762.5 -5867.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 4077.5 -5932.5 4082.5 -5927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 4077.5 -5872.5 4082.5 -5867.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 4187.5 -5932.5 4192.5 -5927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 4187.5 -5872.5 4192.5 -5867.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 4297.5 -5932.5 4302.5 -5927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 4297.5 -5872.5 4302.5 -5867.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 4617.5 -5932.5 4622.5 -5927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 4617.5 -5872.5 4622.5 -5867.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 4727.5 -5932.5 4732.5 -5927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 4727.5 -5872.5 4732.5 -5867.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 4837.5 -5932.5 4842.5 -5927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 4837.5 -5872.5 4842.5 -5867.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 5147.5 -5932.5 5152.5 -5927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 5147.5 -5872.5 5152.5 -5867.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 5257.5 -5932.5 5262.5 -5927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 5257.5 -5872.5 5262.5 -5867.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 5367.5 -5932.5 5372.5 -5927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 5367.5 -5872.5 5372.5 -5867.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 5327.5 -7022.5 5332.5 -7017.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 5327.5 -7082.5 5332.5 -7077.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 5327.5 -7202.5 5332.5 -7197.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 5327.5 -7142.5 5332.5 -7137.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 6367.5 -7072.5 6372.5 -7067.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 6367.5 -7012.5 6372.5 -7007.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 6477.5 -7072.5 6482.5 -7067.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 6477.5 -7012.5 6482.5 -7007.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 6587.5 -7072.5 6592.5 -7067.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 6587.5 -7012.5 6592.5 -7007.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 6367.5 -6982.5 6372.5 -6977.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 6367.5 -6922.5 6372.5 -6917.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 6477.5 -6982.5 6482.5 -6977.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 6477.5 -6922.5 6482.5 -6917.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 6587.5 -6982.5 6592.5 -6977.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 6587.5 -6922.5 6592.5 -6917.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 6907.5 -6982.5 6912.5 -6977.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 6907.5 -6922.5 6912.5 -6917.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 7017.5 -6982.5 7022.5 -6977.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 7017.5 -6922.5 7022.5 -6917.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 7127.5 -6982.5 7132.5 -6977.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 7127.5 -6922.5 7132.5 -6917.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 7447.5 -6982.5 7452.5 -6977.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 7447.5 -6922.5 7452.5 -6917.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 7557.5 -6982.5 7562.5 -6977.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 7557.5 -6922.5 7562.5 -6917.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 7667.5 -6982.5 7672.5 -6977.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 7667.5 -6922.5 7672.5 -6917.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 7537.5 -8742.5 7542.5 -8737.5 {name=d dir=inout}
B 5 7497.5 -8712.5 7502.5 -8707.5 {name=g dir=in}
B 5 7537.5 -8682.5 7542.5 -8677.5 {name=s dir=inout}
B 5 7537.5 -8712.5 7542.5 -8707.5 {name=b dir=in}
B 5 1108.75 -8691.25 1111.25 -8688.75 {name=p dir=out}
B 5 1137.5 -8582.5 1142.5 -8577.5 {name=p dir=inout goto=0}
B 5 1137.5 -8842.5 1142.5 -8837.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -8721.25 1411.25 -8718.75 {name=p dir=in}
B 5 1027.5 -8662.5 1032.5 -8657.5 {name=p dir=inout}
B 5 1027.5 -8602.5 1032.5 -8597.5 {name=m dir=inout}
B 5 6367.5 -6692.5 6372.5 -6687.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 6367.5 -6632.5 6372.5 -6627.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 6477.5 -6692.5 6482.5 -6687.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 6477.5 -6632.5 6482.5 -6627.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 6587.5 -6692.5 6592.5 -6687.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 6587.5 -6632.5 6592.5 -6627.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 6367.5 -6632.5 6372.5 -6627.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 6367.5 -6572.5 6372.5 -6567.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 6477.5 -6632.5 6482.5 -6627.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 6477.5 -6572.5 6482.5 -6567.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 6587.5 -6632.5 6592.5 -6627.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 6587.5 -6572.5 6592.5 -6567.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 6907.5 -6632.5 6912.5 -6627.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 6907.5 -6572.5 6912.5 -6567.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 7017.5 -6632.5 7022.5 -6627.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 7017.5 -6572.5 7022.5 -6567.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 7127.5 -6632.5 7132.5 -6627.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 7127.5 -6572.5 7132.5 -6567.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 7447.5 -6602.5 7452.5 -6597.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 7447.5 -6542.5 7452.5 -6537.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 7557.5 -6602.5 7562.5 -6597.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 7557.5 -6542.5 7562.5 -6537.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 7667.5 -6602.5 7672.5 -6597.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 7667.5 -6542.5 7672.5 -6537.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 7417.5 -7382.5 7422.5 -7377.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 7417.5 -7322.5 7422.5 -7317.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 7537.5 -7382.5 7542.5 -7377.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 7537.5 -7322.5 7542.5 -7317.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 6457.5 -7452.5 6462.5 -7447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 6477.5 -6232.5 6482.5 -6227.5 {name=d dir=inout}
B 5 6437.5 -6202.5 6442.5 -6197.5 {name=g dir=in}
B 5 6477.5 -6172.5 6482.5 -6167.5 {name=s dir=inout}
B 5 6477.5 -6202.5 6482.5 -6197.5 {name=b dir=in}
B 5 6477.5 -6322.5 6482.5 -6317.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 6477.5 -6262.5 6482.5 -6257.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 6567.5 -6232.5 6572.5 -6227.5 {name=p dir=inout pinnumber=1}
B 5 6567.5 -6172.5 6572.5 -6167.5 {name=m dir=inout pinnumber=2}
B 5 6237.5 -6172.5 6242.5 -6167.5 {name=p dir=inout}
B 5 6237.5 -6112.5 6242.5 -6107.5 {name=m dir=inout}
B 5 6318.75 -6201.25 6321.25 -6198.75 {name=p dir=out}
B 5 6347.5 -6092.5 6352.5 -6087.5 {name=p dir=inout goto=0}
B 5 6347.5 -6352.5 6352.5 -6347.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 6618.75 -6231.25 6621.25 -6228.75 {name=p dir=in}
B 5 7127.5 -6232.5 7132.5 -6227.5 {name=d dir=inout}
B 5 7087.5 -6202.5 7092.5 -6197.5 {name=g dir=in}
B 5 7127.5 -6172.5 7132.5 -6167.5 {name=s dir=inout}
B 5 7127.5 -6202.5 7132.5 -6197.5 {name=b dir=in}
B 5 7127.5 -6322.5 7132.5 -6317.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 7127.5 -6262.5 7132.5 -6257.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 6887.5 -6172.5 6892.5 -6167.5 {name=p dir=inout}
B 5 6887.5 -6112.5 6892.5 -6107.5 {name=m dir=inout}
B 5 6968.75 -6201.25 6971.25 -6198.75 {name=p dir=out}
B 5 6997.5 -6092.5 7002.5 -6087.5 {name=p dir=inout goto=0}
B 5 6997.5 -6352.5 7002.5 -6347.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 7268.75 -6231.25 7271.25 -6228.75 {name=p dir=in}
B 5 4127.5 -8362.5 4132.5 -8357.5 {name=d dir=inout}
B 5 4087.5 -8332.5 4092.5 -8327.5 {name=g dir=in}
B 5 4127.5 -8302.5 4132.5 -8297.5 {name=s dir=inout}
B 5 4127.5 -8332.5 4132.5 -8327.5 {name=b dir=in}
B 5 4127.5 -8452.5 4132.5 -8447.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 4127.5 -8392.5 4132.5 -8387.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 4217.5 -8362.5 4222.5 -8357.5 {name=p dir=inout pinnumber=1}
B 5 4217.5 -8302.5 4222.5 -8297.5 {name=m dir=inout pinnumber=2}
B 5 3887.5 -8302.5 3892.5 -8297.5 {name=p dir=inout}
B 5 3887.5 -8242.5 3892.5 -8237.5 {name=m dir=inout}
B 5 3968.75 -8331.25 3971.25 -8328.75 {name=p dir=out}
B 5 3997.5 -8222.5 4002.5 -8217.5 {name=p dir=inout goto=0}
B 5 3997.5 -8482.5 4002.5 -8477.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 4268.75 -8361.25 4271.25 -8358.75 {name=p dir=in}
B 5 4687.5 -8362.5 4692.5 -8357.5 {name=d dir=inout}
B 5 4647.5 -8332.5 4652.5 -8327.5 {name=g dir=in}
B 5 4687.5 -8302.5 4692.5 -8297.5 {name=s dir=inout}
B 5 4687.5 -8332.5 4692.5 -8327.5 {name=b dir=in}
B 5 4687.5 -8452.5 4692.5 -8447.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 4687.5 -8392.5 4692.5 -8387.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 4777.5 -8362.5 4782.5 -8357.5 {name=p dir=inout pinnumber=1}
B 5 4777.5 -8302.5 4782.5 -8297.5 {name=m dir=inout pinnumber=2}
B 5 4447.5 -8302.5 4452.5 -8297.5 {name=p dir=inout}
B 5 4447.5 -8242.5 4452.5 -8237.5 {name=m dir=inout}
B 5 4528.75 -8331.25 4531.25 -8328.75 {name=p dir=out}
B 5 4557.5 -8222.5 4562.5 -8217.5 {name=p dir=inout goto=0}
B 5 4557.5 -8482.5 4562.5 -8477.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 4828.75 -8361.25 4831.25 -8358.75 {name=p dir=in}
B 5 5257.5 -8362.5 5262.5 -8357.5 {name=d dir=inout}
B 5 5217.5 -8332.5 5222.5 -8327.5 {name=g dir=in}
B 5 5257.5 -8302.5 5262.5 -8297.5 {name=s dir=inout}
B 5 5257.5 -8332.5 5262.5 -8327.5 {name=b dir=in}
B 5 5257.5 -8452.5 5262.5 -8447.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 5257.5 -8392.5 5262.5 -8387.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 5347.5 -8362.5 5352.5 -8357.5 {name=p dir=inout pinnumber=1}
B 5 5347.5 -8302.5 5352.5 -8297.5 {name=m dir=inout pinnumber=2}
B 5 5017.5 -8302.5 5022.5 -8297.5 {name=p dir=inout}
B 5 5017.5 -8242.5 5022.5 -8237.5 {name=m dir=inout}
B 5 5098.75 -8331.25 5101.25 -8328.75 {name=p dir=out}
B 5 5127.5 -8222.5 5132.5 -8217.5 {name=p dir=inout goto=0}
B 5 5127.5 -8482.5 5132.5 -8477.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 5398.75 -8361.25 5401.25 -8358.75 {name=p dir=in}
B 5 7687.5 -6232.5 7692.5 -6227.5 {name=d dir=inout}
B 5 7647.5 -6202.5 7652.5 -6197.5 {name=g dir=in}
B 5 7687.5 -6172.5 7692.5 -6167.5 {name=s dir=inout}
B 5 7687.5 -6202.5 7692.5 -6197.5 {name=b dir=in}
B 5 7687.5 -6322.5 7692.5 -6317.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 7687.5 -6262.5 7692.5 -6257.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 7447.5 -6172.5 7452.5 -6167.5 {name=p dir=inout}
B 5 7447.5 -6112.5 7452.5 -6107.5 {name=m dir=inout}
B 5 7528.75 -6201.25 7531.25 -6198.75 {name=p dir=out}
B 5 7557.5 -6092.5 7562.5 -6087.5 {name=p dir=inout goto=0}
B 5 7557.5 -6352.5 7562.5 -6347.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 7828.75 -6231.25 7831.25 -6228.75 {name=p dir=in}
A 1 6880 -8370 5.590169943749475 333.434948822922 360 {fill=1}
A 1 7000 -8370 5.590169943749475 333.434948822922 360 {fill=1}
A 1 7510 -8370 5.590169943749475 333.434948822922 360 {fill=1}
A 1 7630 -8370 5.590169943749475 333.434948822922 360 {fill=1}
A 1 6940 -8090 5.590169943749475 333.434948822922 360 {fill=1}
A 1 7570 -8090 5.590169943749475 333.434948822922 360 {fill=1}
A 1 6400 -7690 5.590169943749475 333.434948822922 360 {fill=1}
A 2 1570 -8630 15 270 360 {}
A 2 2030 -8630 15 270 360 {}
A 4 1030 -8160 15 270 360 {}
A 4 1570 -8160 15 270 360 {}
A 4 500 -8160 15 270 360 {}
A 4 500 -7700 15 270 360 {}
A 4 1040 -7700 15 270 360 {}
A 4 500 -6870 15 270 360 {}
A 4 1040 -6870 15 270 360 {}
A 4 500 -6380 15 270 360 {}
A 4 1040 -6380 15 270 360 {}
A 4 500 -5890 15 270 360 {}
A 4 1690 -5890 15 270 360 {}
A 4 1040 -5890 15 270 360 {}
A 4 1030 -7330 15 270 360 {}
A 4 500 -7330 15 270 360 {}
A 4 1530 -7330 15 270 360 {}
A 4 500 -8630 15 270 360 {}
A 4 3350 -8650 15 270 360 {}
A 4 3890 -8650 15 270 360 {}
A 4 4450 -8650 15 270 360 {}
A 4 5020 -8650 15 270 360 {}
A 4 3350 -7850 15 270 360 {}
A 4 3890 -7850 15 270 360 {}
A 4 5020 -7850 15 270 360 {}
A 4 3350 -8270 15 270 360 {}
A 4 3350 -7440 15 270 360 {}
A 4 4450 -7440 15 270 360 {}
A 4 3890 -7440 15 270 360 {}
A 4 1030 -8630 15 270 360 {}
A 4 6240 -6140 15 270 360 {}
A 4 6890 -6140 15 270 360 {}
A 4 3890 -8270 15 270 360 {}
A 4 4450 -8270 15 270 360 {}
A 4 5020 -8270 15 270 360 {}
A 4 7450 -6140 15 270 360 {}
A 5 4190 -6380 5.590169943749475 333.434948822922 360 {fill=1}
P 1 14 920 -8080 942.5 -8080 947.5 -8080 947.5 -8075 947.5 -8032.5 940 -8007.5 935 -8007.5 905 -8007.5 900 -8007.5 892.5 -8032.5 892.5 -8075 892.5 -8080 897.5 -8080 920 -8080 {bezier=1}
P 1 14 935 -8077.5 940 -8077.5 945 -8077.5 945 -8072.5 945 -8052.5 945 -8047.5 940 -8047.5 930 -8047.5 925 -8047.5 925 -8052.5 925 -8072.5 925 -8077.5 930 -8077.5 935 -8077.5 {bezier=1}
P 1 5 917.5 -8075 922.5 -8075 922.5 -8050 917.5 -8050 917.5 -8075 {}
P 1 14 1350 -8080 1372.5 -8080 1377.5 -8080 1377.5 -8075 1377.5 -8032.5 1370 -8007.5 1365 -8007.5 1335 -8007.5 1330 -8007.5 1322.5 -8032.5 1322.5 -8075 1322.5 -8080 1327.5 -8080 1350 -8080 {bezier=1}
P 1 14 1365 -8077.5 1370 -8077.5 1375 -8077.5 1375 -8072.5 1375 -8052.5 1375 -8047.5 1370 -8047.5 1360 -8047.5 1355 -8047.5 1355 -8052.5 1355 -8072.5 1355 -8077.5 1360 -8077.5 1365 -8077.5 {bezier=1}
P 1 5 1347.5 -8075 1352.5 -8075 1352.5 -8050 1347.5 -8050 1347.5 -8075 {}
P 1 14 2120 -8080 2142.5 -8080 2147.5 -8080 2147.5 -8075 2147.5 -8032.5 2140 -8007.5 2135 -8007.5 2105 -8007.5 2100 -8007.5 2092.5 -8032.5 2092.5 -8075 2092.5 -8080 2097.5 -8080 2120 -8080 {bezier=1}
P 1 14 2135 -8077.5 2140 -8077.5 2145 -8077.5 2145 -8072.5 2145 -8052.5 2145 -8047.5 2140 -8047.5 2130 -8047.5 2125 -8047.5 2125 -8052.5 2125 -8072.5 2125 -8077.5 2130 -8077.5 2135 -8077.5 {bezier=1}
P 1 5 2117.5 -8075 2122.5 -8075 2122.5 -8050 2117.5 -8050 2117.5 -8075 {}
P 1 14 2105 -8077.5 2110 -8077.5 2115 -8077.5 2115 -8072.5 2115 -8052.5 2115 -8047.5 2110 -8047.5 2100 -8047.5 2095 -8047.5 2095 -8052.5 2095 -8072.5 2095 -8077.5 2100 -8077.5 2105 -8077.5 {}
P 1 14 1420 -7890 1442.5 -7890 1447.5 -7890 1447.5 -7885 1447.5 -7842.5 1440 -7817.5 1435 -7817.5 1405 -7817.5 1400 -7817.5 1392.5 -7842.5 1392.5 -7885 1392.5 -7890 1397.5 -7890 1420 -7890 {bezier=1}
P 1 14 1435 -7887.5 1440 -7887.5 1445 -7887.5 1445 -7882.5 1445 -7862.5 1445 -7857.5 1440 -7857.5 1430 -7857.5 1425 -7857.5 1425 -7862.5 1425 -7882.5 1425 -7887.5 1430 -7887.5 1435 -7887.5 {bezier=1}
P 1 5 1417.5 -7885 1422.5 -7885 1422.5 -7860 1417.5 -7860 1417.5 -7885 {}
P 1 14 1440 -7070 1462.5 -7070 1467.5 -7070 1467.5 -7065 1467.5 -7022.5 1460 -6997.5 1455 -6997.5 1425 -6997.5 1420 -6997.5 1412.5 -7022.5 1412.5 -7065 1412.5 -7070 1417.5 -7070 1440 -7070 {bezier=1}
P 1 14 1455 -7067.5 1460 -7067.5 1465 -7067.5 1465 -7062.5 1465 -7042.5 1465 -7037.5 1460 -7037.5 1450 -7037.5 1445 -7037.5 1445 -7042.5 1445 -7062.5 1445 -7067.5 1450 -7067.5 1455 -7067.5 {bezier=1}
P 1 5 1437.5 -7065 1442.5 -7065 1442.5 -7040 1437.5 -7040 1437.5 -7065 {}
P 1 10 1530 -7055 1555 -7055 1565 -7045 1565 -7015 1555 -7005 1505 -7005 1495 -7015 1495 -7045 1505 -7055 1530 -7055 {bezier=1}
P 1 10 1530 -7060 1560 -7060 1570 -7050 1570 -7010 1560 -7000 1500 -7000 1490 -7010 1490 -7050 1500 -7060 1530 -7060 {bezier=1}
P 1 14 1440 -6580 1462.5 -6580 1467.5 -6580 1467.5 -6575 1467.5 -6532.5 1460 -6507.5 1455 -6507.5 1425 -6507.5 1420 -6507.5 1412.5 -6532.5 1412.5 -6575 1412.5 -6580 1417.5 -6580 1440 -6580 {bezier=1}
P 1 14 1455 -6577.5 1460 -6577.5 1465 -6577.5 1465 -6572.5 1465 -6552.5 1465 -6547.5 1460 -6547.5 1450 -6547.5 1445 -6547.5 1445 -6552.5 1445 -6572.5 1445 -6577.5 1450 -6577.5 1455 -6577.5 {bezier=1}
P 1 5 1437.5 -6575 1442.5 -6575 1442.5 -6550 1437.5 -6550 1437.5 -6575 {}
P 1 10 1530 -6565 1555 -6565 1565 -6555 1565 -6525 1555 -6515 1505 -6515 1495 -6525 1495 -6555 1505 -6565 1530 -6565 {bezier=1}
P 1 10 1530 -6570 1560 -6570 1570 -6560 1570 -6520 1560 -6510 1500 -6510 1490 -6520 1490 -6560 1500 -6570 1530 -6570 {bezier=1}
P 1 14 950 -5850 972.5 -5850 977.5 -5850 977.5 -5845 977.5 -5802.5 970 -5777.5 965 -5777.5 935 -5777.5 930 -5777.5 922.5 -5802.5 922.5 -5845 922.5 -5850 927.5 -5850 950 -5850 {bezier=1}
P 1 14 965 -5847.5 970 -5847.5 975 -5847.5 975 -5842.5 975 -5822.5 975 -5817.5 970 -5817.5 960 -5817.5 955 -5817.5 955 -5822.5 955 -5842.5 955 -5847.5 960 -5847.5 965 -5847.5 {bezier=1}
P 1 5 947.5 -5845 952.5 -5845 952.5 -5820 947.5 -5820 947.5 -5845 {}
P 1 14 1430 -5860 1452.5 -5860 1457.5 -5860 1457.5 -5855 1457.5 -5812.5 1450 -5787.5 1445 -5787.5 1415 -5787.5 1410 -5787.5 1402.5 -5812.5 1402.5 -5855 1402.5 -5860 1407.5 -5860 1430 -5860 {bezier=1}
P 1 14 1445 -5857.5 1450 -5857.5 1455 -5857.5 1455 -5852.5 1455 -5832.5 1455 -5827.5 1450 -5827.5 1440 -5827.5 1435 -5827.5 1435 -5832.5 1435 -5852.5 1435 -5857.5 1440 -5857.5 1445 -5857.5 {bezier=1}
P 1 5 1427.5 -5855 1432.5 -5855 1432.5 -5830 1427.5 -5830 1427.5 -5855 {}
P 1 10 1520 -5845 1545 -5845 1555 -5835 1555 -5805 1545 -5795 1495 -5795 1485 -5805 1485 -5835 1495 -5845 1520 -5845 {bezier=1}
P 1 10 1520 -5850 1550 -5850 1560 -5840 1560 -5800 1550 -5790 1490 -5790 1480 -5800 1480 -5840 1490 -5850 1520 -5850 {bezier=1}
P 1 14 920 -7250 942.5 -7250 947.5 -7250 947.5 -7245 947.5 -7202.5 940 -7177.5 935 -7177.5 905 -7177.5 900 -7177.5 892.5 -7202.5 892.5 -7245 892.5 -7250 897.5 -7250 920 -7250 {bezier=1}
P 1 14 935 -7247.5 940 -7247.5 945 -7247.5 945 -7242.5 945 -7222.5 945 -7217.5 940 -7217.5 930 -7217.5 925 -7217.5 925 -7222.5 925 -7242.5 925 -7247.5 930 -7247.5 935 -7247.5 {bezier=1}
P 1 5 917.5 -7245 922.5 -7245 922.5 -7220 917.5 -7220 917.5 -7245 {}
P 1 14 1350 -7250 1372.5 -7250 1377.5 -7250 1377.5 -7245 1377.5 -7202.5 1370 -7177.5 1365 -7177.5 1335 -7177.5 1330 -7177.5 1322.5 -7202.5 1322.5 -7245 1322.5 -7250 1327.5 -7250 1350 -7250 {bezier=1}
P 1 14 1365 -7247.5 1370 -7247.5 1375 -7247.5 1375 -7242.5 1375 -7222.5 1375 -7217.5 1370 -7217.5 1360 -7217.5 1355 -7217.5 1355 -7222.5 1355 -7242.5 1355 -7247.5 1360 -7247.5 1365 -7247.5 {bezier=1}
P 1 5 1347.5 -7245 1352.5 -7245 1352.5 -7220 1347.5 -7220 1347.5 -7245 {}
P 1 14 2120 -7250 2142.5 -7250 2147.5 -7250 2147.5 -7245 2147.5 -7202.5 2140 -7177.5 2135 -7177.5 2105 -7177.5 2100 -7177.5 2092.5 -7202.5 2092.5 -7245 2092.5 -7250 2097.5 -7250 2120 -7250 {bezier=1}
P 1 14 2135 -7247.5 2140 -7247.5 2145 -7247.5 2145 -7242.5 2145 -7222.5 2145 -7217.5 2140 -7217.5 2130 -7217.5 2125 -7217.5 2125 -7222.5 2125 -7242.5 2125 -7247.5 2130 -7247.5 2135 -7247.5 {bezier=1}
P 1 5 2117.5 -7245 2122.5 -7245 2122.5 -7220 2117.5 -7220 2117.5 -7245 {}
P 1 14 2105 -7247.5 2110 -7247.5 2115 -7247.5 2115 -7242.5 2115 -7222.5 2115 -7217.5 2110 -7217.5 2100 -7217.5 2095 -7217.5 2095 -7222.5 2095 -7242.5 2095 -7247.5 2100 -7247.5 2105 -7247.5 {}
P 1 10 1270 -7245 1295 -7245 1305 -7235 1305 -7205 1295 -7195 1245 -7195 1235 -7205 1235 -7235 1245 -7245 1270 -7245 {bezier=1}
P 1 10 1270 -7250 1300 -7250 1310 -7240 1310 -7200 1300 -7190 1240 -7190 1230 -7200 1230 -7240 1240 -7250 1270 -7250 {bezier=1}
P 1 14 920 -8550 942.5 -8550 947.5 -8550 947.5 -8545 947.5 -8502.5 940 -8477.5 935 -8477.5 905 -8477.5 900 -8477.5 892.5 -8502.5 892.5 -8545 892.5 -8550 897.5 -8550 920 -8550 {bezier=1}
P 1 14 935 -8547.5 940 -8547.5 945 -8547.5 945 -8542.5 945 -8522.5 945 -8517.5 940 -8517.5 930 -8517.5 925 -8517.5 925 -8522.5 925 -8542.5 925 -8547.5 930 -8547.5 935 -8547.5 {bezier=1}
P 1 5 917.5 -8545 922.5 -8545 922.5 -8520 917.5 -8520 917.5 -8545 {}
P 1 14 1630 -8540 1652.5 -8540 1657.5 -8540 1657.5 -8535 1657.5 -8492.5 1650 -8467.5 1645 -8467.5 1615 -8467.5 1610 -8467.5 1602.5 -8492.5 1602.5 -8535 1602.5 -8540 1607.5 -8540 1630 -8540 {bezier=1}
P 1 14 1645 -8537.5 1650 -8537.5 1655 -8537.5 1655 -8532.5 1655 -8512.5 1655 -8507.5 1650 -8507.5 1640 -8507.5 1635 -8507.5 1635 -8512.5 1635 -8532.5 1635 -8537.5 1640 -8537.5 1645 -8537.5 {bezier=1}
P 1 5 1627.5 -8535 1632.5 -8535 1632.5 -8510 1627.5 -8510 1627.5 -8535 {}
P 1 10 1710 -8525 1735 -8525 1745 -8515 1745 -8485 1735 -8475 1685 -8475 1675 -8485 1675 -8515 1685 -8525 1710 -8525 {bezier=1}
P 1 10 1710 -8530 1740 -8530 1750 -8520 1750 -8480 1740 -8470 1680 -8470 1670 -8480 1670 -8520 1680 -8530 1710 -8530 {bezier=1}
P 1 14 2410 -8530 2432.5 -8530 2437.5 -8530 2437.5 -8525 2437.5 -8482.5 2430 -8457.5 2425 -8457.5 2395 -8457.5 2390 -8457.5 2382.5 -8482.5 2382.5 -8525 2382.5 -8530 2387.5 -8530 2410 -8530 {bezier=1}
P 1 14 2425 -8527.5 2430 -8527.5 2435 -8527.5 2435 -8522.5 2435 -8502.5 2435 -8497.5 2430 -8497.5 2420 -8497.5 2415 -8497.5 2415 -8502.5 2415 -8522.5 2415 -8527.5 2420 -8527.5 2425 -8527.5 {bezier=1}
P 1 5 2407.5 -8525 2412.5 -8525 2412.5 -8500 2407.5 -8500 2407.5 -8525 {}
P 1 10 2490 -8515 2515 -8515 2525 -8505 2525 -8475 2515 -8465 2465 -8465 2455 -8475 2455 -8505 2465 -8515 2490 -8515 {bezier=1}
P 1 10 2490 -8520 2520 -8520 2530 -8510 2530 -8470 2520 -8460 2460 -8460 2450 -8470 2450 -8510 2460 -8520 2490 -8520 {bezier=1}
P 1 14 4320 -8860 4342.5 -8860 4347.5 -8860 4347.5 -8855 4347.5 -8812.5 4340 -8787.5 4335 -8787.5 4305 -8787.5 4300 -8787.5 4292.5 -8812.5 4292.5 -8855 4292.5 -8860 4297.5 -8860 4320 -8860 {bezier=1}
P 1 14 4335 -8857.5 4340 -8857.5 4345 -8857.5 4345 -8852.5 4345 -8832.5 4345 -8827.5 4340 -8827.5 4330 -8827.5 4325 -8827.5 4325 -8832.5 4325 -8852.5 4325 -8857.5 4330 -8857.5 4335 -8857.5 {bezier=1}
P 1 5 4317.5 -8855 4322.5 -8855 4322.5 -8830 4317.5 -8830 4317.5 -8855 {}
P 1 14 4770 -8930 4792.5 -8930 4797.5 -8930 4797.5 -8925 4797.5 -8882.5 4790 -8857.5 4785 -8857.5 4755 -8857.5 4750 -8857.5 4742.5 -8882.5 4742.5 -8925 4742.5 -8930 4747.5 -8930 4770 -8930 {bezier=1}
P 1 14 4785 -8927.5 4790 -8927.5 4795 -8927.5 4795 -8922.5 4795 -8902.5 4795 -8897.5 4790 -8897.5 4780 -8897.5 4775 -8897.5 4775 -8902.5 4775 -8922.5 4775 -8927.5 4780 -8927.5 4785 -8927.5 {bezier=1}
P 1 5 4767.5 -8925 4772.5 -8925 4772.5 -8900 4767.5 -8900 4767.5 -8925 {}
P 1 14 5390 -8840 5412.5 -8840 5417.5 -8840 5417.5 -8835 5417.5 -8792.5 5410 -8767.5 5405 -8767.5 5375 -8767.5 5370 -8767.5 5362.5 -8792.5 5362.5 -8835 5362.5 -8840 5367.5 -8840 5390 -8840 {bezier=1}
P 1 14 5405 -8837.5 5410 -8837.5 5415 -8837.5 5415 -8832.5 5415 -8812.5 5415 -8807.5 5410 -8807.5 5400 -8807.5 5395 -8807.5 5395 -8812.5 5395 -8832.5 5395 -8837.5 5400 -8837.5 5405 -8837.5 {bezier=1}
P 1 5 5387.5 -8835 5392.5 -8835 5392.5 -8810 5387.5 -8810 5387.5 -8835 {}
P 1 14 5375 -8837.5 5380 -8837.5 5385 -8837.5 5385 -8832.5 5385 -8812.5 5385 -8807.5 5380 -8807.5 5370 -8807.5 5365 -8807.5 5365 -8812.5 5365 -8832.5 5365 -8837.5 5370 -8837.5 5375 -8837.5 {}
P 1 14 3520 -8030 3542.5 -8030 3547.5 -8030 3547.5 -8025 3547.5 -7982.5 3540 -7957.5 3535 -7957.5 3505 -7957.5 3500 -7957.5 3492.5 -7982.5 3492.5 -8025 3492.5 -8030 3497.5 -8030 3520 -8030 {bezier=1}
P 1 14 3535 -8027.5 3540 -8027.5 3545 -8027.5 3545 -8022.5 3545 -8002.5 3545 -7997.5 3540 -7997.5 3530 -7997.5 3525 -7997.5 3525 -8002.5 3525 -8022.5 3525 -8027.5 3530 -8027.5 3535 -8027.5 {bezier=1}
P 1 5 3517.5 -8025 3522.5 -8025 3522.5 -8000 3517.5 -8000 3517.5 -8025 {}
P 1 14 4180 -8050 4202.5 -8050 4207.5 -8050 4207.5 -8045 4207.5 -8002.5 4200 -7977.5 4195 -7977.5 4165 -7977.5 4160 -7977.5 4152.5 -8002.5 4152.5 -8045 4152.5 -8050 4157.5 -8050 4180 -8050 {bezier=1}
P 1 14 4195 -8047.5 4200 -8047.5 4205 -8047.5 4205 -8042.5 4205 -8022.5 4205 -8017.5 4200 -8017.5 4190 -8017.5 4185 -8017.5 4185 -8022.5 4185 -8042.5 4185 -8047.5 4190 -8047.5 4195 -8047.5 {bezier=1}
P 1 5 4177.5 -8045 4182.5 -8045 4182.5 -8020 4177.5 -8020 4177.5 -8045 {}
P 1 14 5370 -8100 5392.5 -8100 5397.5 -8100 5397.5 -8095 5397.5 -8052.5 5390 -8027.5 5385 -8027.5 5355 -8027.5 5350 -8027.5 5342.5 -8052.5 5342.5 -8095 5342.5 -8100 5347.5 -8100 5370 -8100 {bezier=1}
P 1 14 5385 -8097.5 5390 -8097.5 5395 -8097.5 5395 -8092.5 5395 -8072.5 5395 -8067.5 5390 -8067.5 5380 -8067.5 5375 -8067.5 5375 -8072.5 5375 -8092.5 5375 -8097.5 5380 -8097.5 5385 -8097.5 {bezier=1}
P 1 5 5367.5 -8095 5372.5 -8095 5372.5 -8070 5367.5 -8070 5367.5 -8095 {}
P 1 14 5355 -8097.5 5360 -8097.5 5365 -8097.5 5365 -8092.5 5365 -8072.5 5365 -8067.5 5360 -8067.5 5350 -8067.5 5345 -8067.5 5345 -8072.5 5345 -8092.5 5345 -8097.5 5350 -8097.5 5355 -8097.5 {}
P 1 14 3680 -7670 3702.5 -7670 3707.5 -7670 3707.5 -7665 3707.5 -7622.5 3700 -7597.5 3695 -7597.5 3665 -7597.5 3660 -7597.5 3652.5 -7622.5 3652.5 -7665 3652.5 -7670 3657.5 -7670 3680 -7670 {bezier=1}
P 1 14 3695 -7667.5 3700 -7667.5 3705 -7667.5 3705 -7662.5 3705 -7642.5 3705 -7637.5 3700 -7637.5 3690 -7637.5 3685 -7637.5 3685 -7642.5 3685 -7662.5 3685 -7667.5 3690 -7667.5 3695 -7667.5 {bezier=1}
P 1 5 3677.5 -7665 3682.5 -7665 3682.5 -7640 3677.5 -7640 3677.5 -7665 {}
P 1 14 4080 -7620 4102.5 -7620 4107.5 -7620 4107.5 -7615 4107.5 -7572.5 4100 -7547.5 4095 -7547.5 4065 -7547.5 4060 -7547.5 4052.5 -7572.5 4052.5 -7615 4052.5 -7620 4057.5 -7620 4080 -7620 {bezier=1}
P 1 14 4095 -7617.5 4100 -7617.5 4105 -7617.5 4105 -7612.5 4105 -7592.5 4105 -7587.5 4100 -7587.5 4090 -7587.5 4085 -7587.5 4085 -7592.5 4085 -7612.5 4085 -7617.5 4090 -7617.5 4095 -7617.5 {bezier=1}
P 1 5 4077.5 -7615 4082.5 -7615 4082.5 -7590 4077.5 -7590 4077.5 -7615 {}
P 1 10 4000 -7605 4025 -7605 4035 -7595 4035 -7565 4025 -7555 3975 -7555 3965 -7565 3965 -7595 3975 -7605 4000 -7605 {bezier=1}
P 1 10 4000 -7610 4030 -7610 4040 -7600 4040 -7560 4030 -7550 3970 -7550 3960 -7560 3960 -7600 3970 -7610 4000 -7610 {bezier=1}
P 1 14 4640 -7650 4662.5 -7650 4667.5 -7650 4667.5 -7645 4667.5 -7602.5 4660 -7577.5 4655 -7577.5 4625 -7577.5 4620 -7577.5 4612.5 -7602.5 4612.5 -7645 4612.5 -7650 4617.5 -7650 4640 -7650 {bezier=1}
P 1 14 4655 -7647.5 4660 -7647.5 4665 -7647.5 4665 -7642.5 4665 -7622.5 4665 -7617.5 4660 -7617.5 4650 -7617.5 4645 -7617.5 4645 -7622.5 4645 -7642.5 4645 -7647.5 4650 -7647.5 4655 -7647.5 {bezier=1}
P 1 5 4637.5 -7645 4642.5 -7645 4642.5 -7620 4637.5 -7620 4637.5 -7645 {}
P 1 14 4260 -7100 4282.5 -7100 4287.5 -7100 4287.5 -7095 4287.5 -7052.5 4280 -7027.5 4275 -7027.5 4245 -7027.5 4240 -7027.5 4232.5 -7052.5 4232.5 -7095 4232.5 -7100 4237.5 -7100 4260 -7100 {bezier=1}
P 1 14 4275 -7097.5 4280 -7097.5 4285 -7097.5 4285 -7092.5 4285 -7072.5 4285 -7067.5 4280 -7067.5 4270 -7067.5 4265 -7067.5 4265 -7072.5 4265 -7092.5 4265 -7097.5 4270 -7097.5 4275 -7097.5 {bezier=1}
P 1 5 4257.5 -7095 4262.5 -7095 4262.5 -7070 4257.5 -7070 4257.5 -7095 {}
P 1 10 4260 -7255 4285 -7255 4295 -7245 4295 -7215 4285 -7205 4235 -7205 4225 -7215 4225 -7245 4235 -7255 4260 -7255 {bezier=1}
P 1 10 4260 -7260 4290 -7260 4300 -7250 4300 -7210 4290 -7200 4230 -7200 4220 -7210 4220 -7250 4230 -7260 4260 -7260 {bezier=1}
P 1 10 4260 -7175 4285 -7175 4295 -7165 4295 -7135 4285 -7125 4235 -7125 4225 -7135 4225 -7165 4235 -7175 4260 -7175 {bezier=1}
P 1 10 4260 -7180 4290 -7180 4300 -7170 4300 -7130 4290 -7120 4230 -7120 4220 -7130 4220 -7170 4230 -7180 4260 -7180 {bezier=1}
P 1 14 4530 -7100 4552.5 -7100 4557.5 -7100 4557.5 -7095 4557.5 -7052.5 4550 -7027.5 4545 -7027.5 4515 -7027.5 4510 -7027.5 4502.5 -7052.5 4502.5 -7095 4502.5 -7100 4507.5 -7100 4530 -7100 {bezier=1}
P 1 14 4545 -7097.5 4550 -7097.5 4555 -7097.5 4555 -7092.5 4555 -7072.5 4555 -7067.5 4550 -7067.5 4540 -7067.5 4535 -7067.5 4535 -7072.5 4535 -7092.5 4535 -7097.5 4540 -7097.5 4545 -7097.5 {bezier=1}
P 1 5 4527.5 -7095 4532.5 -7095 4532.5 -7070 4527.5 -7070 4527.5 -7095 {}
P 1 10 4530 -7255 4555 -7255 4565 -7245 4565 -7215 4555 -7205 4505 -7205 4495 -7215 4495 -7245 4505 -7255 4530 -7255 {bezier=1}
P 1 10 4530 -7260 4560 -7260 4570 -7250 4570 -7210 4560 -7200 4500 -7200 4490 -7210 4490 -7250 4500 -7260 4530 -7260 {bezier=1}
P 1 10 4530 -7175 4555 -7175 4565 -7165 4565 -7135 4555 -7125 4505 -7125 4495 -7135 4495 -7165 4505 -7175 4530 -7175 {bezier=1}
P 1 10 4530 -7180 4560 -7180 4570 -7170 4570 -7130 4560 -7120 4500 -7120 4490 -7130 4490 -7170 4500 -7180 4530 -7180 {bezier=1}
P 1 14 5130 -7100 5152.5 -7100 5157.5 -7100 5157.5 -7095 5157.5 -7052.5 5150 -7027.5 5145 -7027.5 5115 -7027.5 5110 -7027.5 5102.5 -7052.5 5102.5 -7095 5102.5 -7100 5107.5 -7100 5130 -7100 {bezier=1}
P 1 14 5145 -7097.5 5150 -7097.5 5155 -7097.5 5155 -7092.5 5155 -7072.5 5155 -7067.5 5150 -7067.5 5140 -7067.5 5135 -7067.5 5135 -7072.5 5135 -7092.5 5135 -7097.5 5140 -7097.5 5145 -7097.5 {bezier=1}
P 1 5 5127.5 -7095 5132.5 -7095 5132.5 -7070 5127.5 -7070 5127.5 -7095 {}
P 1 14 5115 -7097.5 5120 -7097.5 5125 -7097.5 5125 -7092.5 5125 -7072.5 5125 -7067.5 5120 -7067.5 5110 -7067.5 5105 -7067.5 5105 -7072.5 5105 -7092.5 5105 -7097.5 5110 -7097.5 5115 -7097.5 {}
P 1 14 4260 -6720 4282.5 -6720 4287.5 -6720 4287.5 -6715 4287.5 -6672.5 4280 -6647.5 4275 -6647.5 4245 -6647.5 4240 -6647.5 4232.5 -6672.5 4232.5 -6715 4232.5 -6720 4237.5 -6720 4260 -6720 {bezier=1}
P 1 14 4275 -6717.5 4280 -6717.5 4285 -6717.5 4285 -6712.5 4285 -6692.5 4285 -6687.5 4280 -6687.5 4270 -6687.5 4265 -6687.5 4265 -6692.5 4265 -6712.5 4265 -6717.5 4270 -6717.5 4275 -6717.5 {bezier=1}
P 1 5 4257.5 -6715 4262.5 -6715 4262.5 -6690 4257.5 -6690 4257.5 -6715 {}
P 1 10 4260 -6875 4285 -6875 4295 -6865 4295 -6835 4285 -6825 4235 -6825 4225 -6835 4225 -6865 4235 -6875 4260 -6875 {bezier=1}
P 1 10 4260 -6880 4290 -6880 4300 -6870 4300 -6830 4290 -6820 4230 -6820 4220 -6830 4220 -6870 4230 -6880 4260 -6880 {bezier=1}
P 1 10 4260 -6795 4285 -6795 4295 -6785 4295 -6755 4285 -6745 4235 -6745 4225 -6755 4225 -6785 4235 -6795 4260 -6795 {bezier=1}
P 1 10 4260 -6800 4290 -6800 4300 -6790 4300 -6750 4290 -6740 4230 -6740 4220 -6750 4220 -6790 4230 -6800 4260 -6800 {bezier=1}
P 1 14 7740 -7060 7762.5 -7060 7767.5 -7060 7767.5 -7055 7767.5 -7012.5 7760 -6987.5 7755 -6987.5 7725 -6987.5 7720 -6987.5 7712.5 -7012.5 7712.5 -7055 7712.5 -7060 7717.5 -7060 7740 -7060 {bezier=1}
P 1 14 7755 -7057.5 7760 -7057.5 7765 -7057.5 7765 -7052.5 7765 -7032.5 7765 -7027.5 7760 -7027.5 7750 -7027.5 7745 -7027.5 7745 -7032.5 7745 -7052.5 7745 -7057.5 7750 -7057.5 7755 -7057.5 {bezier=1}
P 1 5 7737.5 -7055 7742.5 -7055 7742.5 -7030 7737.5 -7030 7737.5 -7055 {}
P 1 10 7740 -7125 7765 -7125 7775 -7115 7775 -7085 7765 -7075 7715 -7075 7705 -7085 7705 -7115 7715 -7125 7740 -7125 {bezier=1}
P 1 10 7740 -7130 7770 -7130 7780 -7120 7780 -7080 7770 -7070 7710 -7070 7700 -7080 7700 -7120 7710 -7130 7740 -7130 {bezier=1}
P 1 14 7230 -7030 7252.5 -7030 7257.5 -7030 7257.5 -7025 7257.5 -6982.5 7250 -6957.5 7245 -6957.5 7215 -6957.5 7210 -6957.5 7202.5 -6982.5 7202.5 -7025 7202.5 -7030 7207.5 -7030 7230 -7030 {bezier=1}
P 1 14 7245 -7027.5 7250 -7027.5 7255 -7027.5 7255 -7022.5 7255 -7002.5 7255 -6997.5 7250 -6997.5 7240 -6997.5 7235 -6997.5 7235 -7002.5 7235 -7022.5 7235 -7027.5 7240 -7027.5 7245 -7027.5 {bezier=1}
P 1 5 7227.5 -7025 7232.5 -7025 7232.5 -7000 7227.5 -7000 7227.5 -7025 {}
P 1 14 4260 -6360 4282.5 -6360 4287.5 -6360 4287.5 -6355 4287.5 -6312.5 4280 -6287.5 4275 -6287.5 4245 -6287.5 4240 -6287.5 4232.5 -6312.5 4232.5 -6355 4232.5 -6360 4237.5 -6360 4260 -6360 {bezier=1}
P 1 14 4245 -6357.5 4240 -6357.5 4235 -6357.5 4235 -6352.5 4235 -6332.5 4235 -6327.5 4240 -6327.5 4250 -6327.5 4255 -6327.5 4255 -6332.5 4255 -6352.5 4255 -6357.5 4250 -6357.5 4245 -6357.5 {bezier=1}
P 1 5 4257.5 -6355 4262.5 -6355 4262.5 -6330 4257.5 -6330 4257.5 -6355 {}
P 1 10 4260 -6425 4285 -6425 4295 -6415 4295 -6385 4285 -6375 4235 -6375 4225 -6385 4225 -6415 4235 -6425 4260 -6425 {bezier=1}
P 1 10 4260 -6430 4290 -6430 4300 -6420 4300 -6380 4290 -6370 4230 -6370 4220 -6380 4220 -6420 4230 -6430 4260 -6430 {bezier=1}
P 1 14 4790 -6470 4812.5 -6470 4817.5 -6470 4817.5 -6465 4817.5 -6422.5 4810 -6397.5 4805 -6397.5 4775 -6397.5 4770 -6397.5 4762.5 -6422.5 4762.5 -6465 4762.5 -6470 4767.5 -6470 4790 -6470 {bezier=1}
P 1 14 4805 -6467.5 4810 -6467.5 4815 -6467.5 4815 -6462.5 4815 -6442.5 4815 -6437.5 4810 -6437.5 4800 -6437.5 4795 -6437.5 4795 -6442.5 4795 -6462.5 4795 -6467.5 4800 -6467.5 4805 -6467.5 {bezier=1}
P 1 5 4787.5 -6465 4792.5 -6465 4792.5 -6440 4787.5 -6440 4787.5 -6465 {}
P 1 14 4410 -5950 4432.5 -5950 4437.5 -5950 4437.5 -5945 4437.5 -5902.5 4430 -5877.5 4425 -5877.5 4395 -5877.5 4390 -5877.5 4382.5 -5902.5 4382.5 -5945 4382.5 -5950 4387.5 -5950 4410 -5950 {bezier=1}
P 1 14 4425 -5947.5 4430 -5947.5 4435 -5947.5 4435 -5942.5 4435 -5922.5 4435 -5917.5 4430 -5917.5 4420 -5917.5 4415 -5917.5 4415 -5922.5 4415 -5942.5 4415 -5947.5 4420 -5947.5 4425 -5947.5 {bezier=1}
P 1 5 4407.5 -5945 4412.5 -5945 4412.5 -5920 4407.5 -5920 4407.5 -5945 {}
P 1 10 4410 -6015 4435 -6015 4445 -6005 4445 -5975 4435 -5965 4385 -5965 4375 -5975 4375 -6005 4385 -6015 4410 -6015 {bezier=1}
P 1 10 4410 -6020 4440 -6020 4450 -6010 4450 -5970 4440 -5960 4380 -5960 4370 -5970 4370 -6010 4380 -6020 4410 -6020 {bezier=1}
P 1 14 4900 -6010 4922.5 -6010 4927.5 -6010 4927.5 -6005 4927.5 -5962.5 4920 -5937.5 4915 -5937.5 4885 -5937.5 4880 -5937.5 4872.5 -5962.5 4872.5 -6005 4872.5 -6010 4877.5 -6010 4900 -6010 {bezier=1}
P 1 14 4915 -6007.5 4920 -6007.5 4925 -6007.5 4925 -6002.5 4925 -5982.5 4925 -5977.5 4920 -5977.5 4910 -5977.5 4905 -5977.5 4905 -5982.5 4905 -6002.5 4905 -6007.5 4910 -6007.5 4915 -6007.5 {bezier=1}
P 1 5 4897.5 -6005 4902.5 -6005 4902.5 -5980 4897.5 -5980 4897.5 -6005 {}
P 1 14 5430 -6140 5452.5 -6140 5457.5 -6140 5457.5 -6135 5457.5 -6092.5 5450 -6067.5 5445 -6067.5 5415 -6067.5 5410 -6067.5 5402.5 -6092.5 5402.5 -6135 5402.5 -6140 5407.5 -6140 5430 -6140 {bezier=1}
P 1 14 5445 -6137.5 5450 -6137.5 5455 -6137.5 5455 -6132.5 5455 -6112.5 5455 -6107.5 5450 -6107.5 5440 -6107.5 5435 -6107.5 5435 -6112.5 5435 -6132.5 5435 -6137.5 5440 -6137.5 5445 -6137.5 {bezier=1}
P 1 5 5427.5 -6135 5432.5 -6135 5432.5 -6110 5427.5 -6110 5427.5 -6135 {}
P 1 14 5415 -6137.5 5420 -6137.5 5425 -6137.5 5425 -6132.5 5425 -6112.5 5425 -6107.5 5420 -6107.5 5410 -6107.5 5405 -6107.5 5405 -6112.5 5405 -6132.5 5405 -6137.5 5410 -6137.5 5415 -6137.5 {}
P 1 10 7620 -8785 7645 -8785 7655 -8775 7655 -8745 7645 -8735 7595 -8735 7585 -8745 7585 -8775 7595 -8785 7620 -8785 {bezier=1}
P 1 10 7620 -8790 7650 -8790 7660 -8780 7660 -8740 7650 -8730 7590 -8730 7580 -8740 7580 -8780 7590 -8790 7620 -8790 {bezier=1}
P 1 10 7620 -8705 7645 -8705 7655 -8695 7655 -8665 7645 -8655 7595 -8655 7585 -8665 7585 -8695 7595 -8705 7620 -8705 {bezier=1}
P 1 10 7620 -8710 7650 -8710 7660 -8700 7660 -8660 7650 -8650 7590 -8650 7580 -8660 7580 -8700 7590 -8710 7620 -8710 {bezier=1}
P 1 14 990 -8820 1012.5 -8820 1017.5 -8820 1017.5 -8815 1017.5 -8772.5 1010 -8747.5 1005 -8747.5 975 -8747.5 970 -8747.5 962.5 -8772.5 962.5 -8815 962.5 -8820 967.5 -8820 990 -8820 {bezier=1}
P 1 14 1005 -8817.5 1010 -8817.5 1015 -8817.5 1015 -8812.5 1015 -8792.5 1015 -8787.5 1010 -8787.5 1000 -8787.5 995 -8787.5 995 -8792.5 995 -8812.5 995 -8817.5 1000 -8817.5 1005 -8817.5 {bezier=1}
P 1 5 987.5 -8815 992.5 -8815 992.5 -8790 987.5 -8790 987.5 -8815 {}
P 1 10 1080 -8805 1105 -8805 1115 -8795 1115 -8765 1105 -8755 1055 -8755 1045 -8765 1045 -8795 1055 -8805 1080 -8805 {bezier=1}
P 1 10 1080 -8810 1110 -8810 1120 -8800 1120 -8760 1110 -8750 1050 -8750 1040 -8760 1040 -8800 1050 -8810 1080 -8810 {bezier=1}
P 1 14 7230 -6650 7252.5 -6650 7257.5 -6650 7257.5 -6645 7257.5 -6602.5 7250 -6577.5 7245 -6577.5 7215 -6577.5 7210 -6577.5 7202.5 -6602.5 7202.5 -6645 7202.5 -6650 7207.5 -6650 7230 -6650 {bezier=1}
P 1 14 7245 -6647.5 7250 -6647.5 7255 -6647.5 7255 -6642.5 7255 -6622.5 7255 -6617.5 7250 -6617.5 7240 -6617.5 7235 -6617.5 7235 -6622.5 7235 -6642.5 7235 -6647.5 7240 -6647.5 7245 -6647.5 {bezier=1}
P 1 5 7227.5 -6645 7232.5 -6645 7232.5 -6620 7227.5 -6620 7227.5 -6645 {}
P 1 14 7740 -6600 7762.5 -6600 7767.5 -6600 7767.5 -6595 7767.5 -6552.5 7760 -6527.5 7755 -6527.5 7725 -6527.5 7720 -6527.5 7712.5 -6552.5 7712.5 -6595 7712.5 -6600 7717.5 -6600 7740 -6600 {bezier=1}
P 1 14 7755 -6597.5 7760 -6597.5 7765 -6597.5 7765 -6592.5 7765 -6572.5 7765 -6567.5 7760 -6567.5 7750 -6567.5 7745 -6567.5 7745 -6572.5 7745 -6592.5 7745 -6597.5 7750 -6597.5 7755 -6597.5 {bezier=1}
P 1 5 7737.5 -6595 7742.5 -6595 7742.5 -6570 7737.5 -6570 7737.5 -6595 {}
P 1 10 7740 -6745 7765 -6745 7775 -6735 7775 -6705 7765 -6695 7715 -6695 7705 -6705 7705 -6735 7715 -6745 7740 -6745 {bezier=1}
P 1 10 7740 -6750 7770 -6750 7780 -6740 7780 -6700 7770 -6690 7710 -6690 7700 -6700 7700 -6740 7710 -6750 7740 -6750 {bezier=1}
P 1 10 7740 -6675 7765 -6675 7775 -6665 7775 -6635 7765 -6625 7715 -6625 7705 -6635 7705 -6665 7715 -6675 7740 -6675 {bezier=1}
P 1 10 7740 -6680 7770 -6680 7780 -6670 7780 -6630 7770 -6620 7710 -6620 7700 -6630 7700 -6670 7710 -6680 7740 -6680 {bezier=1}
P 1 10 7580 -8485 7605 -8485 7615 -8475 7615 -8445 7605 -8435 7555 -8435 7545 -8445 7545 -8475 7555 -8485 7580 -8485 {bezier=1}
P 1 10 7580 -8490 7610 -8490 7620 -8480 7620 -8440 7610 -8430 7550 -8430 7540 -8440 7540 -8480 7550 -8490 7580 -8490 {bezier=1}
P 1 10 7490 -8055 7515 -8055 7525 -8045 7525 -8015 7515 -8005 7465 -8005 7455 -8015 7455 -8045 7465 -8055 7490 -8055 {bezier=1}
P 1 10 7490 -8060 7520 -8060 7530 -8050 7530 -8010 7520 -8000 7460 -8000 7450 -8010 7450 -8050 7460 -8060 7490 -8060 {bezier=1}
P 1 14 5330 -6390 5352.5 -6390 5357.5 -6390 5357.5 -6385 5357.5 -6342.5 5350 -6317.5 5345 -6317.5 5315 -6317.5 5310 -6317.5 5302.5 -6342.5 5302.5 -6385 5302.5 -6390 5307.5 -6390 5330 -6390 {bezier=1}
P 1 14 5345 -6387.5 5350 -6387.5 5355 -6387.5 5355 -6382.5 5355 -6362.5 5355 -6357.5 5350 -6357.5 5340 -6357.5 5335 -6357.5 5335 -6362.5 5335 -6382.5 5335 -6387.5 5340 -6387.5 5345 -6387.5 {bezier=1}
P 1 5 5327.5 -6385 5332.5 -6385 5332.5 -6360 5327.5 -6360 5327.5 -6385 {}
P 1 10 6950 -7405 6975 -7405 6985 -7395 6985 -7365 6975 -7355 6925 -7355 6915 -7365 6915 -7395 6925 -7405 6950 -7405 {bezier=1}
P 1 10 6950 -7410 6980 -7410 6990 -7400 6990 -7360 6980 -7350 6920 -7350 6910 -7360 6910 -7400 6920 -7410 6950 -7410 {bezier=1}
P 1 14 7480 -7500 7502.5 -7500 7507.5 -7500 7507.5 -7495 7507.5 -7452.5 7500 -7427.5 7495 -7427.5 7465 -7427.5 7460 -7427.5 7452.5 -7452.5 7452.5 -7495 7452.5 -7500 7457.5 -7500 7480 -7500 {bezier=1}
P 1 14 7495 -7497.5 7500 -7497.5 7505 -7497.5 7505 -7492.5 7505 -7472.5 7505 -7467.5 7500 -7467.5 7490 -7467.5 7485 -7467.5 7485 -7472.5 7485 -7492.5 7485 -7497.5 7490 -7497.5 7495 -7497.5 {bezier=1}
P 1 5 7477.5 -7495 7482.5 -7495 7482.5 -7470 7477.5 -7470 7477.5 -7495 {}
P 1 14 6330 -7430 6352.5 -7430 6357.5 -7430 6357.5 -7425 6357.5 -7382.5 6350 -7357.5 6345 -7357.5 6315 -7357.5 6310 -7357.5 6302.5 -7382.5 6302.5 -7425 6302.5 -7430 6307.5 -7430 6330 -7430 {bezier=1}
P 1 14 6345 -7427.5 6350 -7427.5 6355 -7427.5 6355 -7422.5 6355 -7402.5 6355 -7397.5 6350 -7397.5 6340 -7397.5 6335 -7397.5 6335 -7402.5 6335 -7422.5 6335 -7427.5 6340 -7427.5 6345 -7427.5 {bezier=1}
P 1 5 6327.5 -7425 6332.5 -7425 6332.5 -7400 6327.5 -7400 6327.5 -7425 {}
P 1 14 6450 -7430 6472.5 -7430 6477.5 -7430 6477.5 -7425 6477.5 -7382.5 6470 -7357.5 6465 -7357.5 6435 -7357.5 6430 -7357.5 6422.5 -7382.5 6422.5 -7425 6422.5 -7430 6427.5 -7430 6450 -7430 {bezier=1}
P 1 14 6465 -7427.5 6470 -7427.5 6475 -7427.5 6475 -7422.5 6475 -7402.5 6475 -7397.5 6470 -7397.5 6460 -7397.5 6455 -7397.5 6455 -7402.5 6455 -7422.5 6455 -7427.5 6460 -7427.5 6465 -7427.5 {bezier=1}
P 1 5 6447.5 -7425 6452.5 -7425 6452.5 -7400 6447.5 -7400 6447.5 -7425 {}
P 1 10 6450 -7335 6475 -7335 6485 -7325 6485 -7295 6475 -7285 6425 -7285 6415 -7295 6415 -7325 6425 -7335 6450 -7335 {bezier=1}
P 1 10 6450 -7340 6480 -7340 6490 -7330 6490 -7290 6480 -7280 6420 -7280 6410 -7290 6410 -7330 6420 -7340 6450 -7340 {bezier=1}
P 1 14 7310 -6100 7332.5 -6100 7337.5 -6100 7337.5 -6095 7337.5 -6052.5 7330 -6027.5 7325 -6027.5 7295 -6027.5 7290 -6027.5 7282.5 -6052.5 7282.5 -6095 7282.5 -6100 7287.5 -6100 7310 -6100 {bezier=1}
P 1 14 7295 -6097.5 7290 -6097.5 7285 -6097.5 7285 -6092.5 7285 -6072.5 7285 -6067.5 7290 -6067.5 7300 -6067.5 7305 -6067.5 7305 -6072.5 7305 -6092.5 7305 -6097.5 7300 -6097.5 7295 -6097.5 {bezier=1}
P 1 5 7307.5 -6095 7312.5 -6095 7312.5 -6070 7307.5 -6070 7307.5 -6095 {}
P 1 10 7310 -6175 7335 -6175 7345 -6165 7345 -6135 7335 -6125 7285 -6125 7275 -6135 7275 -6165 7285 -6175 7310 -6175 {bezier=1}
P 1 10 7310 -6180 7340 -6180 7350 -6170 7350 -6130 7340 -6120 7280 -6120 7270 -6130 7270 -6170 7280 -6180 7310 -6180 {bezier=1}
P 1 10 7580 -7915 7605 -7915 7615 -7905 7615 -7875 7605 -7865 7555 -7865 7545 -7875 7545 -7905 7555 -7915 7580 -7915 {bezier=1}
P 1 10 7580 -7920 7610 -7920 7620 -7910 7620 -7870 7610 -7860 7550 -7860 7540 -7870 7540 -7910 7550 -7920 7580 -7920 {bezier=1}
P 1 14 3290 -8300 3312.5 -8300 3317.5 -8300 3317.5 -8295 3317.5 -8252.5 3310 -8227.5 3305 -8227.5 3275 -8227.5 3270 -8227.5 3262.5 -8252.5 3262.5 -8295 3262.5 -8300 3267.5 -8300 3290 -8300 {bezier=1}
P 1 14 3305 -8297.5 3310 -8297.5 3315 -8297.5 3315 -8292.5 3315 -8272.5 3315 -8267.5 3310 -8267.5 3300 -8267.5 3295 -8267.5 3295 -8272.5 3295 -8292.5 3295 -8297.5 3300 -8297.5 3305 -8297.5 {bezier=1}
P 1 5 3287.5 -8295 3292.5 -8295 3292.5 -8270 3287.5 -8270 3287.5 -8295 {}
P 1 14 3830 -8480 3852.5 -8480 3857.5 -8480 3857.5 -8475 3857.5 -8432.5 3850 -8407.5 3845 -8407.5 3815 -8407.5 3810 -8407.5 3802.5 -8432.5 3802.5 -8475 3802.5 -8480 3807.5 -8480 3830 -8480 {bezier=1}
P 1 14 3845 -8477.5 3850 -8477.5 3855 -8477.5 3855 -8472.5 3855 -8452.5 3855 -8447.5 3850 -8447.5 3840 -8447.5 3835 -8447.5 3835 -8452.5 3835 -8472.5 3835 -8477.5 3840 -8477.5 3845 -8477.5 {bezier=1}
P 1 5 3827.5 -8475 3832.5 -8475 3832.5 -8450 3827.5 -8450 3827.5 -8475 {}
P 1 14 4840 -8270 4862.5 -8270 4867.5 -8270 4867.5 -8265 4867.5 -8222.5 4860 -8197.5 4855 -8197.5 4825 -8197.5 4820 -8197.5 4812.5 -8222.5 4812.5 -8265 4812.5 -8270 4817.5 -8270 4840 -8270 {bezier=1}
P 1 14 4855 -8267.5 4860 -8267.5 4865 -8267.5 4865 -8262.5 4865 -8242.5 4865 -8237.5 4860 -8237.5 4850 -8237.5 4845 -8237.5 4845 -8242.5 4845 -8262.5 4845 -8267.5 4850 -8267.5 4855 -8267.5 {bezier=1}
P 1 5 4837.5 -8265 4842.5 -8265 4842.5 -8240 4837.5 -8240 4837.5 -8265 {}
P 1 14 5410 -8270 5432.5 -8270 5437.5 -8270 5437.5 -8265 5437.5 -8222.5 5430 -8197.5 5425 -8197.5 5395 -8197.5 5390 -8197.5 5382.5 -8222.5 5382.5 -8265 5382.5 -8270 5387.5 -8270 5410 -8270 {bezier=1}
P 1 14 5425 -8267.5 5430 -8267.5 5435 -8267.5 5435 -8262.5 5435 -8242.5 5435 -8237.5 5430 -8237.5 5420 -8237.5 5415 -8237.5 5415 -8242.5 5415 -8262.5 5415 -8267.5 5420 -8267.5 5425 -8267.5 {bezier=1}
P 1 5 5407.5 -8265 5412.5 -8265 5412.5 -8240 5407.5 -8240 5407.5 -8265 {}
P 1 14 2280 -5860 2302.5 -5860 2307.5 -5860 2307.5 -5855 2307.5 -5812.5 2300 -5787.5 2295 -5787.5 2265 -5787.5 2260 -5787.5 2252.5 -5812.5 2252.5 -5855 2252.5 -5860 2257.5 -5860 2280 -5860 {bezier=1}
P 1 14 2295 -5857.5 2300 -5857.5 2305 -5857.5 2305 -5852.5 2305 -5832.5 2305 -5827.5 2300 -5827.5 2290 -5827.5 2285 -5827.5 2285 -5832.5 2285 -5852.5 2285 -5857.5 2290 -5857.5 2295 -5857.5 {bezier=1}
P 1 5 2277.5 -5855 2282.5 -5855 2282.5 -5830 2277.5 -5830 2277.5 -5855 {}
P 1 10 2370 -5845 2395 -5845 2405 -5835 2405 -5805 2395 -5795 2345 -5795 2335 -5805 2335 -5835 2345 -5845 2370 -5845 {bezier=1}
P 1 10 2370 -5850 2400 -5850 2410 -5840 2410 -5800 2400 -5790 2340 -5790 2330 -5800 2330 -5840 2340 -5850 2370 -5850 {bezier=1}
P 1 14 4810 -6720 4832.5 -6720 4837.5 -6720 4837.5 -6715 4837.5 -6672.5 4830 -6647.5 4825 -6647.5 4795 -6647.5 4790 -6647.5 4782.5 -6672.5 4782.5 -6715 4782.5 -6720 4787.5 -6720 4810 -6720 {bezier=1}
P 1 14 4825 -6717.5 4830 -6717.5 4835 -6717.5 4835 -6712.5 4835 -6692.5 4835 -6687.5 4830 -6687.5 4820 -6687.5 4815 -6687.5 4815 -6692.5 4815 -6712.5 4815 -6717.5 4820 -6717.5 4825 -6717.5 {bezier=1}
P 1 5 4807.5 -6715 4812.5 -6715 4812.5 -6690 4807.5 -6690 4807.5 -6715 {}
P 1 10 4810 -6875 4835 -6875 4845 -6865 4845 -6835 4835 -6825 4785 -6825 4775 -6835 4775 -6865 4785 -6875 4810 -6875 {bezier=1}
P 1 10 4810 -6880 4840 -6880 4850 -6870 4850 -6830 4840 -6820 4780 -6820 4770 -6830 4770 -6870 4780 -6880 4810 -6880 {bezier=1}
P 1 10 4810 -6795 4835 -6795 4845 -6785 4845 -6755 4835 -6745 4785 -6745 4775 -6755 4775 -6785 4785 -6795 4810 -6795 {bezier=1}
P 1 10 4810 -6800 4840 -6800 4850 -6790 4850 -6750 4840 -6740 4780 -6740 4770 -6750 4770 -6790 4780 -6800 4810 -6800 {bezier=1}
P 1 14 8000 -8090 8022.5 -8090 8027.5 -8090 8027.5 -8085 8027.5 -8042.5 8020 -8017.5 8015 -8017.5 7985 -8017.5 7980 -8017.5 7972.5 -8042.5 7972.5 -8085 7972.5 -8090 7977.5 -8090 8000 -8090 {bezier=1}
P 1 14 8015 -8087.5 8020 -8087.5 8025 -8087.5 8025 -8082.5 8025 -8062.5 8025 -8057.5 8020 -8057.5 8010 -8057.5 8005 -8057.5 8005 -8062.5 8005 -8082.5 8005 -8087.5 8010 -8087.5 8015 -8087.5 {bezier=1}
P 1 5 7997.5 -8085 8002.5 -8085 8002.5 -8060 7997.5 -8060 7997.5 -8085 {}
P 1 14 6470 -8210 6492.5 -8210 6497.5 -8210 6497.5 -8205 6497.5 -8162.5 6490 -8137.5 6485 -8137.5 6455 -8137.5 6450 -8137.5 6442.5 -8162.5 6442.5 -8205 6442.5 -8210 6447.5 -8210 6470 -8210 {bezier=1}
P 1 14 6485 -8207.5 6490 -8207.5 6495 -8207.5 6495 -8202.5 6495 -8182.5 6495 -8177.5 6490 -8177.5 6480 -8177.5 6475 -8177.5 6475 -8182.5 6475 -8202.5 6475 -8207.5 6480 -8207.5 6485 -8207.5 {bezier=1}
P 1 5 6467.5 -8205 6472.5 -8205 6472.5 -8180 6467.5 -8180 6467.5 -8205 {}
P 1 14 7010 -8190 7032.5 -8190 7037.5 -8190 7037.5 -8185 7037.5 -8142.5 7030 -8117.5 7025 -8117.5 6995 -8117.5 6990 -8117.5 6982.5 -8142.5 6982.5 -8185 6982.5 -8190 6987.5 -8190 7010 -8190 {bezier=1}
P 1 14 7025 -8187.5 7030 -8187.5 7035 -8187.5 7035 -8182.5 7035 -8162.5 7035 -8157.5 7030 -8157.5 7020 -8157.5 7015 -8157.5 7015 -8162.5 7015 -8182.5 7015 -8187.5 7020 -8187.5 7025 -8187.5 {bezier=1}
P 1 5 7007.5 -8185 7012.5 -8185 7012.5 -8160 7007.5 -8160 7007.5 -8185 {}
P 1 14 6920 -7810 6942.5 -7810 6947.5 -7810 6947.5 -7805 6947.5 -7762.5 6940 -7737.5 6935 -7737.5 6905 -7737.5 6900 -7737.5 6892.5 -7762.5 6892.5 -7805 6892.5 -7810 6897.5 -7810 6920 -7810 {bezier=1}
P 1 14 6935 -7807.5 6940 -7807.5 6945 -7807.5 6945 -7802.5 6945 -7782.5 6945 -7777.5 6940 -7777.5 6930 -7777.5 6925 -7777.5 6925 -7782.5 6925 -7802.5 6925 -7807.5 6930 -7807.5 6935 -7807.5 {bezier=1}
P 1 5 6917.5 -7805 6922.5 -7805 6922.5 -7780 6917.5 -7780 6917.5 -7805 {}
P 1 14 8180 -7760 8202.5 -7760 8207.5 -7760 8207.5 -7755 8207.5 -7712.5 8200 -7687.5 8195 -7687.5 8165 -7687.5 8160 -7687.5 8152.5 -7712.5 8152.5 -7755 8152.5 -7760 8157.5 -7760 8180 -7760 {bezier=1}
P 1 14 8195 -7757.5 8200 -7757.5 8205 -7757.5 8205 -7752.5 8205 -7732.5 8205 -7727.5 8200 -7727.5 8190 -7727.5 8185 -7727.5 8185 -7732.5 8185 -7752.5 8185 -7757.5 8190 -7757.5 8195 -7757.5 {bezier=1}
P 1 5 8177.5 -7755 8182.5 -7755 8182.5 -7730 8177.5 -7730 8177.5 -7755 {}
P 1 14 8140 -6350 8162.5 -6350 8167.5 -6350 8167.5 -6345 8167.5 -6302.5 8160 -6277.5 8155 -6277.5 8125 -6277.5 8120 -6277.5 8112.5 -6302.5 8112.5 -6345 8112.5 -6350 8117.5 -6350 8140 -6350 {bezier=1}
P 1 14 8125 -6347.5 8120 -6347.5 8115 -6347.5 8115 -6342.5 8115 -6322.5 8115 -6317.5 8120 -6317.5 8130 -6317.5 8135 -6317.5 8135 -6322.5 8135 -6342.5 8135 -6347.5 8130 -6347.5 8125 -6347.5 {bezier=1}
P 1 5 8137.5 -6345 8142.5 -6345 8142.5 -6320 8137.5 -6320 8137.5 -6345 {}
P 2 7 897.5 -5980 893.75 -5985 885 -5985 888.75 -5980 885 -5975 893.75 -5975 897.5 -5980 {fill=true}
P 2 7 1437.5 -5980 1433.75 -5985 1425 -5985 1428.75 -5980 1425 -5975 1433.75 -5975 1437.5 -5980 {fill=true}
P 2 7 2277.5 -5980 2273.75 -5985 2265 -5985 2268.75 -5980 2265 -5975 2273.75 -5975 2277.5 -5980 {fill=true}
P 2 7 7690 -7080 7680 -7090 7690 -7090 7690 -7090 7670 -7100 7680 -7080 7680 -7090 {}
P 2 7 7180 -6980 7170 -6990 7180 -6990 7180 -6990 7160 -7000 7170 -6980 7170 -6990 {}
P 2 7 7690 -6700 7680 -6710 7690 -6710 7690 -6710 7670 -6720 7680 -6700 7680 -6710 {}
P 2 7 7180 -6600 7170 -6610 7180 -6610 7180 -6610 7160 -6620 7170 -6600 7170 -6610 {}
P 3 6 6940 -7660 6940 -7670 6930 -7670 6940 -7690 6950 -7670 6940 -7670 {}
P 3 6 6400 -7660 6400 -7670 6390 -7670 6400 -7690 6410 -7670 6400 -7670 {}
P 5 7 1105 -8220 1101.25 -8225 1092.5 -8225 1096.25 -8220 1092.5 -8215 1101.25 -8215 1105 -8220 {fill=true}
P 5 7 1427.5 -8250 1423.75 -8255 1415 -8255 1418.75 -8250 1415 -8245 1423.75 -8245 1427.5 -8250 {fill=true}
P 5 7 1645 -8220 1641.25 -8225 1632.5 -8225 1636.25 -8220 1632.5 -8215 1641.25 -8215 1645 -8220 {fill=true}
P 5 7 1967.5 -8250 1963.75 -8255 1955 -8255 1958.75 -8250 1955 -8245 1963.75 -8245 1967.5 -8250 {fill=true}
P 5 7 575 -8220 571.25 -8225 562.5 -8225 566.25 -8220 562.5 -8215 571.25 -8215 575 -8220 {fill=true}
P 5 7 897.5 -8250 893.75 -8255 885 -8255 888.75 -8250 885 -8245 893.75 -8245 897.5 -8250 {fill=true}
P 5 7 575 -7760 571.25 -7765 562.5 -7765 566.25 -7760 562.5 -7755 571.25 -7755 575 -7760 {fill=true}
P 5 7 897.5 -7790 893.75 -7795 885 -7795 888.75 -7790 885 -7785 893.75 -7785 897.5 -7790 {fill=true}
P 5 7 1115 -7760 1111.25 -7765 1102.5 -7765 1106.25 -7760 1102.5 -7755 1111.25 -7755 1115 -7760 {fill=true}
P 5 7 1437.5 -7790 1433.75 -7795 1425 -7795 1428.75 -7790 1425 -7785 1433.75 -7785 1437.5 -7790 {fill=true}
P 5 7 575 -6930 571.25 -6935 562.5 -6935 566.25 -6930 562.5 -6925 571.25 -6925 575 -6930 {fill=true}
P 5 7 897.5 -6960 893.75 -6965 885 -6965 888.75 -6960 885 -6955 893.75 -6955 897.5 -6960 {fill=true}
P 5 7 1115 -6930 1111.25 -6935 1102.5 -6935 1106.25 -6930 1102.5 -6925 1111.25 -6925 1115 -6930 {fill=true}
P 5 7 1437.5 -6960 1433.75 -6965 1425 -6965 1428.75 -6960 1425 -6955 1433.75 -6955 1437.5 -6960 {fill=true}
P 5 7 575 -6440 571.25 -6445 562.5 -6445 566.25 -6440 562.5 -6435 571.25 -6435 575 -6440 {fill=true}
P 5 7 897.5 -6470 893.75 -6475 885 -6475 888.75 -6470 885 -6465 893.75 -6465 897.5 -6470 {fill=true}
P 5 7 1115 -6440 1111.25 -6445 1102.5 -6445 1106.25 -6440 1102.5 -6435 1111.25 -6435 1115 -6440 {fill=true}
P 5 7 1437.5 -6470 1433.75 -6475 1425 -6475 1428.75 -6470 1425 -6465 1433.75 -6465 1437.5 -6470 {fill=true}
P 5 7 575 -5950 571.25 -5955 562.5 -5955 566.25 -5950 562.5 -5945 571.25 -5945 575 -5950 {fill=true}
P 5 7 1765 -5950 1761.25 -5955 1752.5 -5955 1756.25 -5950 1752.5 -5945 1761.25 -5945 1765 -5950 {fill=true}
P 5 7 1115 -5950 1111.25 -5955 1102.5 -5955 1106.25 -5950 1102.5 -5945 1111.25 -5945 1115 -5950 {fill=true}
P 5 7 1105 -7390 1101.25 -7395 1092.5 -7395 1096.25 -7390 1092.5 -7385 1101.25 -7385 1105 -7390 {fill=true}
P 5 7 1427.5 -7420 1423.75 -7425 1415 -7425 1418.75 -7420 1415 -7415 1423.75 -7415 1427.5 -7420 {fill=true}
P 5 7 575 -7390 571.25 -7395 562.5 -7395 566.25 -7390 562.5 -7385 571.25 -7385 575 -7390 {fill=true}
P 5 7 897.5 -7420 893.75 -7425 885 -7425 888.75 -7420 885 -7415 893.75 -7415 897.5 -7420 {fill=true}
P 5 7 1605 -7390 1601.25 -7395 1592.5 -7395 1596.25 -7390 1592.5 -7385 1601.25 -7385 1605 -7390 {fill=true}
P 5 7 1927.5 -7420 1923.75 -7425 1915 -7425 1918.75 -7420 1915 -7415 1923.75 -7415 1927.5 -7420 {fill=true}
P 5 7 1645 -8690 1641.25 -8695 1632.5 -8695 1636.25 -8690 1632.5 -8685 1641.25 -8685 1645 -8690 {fill=true}
P 5 7 1967.5 -8720 1963.75 -8725 1955 -8725 1958.75 -8720 1955 -8715 1963.75 -8715 1967.5 -8720 {fill=true}
P 5 7 575 -8690 571.25 -8695 562.5 -8695 566.25 -8690 562.5 -8685 571.25 -8685 575 -8690 {fill=true}
P 5 7 897.5 -8720 893.75 -8725 885 -8725 888.75 -8720 885 -8715 893.75 -8715 897.5 -8720 {fill=true}
P 5 7 2105 -8690 2101.25 -8695 2092.5 -8695 2096.25 -8690 2092.5 -8685 2101.25 -8685 2105 -8690 {fill=true}
P 5 7 2427.5 -8720 2423.75 -8725 2415 -8725 2418.75 -8720 2415 -8715 2423.75 -8715 2427.5 -8720 {fill=true}
P 5 7 3425 -8710 3421.25 -8715 3412.5 -8715 3416.25 -8710 3412.5 -8705 3421.25 -8705 3425 -8710 {fill=true}
P 5 7 3747.5 -8740 3743.75 -8745 3735 -8745 3738.75 -8740 3735 -8735 3743.75 -8735 3747.5 -8740 {fill=true}
P 5 7 3965 -8710 3961.25 -8715 3952.5 -8715 3956.25 -8710 3952.5 -8705 3961.25 -8705 3965 -8710 {fill=true}
P 5 7 4287.5 -8740 4283.75 -8745 4275 -8745 4278.75 -8740 4275 -8735 4283.75 -8735 4287.5 -8740 {fill=true}
P 5 7 4525 -8710 4521.25 -8715 4512.5 -8715 4516.25 -8710 4512.5 -8705 4521.25 -8705 4525 -8710 {fill=true}
P 5 7 4847.5 -8740 4843.75 -8745 4835 -8745 4838.75 -8740 4835 -8735 4843.75 -8735 4847.5 -8740 {fill=true}
P 5 7 5095 -8710 5091.25 -8715 5082.5 -8715 5086.25 -8710 5082.5 -8705 5091.25 -8705 5095 -8710 {fill=true}
P 5 7 5417.5 -8740 5413.75 -8745 5405 -8745 5408.75 -8740 5405 -8735 5413.75 -8735 5417.5 -8740 {fill=true}
P 5 7 3425 -7910 3421.25 -7915 3412.5 -7915 3416.25 -7910 3412.5 -7905 3421.25 -7905 3425 -7910 {fill=true}
P 5 7 3747.5 -7940 3743.75 -7945 3735 -7945 3738.75 -7940 3735 -7935 3743.75 -7935 3747.5 -7940 {fill=true}
P 5 7 3965 -7910 3961.25 -7915 3952.5 -7915 3956.25 -7910 3952.5 -7905 3961.25 -7905 3965 -7910 {fill=true}
P 5 7 4287.5 -7940 4283.75 -7945 4275 -7945 4278.75 -7940 4275 -7935 4283.75 -7935 4287.5 -7940 {fill=true}
P 5 7 5095 -7910 5091.25 -7915 5082.5 -7915 5086.25 -7910 5082.5 -7905 5091.25 -7905 5095 -7910 {fill=true}
P 5 7 5417.5 -7940 5413.75 -7945 5405 -7945 5408.75 -7940 5405 -7935 5413.75 -7935 5417.5 -7940 {fill=true}
P 5 7 3425 -8330 3421.25 -8335 3412.5 -8335 3416.25 -8330 3412.5 -8325 3421.25 -8325 3425 -8330 {fill=true}
P 5 7 3747.5 -8360 3743.75 -8365 3735 -8365 3738.75 -8360 3735 -8355 3743.75 -8355 3747.5 -8360 {fill=true}
P 5 7 3425 -7500 3421.25 -7505 3412.5 -7505 3416.25 -7500 3412.5 -7495 3421.25 -7495 3425 -7500 {fill=true}
P 5 7 3747.5 -7530 3743.75 -7535 3735 -7535 3738.75 -7530 3735 -7525 3743.75 -7525 3747.5 -7530 {fill=true}
P 5 7 4525 -7500 4521.25 -7505 4512.5 -7505 4516.25 -7500 4512.5 -7495 4521.25 -7495 4525 -7500 {fill=true}
P 5 7 4847.5 -7530 4843.75 -7535 4835 -7535 4838.75 -7530 4835 -7525 4843.75 -7525 4847.5 -7530 {fill=true}
P 5 7 3965 -7500 3961.25 -7505 3952.5 -7505 3956.25 -7500 3952.5 -7495 3961.25 -7495 3965 -7500 {fill=true}
P 5 7 4287.5 -7530 4283.75 -7535 4275 -7535 4278.75 -7530 4275 -7525 4283.75 -7525 4287.5 -7530 {fill=true}
P 5 7 1105 -8690 1101.25 -8695 1092.5 -8695 1096.25 -8690 1092.5 -8685 1101.25 -8685 1105 -8690 {fill=true}
P 5 7 1427.5 -8720 1423.75 -8725 1415 -8725 1418.75 -8720 1415 -8715 1423.75 -8715 1427.5 -8720 {fill=true}
P 5 7 6315 -6200 6311.25 -6205 6302.5 -6205 6306.25 -6200 6302.5 -6195 6311.25 -6195 6315 -6200 {fill=true}
P 5 7 6637.5 -6230 6633.75 -6235 6625 -6235 6628.75 -6230 6625 -6225 6633.75 -6225 6637.5 -6230 {fill=true}
P 5 7 6965 -6200 6961.25 -6205 6952.5 -6205 6956.25 -6200 6952.5 -6195 6961.25 -6195 6965 -6200 {fill=true}
P 5 7 7287.5 -6230 7283.75 -6235 7275 -6235 7278.75 -6230 7275 -6225 7283.75 -6225 7287.5 -6230 {fill=true}
P 5 7 3965 -8330 3961.25 -8335 3952.5 -8335 3956.25 -8330 3952.5 -8325 3961.25 -8325 3965 -8330 {fill=true}
P 5 7 4287.5 -8360 4283.75 -8365 4275 -8365 4278.75 -8360 4275 -8355 4283.75 -8355 4287.5 -8360 {fill=true}
P 5 7 4525 -8330 4521.25 -8335 4512.5 -8335 4516.25 -8330 4512.5 -8325 4521.25 -8325 4525 -8330 {fill=true}
P 5 7 4847.5 -8360 4843.75 -8365 4835 -8365 4838.75 -8360 4835 -8355 4843.75 -8355 4847.5 -8360 {fill=true}
P 5 7 5095 -8330 5091.25 -8335 5082.5 -8335 5086.25 -8330 5082.5 -8325 5091.25 -8325 5095 -8330 {fill=true}
P 5 7 5417.5 -8360 5413.75 -8365 5405 -8365 5408.75 -8360 5405 -8355 5413.75 -8355 5417.5 -8360 {fill=true}
P 5 7 7525 -6200 7521.25 -6205 7512.5 -6205 7516.25 -6200 7512.5 -6195 7521.25 -6195 7525 -6200 {fill=true}
P 5 7 7847.5 -6230 7843.75 -6235 7835 -6235 7838.75 -6230 7835 -6225 7843.75 -6225 7847.5 -6230 {fill=true}
P 7 14 905 -8077.5 910 -8077.5 915 -8077.5 915 -8072.5 915 -8052.5 915 -8047.5 910 -8047.5 900 -8047.5 895 -8047.5 895 -8052.5 895 -8072.5 895 -8077.5 900 -8077.5 905 -8077.5 {fill=1
bezier=1}
P 7 14 1335 -8077.5 1340 -8077.5 1345 -8077.5 1345 -8072.5 1345 -8052.5 1345 -8047.5 1340 -8047.5 1330 -8047.5 1325 -8047.5 1325 -8052.5 1325 -8072.5 1325 -8077.5 1330 -8077.5 1335 -8077.5 {fill=1
bezier=1}
P 7 14 1405 -7887.5 1410 -7887.5 1415 -7887.5 1415 -7882.5 1415 -7862.5 1415 -7857.5 1410 -7857.5 1400 -7857.5 1395 -7857.5 1395 -7862.5 1395 -7882.5 1395 -7887.5 1400 -7887.5 1405 -7887.5 {fill=1
bezier=1}
P 7 14 1425 -7067.5 1430 -7067.5 1435 -7067.5 1435 -7062.5 1435 -7042.5 1435 -7037.5 1430 -7037.5 1420 -7037.5 1415 -7037.5 1415 -7042.5 1415 -7062.5 1415 -7067.5 1420 -7067.5 1425 -7067.5 {fill=1
bezier=1}
P 7 14 1425 -6577.5 1430 -6577.5 1435 -6577.5 1435 -6572.5 1435 -6552.5 1435 -6547.5 1430 -6547.5 1420 -6547.5 1415 -6547.5 1415 -6552.5 1415 -6572.5 1415 -6577.5 1420 -6577.5 1425 -6577.5 {fill=1
bezier=1}
P 7 14 935 -5847.5 940 -5847.5 945 -5847.5 945 -5842.5 945 -5822.5 945 -5817.5 940 -5817.5 930 -5817.5 925 -5817.5 925 -5822.5 925 -5842.5 925 -5847.5 930 -5847.5 935 -5847.5 {fill=1
bezier=1}
P 7 14 1415 -5857.5 1420 -5857.5 1425 -5857.5 1425 -5852.5 1425 -5832.5 1425 -5827.5 1420 -5827.5 1410 -5827.5 1405 -5827.5 1405 -5832.5 1405 -5852.5 1405 -5857.5 1410 -5857.5 1415 -5857.5 {fill=1
bezier=1}
P 7 14 905 -7247.5 910 -7247.5 915 -7247.5 915 -7242.5 915 -7222.5 915 -7217.5 910 -7217.5 900 -7217.5 895 -7217.5 895 -7222.5 895 -7242.5 895 -7247.5 900 -7247.5 905 -7247.5 {fill=1
bezier=1}
P 7 14 1335 -7247.5 1340 -7247.5 1345 -7247.5 1345 -7242.5 1345 -7222.5 1345 -7217.5 1340 -7217.5 1330 -7217.5 1325 -7217.5 1325 -7222.5 1325 -7242.5 1325 -7247.5 1330 -7247.5 1335 -7247.5 {fill=1}
P 7 14 905 -8547.5 910 -8547.5 915 -8547.5 915 -8542.5 915 -8522.5 915 -8517.5 910 -8517.5 900 -8517.5 895 -8517.5 895 -8522.5 895 -8542.5 895 -8547.5 900 -8547.5 905 -8547.5 {fill=1
bezier=1}
P 7 14 1615 -8537.5 1620 -8537.5 1625 -8537.5 1625 -8532.5 1625 -8512.5 1625 -8507.5 1620 -8507.5 1610 -8507.5 1605 -8507.5 1605 -8512.5 1605 -8532.5 1605 -8537.5 1610 -8537.5 1615 -8537.5 {fill=1
bezier=1}
P 7 14 2395 -8527.5 2400 -8527.5 2405 -8527.5 2405 -8522.5 2405 -8502.5 2405 -8497.5 2400 -8497.5 2390 -8497.5 2385 -8497.5 2385 -8502.5 2385 -8522.5 2385 -8527.5 2390 -8527.5 2395 -8527.5 {fill=1
bezier=1}
P 7 14 4305 -8857.5 4310 -8857.5 4315 -8857.5 4315 -8852.5 4315 -8832.5 4315 -8827.5 4310 -8827.5 4300 -8827.5 4295 -8827.5 4295 -8832.5 4295 -8852.5 4295 -8857.5 4300 -8857.5 4305 -8857.5 {fill=1
bezier=1}
P 7 14 4755 -8927.5 4760 -8927.5 4765 -8927.5 4765 -8922.5 4765 -8902.5 4765 -8897.5 4760 -8897.5 4750 -8897.5 4745 -8897.5 4745 -8902.5 4745 -8922.5 4745 -8927.5 4750 -8927.5 4755 -8927.5 {fill=1
bezier=1}
P 7 14 3505 -8027.5 3510 -8027.5 3515 -8027.5 3515 -8022.5 3515 -8002.5 3515 -7997.5 3510 -7997.5 3500 -7997.5 3495 -7997.5 3495 -8002.5 3495 -8022.5 3495 -8027.5 3500 -8027.5 3505 -8027.5 {fill=1
bezier=1}
P 7 14 4165 -8047.5 4170 -8047.5 4175 -8047.5 4175 -8042.5 4175 -8022.5 4175 -8017.5 4170 -8017.5 4160 -8017.5 4155 -8017.5 4155 -8022.5 4155 -8042.5 4155 -8047.5 4160 -8047.5 4165 -8047.5 {fill=1
bezier=1}
P 7 14 3665 -7667.5 3670 -7667.5 3675 -7667.5 3675 -7662.5 3675 -7642.5 3675 -7637.5 3670 -7637.5 3660 -7637.5 3655 -7637.5 3655 -7642.5 3655 -7662.5 3655 -7667.5 3660 -7667.5 3665 -7667.5 {fill=1}
P 7 14 4065 -7617.5 4070 -7617.5 4075 -7617.5 4075 -7612.5 4075 -7592.5 4075 -7587.5 4070 -7587.5 4060 -7587.5 4055 -7587.5 4055 -7592.5 4055 -7612.5 4055 -7617.5 4060 -7617.5 4065 -7617.5 {fill=1
bezier=1}
P 7 14 4245 -7097.5 4250 -7097.5 4255 -7097.5 4255 -7092.5 4255 -7072.5 4255 -7067.5 4250 -7067.5 4240 -7067.5 4235 -7067.5 4235 -7072.5 4235 -7092.5 4235 -7097.5 4240 -7097.5 4245 -7097.5 {fill=1
bezier=1}
P 7 14 4515 -7097.5 4520 -7097.5 4525 -7097.5 4525 -7092.5 4525 -7072.5 4525 -7067.5 4520 -7067.5 4510 -7067.5 4505 -7067.5 4505 -7072.5 4505 -7092.5 4505 -7097.5 4510 -7097.5 4515 -7097.5 {fill=1
bezier=1}
P 7 14 4245 -6717.5 4250 -6717.5 4255 -6717.5 4255 -6712.5 4255 -6692.5 4255 -6687.5 4250 -6687.5 4240 -6687.5 4235 -6687.5 4235 -6692.5 4235 -6712.5 4235 -6717.5 4240 -6717.5 4245 -6717.5 {fill=1
bezier=1}
P 7 14 7725 -7057.5 7730 -7057.5 7735 -7057.5 7735 -7052.5 7735 -7032.5 7735 -7027.5 7730 -7027.5 7720 -7027.5 7715 -7027.5 7715 -7032.5 7715 -7052.5 7715 -7057.5 7720 -7057.5 7725 -7057.5 {fill=1
bezier=1}
P 7 14 7215 -7027.5 7220 -7027.5 7225 -7027.5 7225 -7022.5 7225 -7002.5 7225 -6997.5 7220 -6997.5 7210 -6997.5 7205 -6997.5 7205 -7002.5 7205 -7022.5 7205 -7027.5 7210 -7027.5 7215 -7027.5 {fill=1
bezier=1}
P 7 14 4275 -6357.5 4270 -6357.5 4265 -6357.5 4265 -6352.5 4265 -6332.5 4265 -6327.5 4270 -6327.5 4280 -6327.5 4285 -6327.5 4285 -6332.5 4285 -6352.5 4285 -6357.5 4280 -6357.5 4275 -6357.5 {fill=1
bezier=1}
P 7 14 4775 -6467.5 4780 -6467.5 4785 -6467.5 4785 -6462.5 4785 -6442.5 4785 -6437.5 4780 -6437.5 4770 -6437.5 4765 -6437.5 4765 -6442.5 4765 -6462.5 4765 -6467.5 4770 -6467.5 4775 -6467.5 {fill=1
bezier=1}
P 7 14 4395 -5947.5 4400 -5947.5 4405 -5947.5 4405 -5942.5 4405 -5922.5 4405 -5917.5 4400 -5917.5 4390 -5917.5 4385 -5917.5 4385 -5922.5 4385 -5942.5 4385 -5947.5 4390 -5947.5 4395 -5947.5 {fill=1
bezier=1}
P 7 14 4885 -6007.5 4890 -6007.5 4895 -6007.5 4895 -6002.5 4895 -5982.5 4895 -5977.5 4890 -5977.5 4880 -5977.5 4875 -5977.5 4875 -5982.5 4875 -6002.5 4875 -6007.5 4880 -6007.5 4885 -6007.5 {fill=1
bezier=1}
P 7 14 4625 -7647.5 4630 -7647.5 4635 -7647.5 4635 -7642.5 4635 -7622.5 4635 -7617.5 4630 -7617.5 4620 -7617.5 4615 -7617.5 4615 -7622.5 4615 -7642.5 4615 -7647.5 4620 -7647.5 4625 -7647.5 {}
P 7 14 975 -8817.5 980 -8817.5 985 -8817.5 985 -8812.5 985 -8792.5 985 -8787.5 980 -8787.5 970 -8787.5 965 -8787.5 965 -8792.5 965 -8812.5 965 -8817.5 970 -8817.5 975 -8817.5 {fill=1
bezier=1}
P 7 14 7215 -6647.5 7220 -6647.5 7225 -6647.5 7225 -6642.5 7225 -6622.5 7225 -6617.5 7220 -6617.5 7210 -6617.5 7205 -6617.5 7205 -6622.5 7205 -6642.5 7205 -6647.5 7210 -6647.5 7215 -6647.5 {fill=1
bezier=1}
P 7 14 7725 -6597.5 7730 -6597.5 7735 -6597.5 7735 -6592.5 7735 -6572.5 7735 -6567.5 7730 -6567.5 7720 -6567.5 7715 -6567.5 7715 -6572.5 7715 -6592.5 7715 -6597.5 7720 -6597.5 7725 -6597.5 {fill=1
bezier=1}
P 7 14 5315 -6387.5 5320 -6387.5 5325 -6387.5 5325 -6382.5 5325 -6362.5 5325 -6357.5 5320 -6357.5 5310 -6357.5 5305 -6357.5 5305 -6362.5 5305 -6382.5 5305 -6387.5 5310 -6387.5 5315 -6387.5 {fill=1
bezier=1}
P 7 14 7465 -7497.5 7470 -7497.5 7475 -7497.5 7475 -7492.5 7475 -7472.5 7475 -7467.5 7470 -7467.5 7460 -7467.5 7455 -7467.5 7455 -7472.5 7455 -7492.5 7455 -7497.5 7460 -7497.5 7465 -7497.5 {fill=1
bezier=1}
P 7 14 6315 -7427.5 6320 -7427.5 6325 -7427.5 6325 -7422.5 6325 -7402.5 6325 -7397.5 6320 -7397.5 6310 -7397.5 6305 -7397.5 6305 -7402.5 6305 -7422.5 6305 -7427.5 6310 -7427.5 6315 -7427.5 {fill=1
bezier=1}
P 7 14 6435 -7427.5 6440 -7427.5 6445 -7427.5 6445 -7422.5 6445 -7402.5 6445 -7397.5 6440 -7397.5 6430 -7397.5 6425 -7397.5 6425 -7402.5 6425 -7422.5 6425 -7427.5 6430 -7427.5 6435 -7427.5 {fill=1
bezier=1}
P 7 14 7325 -6097.5 7320 -6097.5 7315 -6097.5 7315 -6092.5 7315 -6072.5 7315 -6067.5 7320 -6067.5 7330 -6067.5 7335 -6067.5 7335 -6072.5 7335 -6092.5 7335 -6097.5 7330 -6097.5 7325 -6097.5 {fill=1
bezier=1}
P 7 14 3275 -8297.5 3280 -8297.5 3285 -8297.5 3285 -8292.5 3285 -8272.5 3285 -8267.5 3280 -8267.5 3270 -8267.5 3265 -8267.5 3265 -8272.5 3265 -8292.5 3265 -8297.5 3270 -8297.5 3275 -8297.5 {fill=1
bezier=1}
P 7 14 3815 -8477.5 3820 -8477.5 3825 -8477.5 3825 -8472.5 3825 -8452.5 3825 -8447.5 3820 -8447.5 3810 -8447.5 3805 -8447.5 3805 -8452.5 3805 -8472.5 3805 -8477.5 3810 -8477.5 3815 -8477.5 {fill=1
bezier=1}
P 7 14 4825 -8267.5 4830 -8267.5 4835 -8267.5 4835 -8262.5 4835 -8242.5 4835 -8237.5 4830 -8237.5 4820 -8237.5 4815 -8237.5 4815 -8242.5 4815 -8262.5 4815 -8267.5 4820 -8267.5 4825 -8267.5 {fill=1
bezier=1}
P 7 14 5395 -8267.5 5400 -8267.5 5405 -8267.5 5405 -8262.5 5405 -8242.5 5405 -8237.5 5400 -8237.5 5390 -8237.5 5385 -8237.5 5385 -8242.5 5385 -8262.5 5385 -8267.5 5390 -8267.5 5395 -8267.5 {fill=1
bezier=1}
P 7 14 2265 -5857.5 2270 -5857.5 2275 -5857.5 2275 -5852.5 2275 -5832.5 2275 -5827.5 2270 -5827.5 2260 -5827.5 2255 -5827.5 2255 -5832.5 2255 -5852.5 2255 -5857.5 2260 -5857.5 2265 -5857.5 {fill=1
bezier=1}
P 7 14 4795 -6717.5 4800 -6717.5 4805 -6717.5 4805 -6712.5 4805 -6692.5 4805 -6687.5 4800 -6687.5 4790 -6687.5 4785 -6687.5 4785 -6692.5 4785 -6712.5 4785 -6717.5 4790 -6717.5 4795 -6717.5 {fill=1
bezier=1}
P 7 14 7985 -8087.5 7990 -8087.5 7995 -8087.5 7995 -8082.5 7995 -8062.5 7995 -8057.5 7990 -8057.5 7980 -8057.5 7975 -8057.5 7975 -8062.5 7975 -8082.5 7975 -8087.5 7980 -8087.5 7985 -8087.5 {fill=1
bezier=1}
P 7 14 6455 -8207.5 6460 -8207.5 6465 -8207.5 6465 -8202.5 6465 -8182.5 6465 -8177.5 6460 -8177.5 6450 -8177.5 6445 -8177.5 6445 -8182.5 6445 -8202.5 6445 -8207.5 6450 -8207.5 6455 -8207.5 {fill=1
bezier=1}
P 7 14 6995 -8187.5 7000 -8187.5 7005 -8187.5 7005 -8182.5 7005 -8162.5 7005 -8157.5 7000 -8157.5 6990 -8157.5 6985 -8157.5 6985 -8162.5 6985 -8182.5 6985 -8187.5 6990 -8187.5 6995 -8187.5 {fill=1
bezier=1}
P 7 14 6905 -7807.5 6910 -7807.5 6915 -7807.5 6915 -7802.5 6915 -7782.5 6915 -7777.5 6910 -7777.5 6900 -7777.5 6895 -7777.5 6895 -7782.5 6895 -7802.5 6895 -7807.5 6900 -7807.5 6905 -7807.5 {fill=1
bezier=1}
P 7 14 8165 -7757.5 8170 -7757.5 8175 -7757.5 8175 -7752.5 8175 -7732.5 8175 -7727.5 8170 -7727.5 8160 -7727.5 8155 -7727.5 8155 -7732.5 8155 -7752.5 8155 -7757.5 8160 -7757.5 8165 -7757.5 {fill=1
bezier=1}
P 7 14 8155 -6347.5 8150 -6347.5 8145 -6347.5 8145 -6342.5 8145 -6322.5 8145 -6317.5 8150 -6317.5 8160 -6317.5 8165 -6317.5 8165 -6322.5 8165 -6342.5 8165 -6347.5 8160 -6347.5 8155 -6347.5 {fill=1
bezier=1}
P 9 8 4600 -7990 4742.5 -7962.5 4720 -7930 4810 -7870 4790 -7840 4700 -7900 4675 -7865 4600 -7990 {fill=0}
P 10 7 880 -8050 872.5 -8057.5 877.5 -8062.5 862.5 -8067.5 867.5 -8052.5 872.5 -8057.5 880 -8050 {fill=1}
P 10 7 2110 -8100 2102.5 -8107.5 2107.5 -8112.5 2092.5 -8117.5 2097.5 -8102.5 2102.5 -8107.5 2110 -8100 {fill=1}
P 10 7 1330 -8090 1322.5 -8097.5 1327.5 -8102.5 1312.5 -8107.5 1317.5 -8092.5 1322.5 -8097.5 1330 -8090 {fill=1}
P 10 7 760 -7830 752.5 -7837.5 757.5 -7842.5 742.5 -7847.5 747.5 -7832.5 752.5 -7837.5 760 -7830 {fill=1}
P 10 7 1380 -7830 1372.5 -7837.5 1377.5 -7842.5 1362.5 -7847.5 1367.5 -7832.5 1372.5 -7837.5 1380 -7830 {fill=1}
P 10 7 760 -7000 752.5 -7007.5 757.5 -7012.5 742.5 -7017.5 747.5 -7002.5 752.5 -7007.5 760 -7000 {fill=1}
P 10 7 1380 -7000 1372.5 -7007.5 1377.5 -7012.5 1362.5 -7017.5 1367.5 -7002.5 1372.5 -7007.5 1380 -7000 {fill=1}
P 10 7 760 -6510 752.5 -6517.5 757.5 -6522.5 742.5 -6527.5 747.5 -6512.5 752.5 -6517.5 760 -6510 {fill=1}
P 10 7 1380 -6510 1372.5 -6517.5 1377.5 -6522.5 1362.5 -6527.5 1367.5 -6512.5 1372.5 -6517.5 1380 -6510 {fill=1}
P 10 7 920 -5790 912.5 -5797.5 917.5 -5802.5 902.5 -5807.5 907.5 -5792.5 912.5 -5797.5 920 -5790 {fill=1}
P 10 7 1390 -5850 1382.5 -5857.5 1387.5 -5862.5 1372.5 -5867.5 1377.5 -5852.5 1382.5 -5857.5 1390 -5850 {fill=1}
P 10 7 2240 -5850 2232.5 -5857.5 2237.5 -5862.5 2222.5 -5867.5 2227.5 -5852.5 2232.5 -5857.5 2240 -5850 {fill=1}
P 10 7 880 -7220 872.5 -7227.5 877.5 -7232.5 862.5 -7237.5 867.5 -7222.5 872.5 -7227.5 880 -7220 {fill=1}
P 10 7 2110 -7270 2102.5 -7277.5 2107.5 -7282.5 2092.5 -7287.5 2097.5 -7272.5 2102.5 -7277.5 2110 -7270 {fill=1}
P 10 7 1330 -7260 1322.5 -7267.5 1327.5 -7272.5 1312.5 -7277.5 1317.5 -7262.5 1322.5 -7267.5 1330 -7260 {fill=1}
P 10 7 880 -8520 872.5 -8527.5 877.5 -8532.5 862.5 -8537.5 867.5 -8522.5 872.5 -8527.5 880 -8520 {fill=1}
P 10 7 1630 -8550 1622.5 -8557.5 1627.5 -8562.5 1612.5 -8567.5 1617.5 -8552.5 1622.5 -8557.5 1630 -8550 {fill=1}
P 10 7 2410 -8540 2402.5 -8547.5 2407.5 -8552.5 2392.5 -8557.5 2397.5 -8542.5 2402.5 -8547.5 2410 -8540 {fill=1}
P 10 7 3610 -8810 3602.5 -8817.5 3607.5 -8822.5 3592.5 -8827.5 3597.5 -8812.5 3602.5 -8817.5 3610 -8810 {fill=1}
P 10 7 4280 -8810 4272.5 -8817.5 4277.5 -8822.5 4262.5 -8827.5 4267.5 -8812.5 4272.5 -8817.5 4280 -8810 {fill=1}
P 10 7 4780 -8810 4772.5 -8817.5 4777.5 -8822.5 4762.5 -8827.5 4767.5 -8812.5 4772.5 -8817.5 4780 -8810 {fill=1}
P 10 7 5350 -8840 5342.5 -8847.5 5347.5 -8852.5 5332.5 -8857.5 5337.5 -8842.5 5342.5 -8847.5 5350 -8840 {fill=1}
P 10 7 3560 -8040 3552.5 -8047.5 3557.5 -8052.5 3542.5 -8057.5 3547.5 -8042.5 3552.5 -8047.5 3560 -8040 {fill=1}
P 10 7 4140 -8040 4132.5 -8047.5 4137.5 -8052.5 4122.5 -8057.5 4127.5 -8042.5 4132.5 -8047.5 4140 -8040 {fill=1}
P 10 7 5350 -8110 5342.5 -8117.5 5347.5 -8122.5 5332.5 -8127.5 5337.5 -8112.5 5342.5 -8117.5 5350 -8110 {fill=1}
P 10 7 3650 -7670 3642.5 -7677.5 3647.5 -7682.5 3632.5 -7687.5 3637.5 -7672.5 3642.5 -7677.5 3650 -7670 {fill=1}
P 10 7 4650 -7660 4642.5 -7667.5 4647.5 -7672.5 4632.5 -7677.5 4637.5 -7662.5 4642.5 -7667.5 4650 -7660 {fill=1}
P 10 7 4090 -7630 4082.5 -7637.5 4087.5 -7642.5 4072.5 -7647.5 4077.5 -7632.5 4082.5 -7637.5 4090 -7630 {fill=1}
P 10 7 4210 -6710 4202.5 -6717.5 4207.5 -6722.5 4192.5 -6727.5 4197.5 -6712.5 4202.5 -6717.5 4210 -6710 {fill=1}
P 10 7 4750 -6750 4742.5 -6757.5 4747.5 -6762.5 4732.5 -6767.5 4737.5 -6752.5 4742.5 -6757.5 4750 -6750 {fill=1}
P 10 7 4210 -7090 4202.5 -7097.5 4207.5 -7102.5 4192.5 -7107.5 4197.5 -7092.5 4202.5 -7097.5 4210 -7090 {fill=1}
P 10 7 4630 -7090 4622.5 -7097.5 4627.5 -7102.5 4612.5 -7107.5 4617.5 -7092.5 4622.5 -7097.5 4630 -7090 {fill=1}
P 10 7 5230 -7090 5222.5 -7097.5 5227.5 -7102.5 5212.5 -7107.5 5217.5 -7092.5 5222.5 -7097.5 5230 -7090 {fill=1}
P 10 7 6320 -8680 6312.5 -8687.5 6317.5 -8692.5 6302.5 -8697.5 6307.5 -8682.5 6312.5 -8687.5 6320 -8680 {fill=1}
P 10 7 6900 -8680 6892.5 -8687.5 6897.5 -8692.5 6882.5 -8697.5 6887.5 -8682.5 6892.5 -8687.5 6900 -8680 {fill=1}
P 10 7 1010 -8830 1002.5 -8837.5 1007.5 -8842.5 992.5 -8847.5 997.5 -8832.5 1002.5 -8837.5 1010 -8830 {fill=1}
P 10 7 6340 -8440 6332.5 -8447.5 6337.5 -8452.5 6322.5 -8457.5 6327.5 -8442.5 6332.5 -8447.5 6340 -8440 {fill=1}
P 10 7 6960 -8350 6952.5 -8357.5 6957.5 -8362.5 6942.5 -8367.5 6947.5 -8352.5 6952.5 -8357.5 6960 -8350 {fill=1}
P 10 7 6420 -8170 6412.5 -8177.5 6417.5 -8182.5 6402.5 -8187.5 6407.5 -8172.5 6412.5 -8177.5 6420 -8170 {fill=1}
P 10 7 6960 -8140 6952.5 -8147.5 6957.5 -8152.5 6942.5 -8157.5 6947.5 -8142.5 6952.5 -8147.5 6960 -8140 {fill=1}
P 10 7 8010 -8110 8002.5 -8117.5 8007.5 -8122.5 7992.5 -8127.5 7997.5 -8112.5 8002.5 -8117.5 8010 -8110 {fill=1}
P 10 7 7490 -7390 7482.5 -7397.5 7487.5 -7402.5 7472.5 -7407.5 7477.5 -7392.5 7482.5 -7397.5 7490 -7390 {fill=1}
P 10 7 6360 -7460 6352.5 -7467.5 6357.5 -7472.5 6342.5 -7477.5 6347.5 -7462.5 6352.5 -7467.5 6360 -7460 {fill=1}
P 10 7 6480 -7460 6472.5 -7467.5 6477.5 -7472.5 6462.5 -7477.5 6467.5 -7462.5 6472.5 -7467.5 6480 -7460 {fill=1}
P 10 7 6590 -6180 6582.5 -6187.5 6587.5 -6192.5 6572.5 -6197.5 6577.5 -6182.5 6582.5 -6187.5 6590 -6180 {fill=1}
P 10 7 7240 -6180 7232.5 -6187.5 7237.5 -6192.5 7222.5 -6197.5 7227.5 -6182.5 7232.5 -6187.5 7240 -6180 {fill=1}
P 10 7 6420 -7740 6412.5 -7747.5 6417.5 -7752.5 6402.5 -7757.5 6407.5 -7742.5 6412.5 -7747.5 6420 -7740 {fill=1}
P 10 7 6880 -7790 6872.5 -7797.5 6877.5 -7802.5 6862.5 -7807.5 6867.5 -7792.5 6872.5 -7797.5 6880 -7790 {fill=1}
P 10 7 3370 -8280 3362.5 -8287.5 3367.5 -8292.5 3352.5 -8297.5 3357.5 -8282.5 3362.5 -8287.5 3370 -8280 {fill=1}
P 10 7 3910 -8460 3902.5 -8467.5 3907.5 -8472.5 3892.5 -8477.5 3897.5 -8462.5 3902.5 -8467.5 3910 -8460 {fill=1}
P 10 7 4800 -8200 4792.5 -8207.5 4797.5 -8212.5 4782.5 -8217.5 4787.5 -8202.5 4792.5 -8207.5 4800 -8200 {fill=1}
P 10 7 5370 -8250 5362.5 -8257.5 5367.5 -8262.5 5352.5 -8267.5 5357.5 -8252.5 5362.5 -8257.5 5370 -8250 {fill=1}
P 10 7 3670 -6360 3662.5 -6367.5 3667.5 -6372.5 3652.5 -6377.5 3657.5 -6362.5 3662.5 -6367.5 3670 -6360 {fill=1}
P 10 7 4210 -6360 4202.5 -6367.5 4207.5 -6372.5 4192.5 -6377.5 4197.5 -6362.5 4202.5 -6367.5 4210 -6360 {fill=1}
P 10 7 4750 -6440 4742.5 -6447.5 4747.5 -6452.5 4732.5 -6457.5 4737.5 -6442.5 4742.5 -6447.5 4750 -6440 {fill=1}
P 10 7 5290 -6360 5282.5 -6367.5 5287.5 -6372.5 5272.5 -6377.5 5277.5 -6362.5 5282.5 -6367.5 5290 -6360 {fill=1}
P 10 7 5390 -6110 5382.5 -6117.5 5387.5 -6122.5 5372.5 -6127.5 5377.5 -6112.5 5382.5 -6117.5 5390 -6110 {fill=1}
P 10 7 4860 -6010 4852.5 -6017.5 4857.5 -6022.5 4842.5 -6027.5 4847.5 -6012.5 4852.5 -6017.5 4860 -6010 {fill=1}
P 10 7 4350 -6000 4342.5 -6007.5 4347.5 -6012.5 4332.5 -6017.5 4337.5 -6002.5 4342.5 -6007.5 4350 -6000 {fill=1}
P 10 8 4600 -7990 4742.5 -7962.5 4720 -7930 4810 -7870 4790 -7840 4700 -7900 4675 -7865 4600 -7990 {fill=1}
P 10 7 8130 -7750 8122.5 -7757.5 8127.5 -7762.5 8112.5 -7767.5 8117.5 -7752.5 8122.5 -7757.5 8130 -7750 {fill=1}
P 10 7 8110 -6360 8102.5 -6367.5 8107.5 -6372.5 8092.5 -6377.5 8097.5 -6362.5 8102.5 -6367.5 8110 -6360 {fill=1}
T {INTUITIVE_INTERFACE CHEAT SHEET} 4100 -9370 0 0 2 2 {hcenter=1}
T {D} 1275 -8247.5 0 0 0.15 0.15 { layer=2}
T {D} 2055 -8257.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -8247.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -7787.5 0 0 0.15 0.15 {}
T {D} 1285 -7787.5 0 0 0.15 0.15 {}
T {D} 745 -6957.5 0 0 0.15 0.15 {}
T {D} 1285 -6957.5 0 0 0.15 0.15 {}
T {D} 745 -6467.5 0 0 0.15 0.15 {}
T {D} 1285 -6467.5 0 0 0.15 0.15 {}
T {D} 745 -5977.5 0 0 0.15 0.15 { layer=2}
T {D} 2125 -5977.5 0 0 0.15 0.15 { layer=2}
T {D} 1285 -5977.5 0 0 0.15 0.15 { layer=2}
T {(Enable Options-> Intuitive Click & Drag interface
or add: `set intuitive_interface 1` in xschemrc file).} 4080 -9230 0 0 1 1 {hcenter=1 layer=1}
T {Move objects} 0 -8320 0 0 1 1 {}
T {Move objects} 0 -7910 0 0 1 1 {}
T {Move objects,
create wires} 0 -7080 0 0 1 1 {}
T {Move objects,
keep attached
wires
} 0 -6590 0 0 1 1 {}
T {Move objects,
keep attached
wires
} 0 -6100 0 0 1 1 {}
T {Shift} 1530 -7045 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1530 -6555 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1520 -5835 0 0 0.5 0.5 {hcenter=1}
T {Duplicate objects} 0 -7470 0 0 1 1 {}
T {D} 1275 -7417.5 0 0 0.15 0.15 { layer=2}
T {D} 2055 -7427.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -7417.5 0 0 0.15 0.15 { layer=2}
T {D} 1775 -7417.5 0 0 0.15 0.15 {}
T {Shift} 1270 -7235 0 0 0.5 0.5 {hcenter=1}
T {D} 1815 -8717.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -8717.5 0 0 0.15 0.15 { layer=2}
T {Select
and unselect
objects} 0 -8770 0 0 1 1 {}
T {Shift} 1710 -8515 0 0 0.5 0.5 {hcenter=1}
T {D} 2275 -8717.5 0 0 0.15 0.15 { layer=2}
T {Alt} 2490 -8505 0 0 0.5 0.5 {hcenter=1}
T {Select} 750 -8520 0 0 0.5 0.5 {}
T {Add
Selection} 1770 -8530 0 0 0.5 0.5 {}
T {Remove
Selection} 2220 -8530 0 0 0.5 0.5 {}
T {D} 3595 -8737.5 0 0 0.15 0.15 {}
T {D} 4135 -8737.5 0 0 0.15 0.15 {}
T {D} 4695 -8737.5 0 0 0.15 0.15 {}
T {D} 5265 -8737.5 0 0 0.15 0.15 {}
T {D} 3595 -7937.5 0 0 0.15 0.15 {}
T {D} 4135 -7937.5 0 0 0.15 0.15 {}
T {D} 5265 -7937.5 0 0 0.15 0.15 {}
T {D} 3595 -8357.5 0 0 0.15 0.15 {}
T {D} 3595 -7527.5 0 0 0.15 0.15 {}
T {D} 4695 -7527.5 0 0 0.15 0.15 {}
T {D} 4135 -7527.5 0 0 0.15 0.15 {}
T {Create and move
wires} 2830 -8860 0 0 1 1 {}
T {Resize wires} 2830 -8060 0 0 1 1 {}
T {Create wires} 2830 -8480 0 0 1 1 {}
T {Stretch circuit} 2830 -7650 0 0 1 1 {}
T {Move components, 
create wires,
resize wires} 2830 -6860 0 0 1 1 {}
T {Move components,
create new wires} 2830 -7240 0 0 1 1 {}
T {Cut wires} 2830 -6510 0 0 1 1 {}
T {Stretch multiple
shapes} 2830 -6090 0 0 1 1 {}
T {Ctrl} 4000 -7595 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 4260 -7245 0 0 0.5 0.5 {hcenter=1}
T {Shift} 4260 -7165 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 4530 -7245 0 0 0.5 0.5 {hcenter=1}
T {Shift} 4530 -7165 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 4260 -6865 0 0 0.5 0.5 {hcenter=1}
T {Shift} 4260 -6785 0 0 0.5 0.5 {hcenter=1}
T {Accurately position closer
to the wire end to be moved
so it will not be unselected} 4440 -8170 0 0 0.5 0.5 {}
T {Move multiple
objects keeping
connections} 5660 -7140 0 0 1 1 {}
T {Ctrl} 7740 -7115 0 0 0.5 0.5 {hcenter=1}
T {Alt} 4260 -6415 0 0 0.5 0.5 {hcenter=1}
T {Click to select wire, release button
click wire endpoint and drag it away} 3490 -8150 0 0 0.5 0.5 {}
T {Ctrl} 4410 -6005 0 0 0.5 0.5 {hcenter=1}
T {D} 6315 -8737.5 0 0 0.15 0.15 { layer=2}
T {D} 6895 -8737.5 0 0 0.15 0.15 { layer=2}
T {D} 7545 -8737.5 0 0 0.15 0.15 {}
T {Ctrl} 7620 -8775 0 0 0.5 0.5 {hcenter=1}
T {!} 7620 -8695 0 0 0.5 0.5 {hcenter=1}
T {Break wires
under component
} 5660 -8810 0 0 1 1 {}
T {If Shift key is needed for ! 
use also Shift} 7680 -8750 0 0 0.5 0.5 {}
T {D} 1275 -8717.5 0 0 0.15 0.15 { layer=2}
T {Add
Selection} 1090 -8540 0 0 0.5 0.5 {}
T {Shift} 1080 -8795 0 0 0.5 0.5 {hcenter=1}
T {Move multiple
objects keeping
connections,
adding wires} 5660 -6760 0 0 1 1 {}
T {Ctrl} 7740 -6735 0 0 0.5 0.5 {hcenter=1}
T {Shift} 7740 -6665 0 0 0.5 0.5 {hcenter=1}
T {Join / Trim wires} 5660 -8470 0 0 1 1 {}
T {&} 7580 -8475 0 0 0.5 0.5 {hcenter=1}
T {This wire will not be broken} 6780 -8060 0 0 0.5 0.5 {}
T {&} 7490 -8045 0 0 0.5 0.5 {hcenter=1}
T {This wire is now 
broken} 7550 -8060 0 0 0.5 0.5 {}
T {break wires
at instance
pins} 5660 -7540 0 0 1 1 {}
T {!} 6950 -7395 0 0 0.5 0.5 {hcenter=1}
T {Shift} 6450 -7325 0 0 0.5 0.5 {hcenter=1}
T {+} 6380 -7400 0 0 0.5 0.5 {}
T {The single wire line will be
broken at selected instance pins} 7300 -7570 0 0 0.5 0.5 {}
T {Single wire line} 6300 -7560 0 0 0.5 0.5 {}
T {D} 6485 -6227.5 0 0 0.15 0.15 {}
T {D} 7135 -6227.5 0 0 0.15 0.15 {}
T {Shift} 7310 -6165 0 0 0.5 0.5 {hcenter=1}
T {Select instance
and all connected
wires} 5660 -6360 0 0 1 1 {}
T {Join / Trim wires} 5660 -8190 0 0 1 1 {}
T {Options->Auto join / trim wires to perform this function automatically} 6500 -8290 0 0 0.5 0.5 {}
T {Join / Trim wires} 5660 -7800 0 0 1 1 {}
T {This wire is broken} 6290 -7660 0 0 0.5 0.5 {}
T {This wire is still broken} 6830 -7660 0 0 0.5 0.5 {}
T {This wire is now joined} 7460 -7660 0 0 0.5 0.5 {}
T {&} 7580 -7905 0 0 0.5 0.5 {hcenter=1}
T {Options->Auto join / trim wires to perform this function automatically} 6500 -7920 0 0 0.5 0.5 {}
T {Options->Auto join / trim wires to perform this function automatically} 6500 -8530 0 0 0.5 0.5 {}
T {multiple overlayed wires create
unneeded connecting dots} 6770 -8450 0 0 0.5 0.5 {}
T {overlayed wires are removed} 7930 -8430 0 0 0.5 0.5 {}
T {D} 4135 -8357.5 0 0 0.15 0.15 {}
T {D} 4695 -8357.5 0 0 0.15 0.15 {}
T {D} 5265 -8357.5 0 0 0.15 0.15 {}
T {Ctrl} 2370 -5835 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 4810 -6865 0 0 0.5 0.5 {hcenter=1}
T {Shift} 4810 -6785 0 0 0.5 0.5 {hcenter=1}
T {you can now 
select one of
the cut segments...} 4760 -6380 0 0 0.4 0.4 {}
T {... and move it.} 5250 -6300 0 0 0.4 0.4 {}
T {D} 7695 -6227.5 0 0 0.15 0.15 {}
