v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 1 917.5 -8072.5 922.5 -8072.5 {}
L 1 917.5 -8070 922.5 -8070 {}
L 1 917.5 -8067.5 922.5 -8067.5 {}
L 1 917.5 -8065 922.5 -8065 {}
L 1 917.5 -8062.5 922.5 -8062.5 {}
L 1 917.5 -8060 922.5 -8060 {}
L 1 917.5 -8057.5 922.5 -8057.5 {}
L 1 917.5 -8055 922.5 -8055 {}
L 1 917.5 -8052.5 922.5 -8052.5 {}
L 1 1347.5 -8072.5 1352.5 -8072.5 {}
L 1 1347.5 -8070 1352.5 -8070 {}
L 1 1347.5 -8067.5 1352.5 -8067.5 {}
L 1 1347.5 -8065 1352.5 -8065 {}
L 1 1347.5 -8062.5 1352.5 -8062.5 {}
L 1 1347.5 -8060 1352.5 -8060 {}
L 1 1347.5 -8057.5 1352.5 -8057.5 {}
L 1 1347.5 -8055 1352.5 -8055 {}
L 1 1347.5 -8052.5 1352.5 -8052.5 {}
L 1 2117.5 -8072.5 2122.5 -8072.5 {}
L 1 2117.5 -8070 2122.5 -8070 {}
L 1 2117.5 -8067.5 2122.5 -8067.5 {}
L 1 2117.5 -8065 2122.5 -8065 {}
L 1 2117.5 -8062.5 2122.5 -8062.5 {}
L 1 2117.5 -8060 2122.5 -8060 {}
L 1 2117.5 -8057.5 2122.5 -8057.5 {}
L 1 2117.5 -8055 2122.5 -8055 {}
L 1 2117.5 -8052.5 2122.5 -8052.5 {}
L 1 1417.5 -7882.5 1422.5 -7882.5 {}
L 1 1417.5 -7880 1422.5 -7880 {}
L 1 1417.5 -7877.5 1422.5 -7877.5 {}
L 1 1417.5 -7875 1422.5 -7875 {}
L 1 1417.5 -7872.5 1422.5 -7872.5 {}
L 1 1417.5 -7870 1422.5 -7870 {}
L 1 1417.5 -7867.5 1422.5 -7867.5 {}
L 1 1417.5 -7865 1422.5 -7865 {}
L 1 1417.5 -7862.5 1422.5 -7862.5 {}
L 1 1437.5 -6272.5 1442.5 -6272.5 {}
L 1 1437.5 -6270 1442.5 -6270 {}
L 1 1437.5 -6267.5 1442.5 -6267.5 {}
L 1 1437.5 -6265 1442.5 -6265 {}
L 1 1437.5 -6262.5 1442.5 -6262.5 {}
L 1 1437.5 -6260 1442.5 -6260 {}
L 1 1437.5 -6257.5 1442.5 -6257.5 {}
L 1 1437.5 -6255 1442.5 -6255 {}
L 1 1437.5 -6252.5 1442.5 -6252.5 {}
L 1 1437.5 -5782.5 1442.5 -5782.5 {}
L 1 1437.5 -5780 1442.5 -5780 {}
L 1 1437.5 -5777.5 1442.5 -5777.5 {}
L 1 1437.5 -5775 1442.5 -5775 {}
L 1 1437.5 -5772.5 1442.5 -5772.5 {}
L 1 1437.5 -5770 1442.5 -5770 {}
L 1 1437.5 -5767.5 1442.5 -5767.5 {}
L 1 1437.5 -5765 1442.5 -5765 {}
L 1 1437.5 -5762.5 1442.5 -5762.5 {}
L 1 947.5 -5052.5 952.5 -5052.5 {}
L 1 947.5 -5050 952.5 -5050 {}
L 1 947.5 -5047.5 952.5 -5047.5 {}
L 1 947.5 -5045 952.5 -5045 {}
L 1 947.5 -5042.5 952.5 -5042.5 {}
L 1 947.5 -5040 952.5 -5040 {}
L 1 947.5 -5037.5 952.5 -5037.5 {}
L 1 947.5 -5035 952.5 -5035 {}
L 1 947.5 -5032.5 952.5 -5032.5 {}
L 1 1040 -5310 1280 -5310 {}
L 1 1040 -5050 1280 -5050 {}
L 1 1427.5 -5062.5 1432.5 -5062.5 {}
L 1 1427.5 -5060 1432.5 -5060 {}
L 1 1427.5 -5057.5 1432.5 -5057.5 {}
L 1 1427.5 -5055 1432.5 -5055 {}
L 1 1427.5 -5052.5 1432.5 -5052.5 {}
L 1 1427.5 -5050 1432.5 -5050 {}
L 1 1427.5 -5047.5 1432.5 -5047.5 {}
L 1 1427.5 -5045 1432.5 -5045 {}
L 1 1427.5 -5042.5 1432.5 -5042.5 {}
L 1 917.5 -7242.5 922.5 -7242.5 {}
L 1 917.5 -7240 922.5 -7240 {}
L 1 917.5 -7237.5 922.5 -7237.5 {}
L 1 917.5 -7235 922.5 -7235 {}
L 1 917.5 -7232.5 922.5 -7232.5 {}
L 1 917.5 -7230 922.5 -7230 {}
L 1 917.5 -7227.5 922.5 -7227.5 {}
L 1 917.5 -7225 922.5 -7225 {}
L 1 917.5 -7222.5 922.5 -7222.5 {}
L 1 1347.5 -7242.5 1352.5 -7242.5 {}
L 1 1347.5 -7240 1352.5 -7240 {}
L 1 1347.5 -7237.5 1352.5 -7237.5 {}
L 1 1347.5 -7235 1352.5 -7235 {}
L 1 1347.5 -7232.5 1352.5 -7232.5 {}
L 1 1347.5 -7230 1352.5 -7230 {}
L 1 1347.5 -7227.5 1352.5 -7227.5 {}
L 1 1347.5 -7225 1352.5 -7225 {}
L 1 1347.5 -7222.5 1352.5 -7222.5 {}
L 1 2117.5 -7242.5 2122.5 -7242.5 {}
L 1 2117.5 -7240 2122.5 -7240 {}
L 1 2117.5 -7237.5 2122.5 -7237.5 {}
L 1 2117.5 -7235 2122.5 -7235 {}
L 1 2117.5 -7232.5 2122.5 -7232.5 {}
L 1 2117.5 -7230 2122.5 -7230 {}
L 1 2117.5 -7227.5 2122.5 -7227.5 {}
L 1 2117.5 -7225 2122.5 -7225 {}
L 1 2117.5 -7222.5 2122.5 -7222.5 {}
L 1 917.5 -8542.5 922.5 -8542.5 {}
L 1 917.5 -8540 922.5 -8540 {}
L 1 917.5 -8537.5 922.5 -8537.5 {}
L 1 917.5 -8535 922.5 -8535 {}
L 1 917.5 -8532.5 922.5 -8532.5 {}
L 1 917.5 -8530 922.5 -8530 {}
L 1 917.5 -8527.5 922.5 -8527.5 {}
L 1 917.5 -8525 922.5 -8525 {}
L 1 917.5 -8522.5 922.5 -8522.5 {}
L 1 1627.5 -8532.5 1632.5 -8532.5 {}
L 1 1627.5 -8530 1632.5 -8530 {}
L 1 1627.5 -8527.5 1632.5 -8527.5 {}
L 1 1627.5 -8525 1632.5 -8525 {}
L 1 1627.5 -8522.5 1632.5 -8522.5 {}
L 1 1627.5 -8520 1632.5 -8520 {}
L 1 1627.5 -8517.5 1632.5 -8517.5 {}
L 1 1627.5 -8515 1632.5 -8515 {}
L 1 1627.5 -8512.5 1632.5 -8512.5 {}
L 1 2407.5 -8522.5 2412.5 -8522.5 {}
L 1 2407.5 -8520 2412.5 -8520 {}
L 1 2407.5 -8517.5 2412.5 -8517.5 {}
L 1 2407.5 -8515 2412.5 -8515 {}
L 1 2407.5 -8512.5 2412.5 -8512.5 {}
L 1 2407.5 -8510 2412.5 -8510 {}
L 1 2407.5 -8507.5 2412.5 -8507.5 {}
L 1 2407.5 -8505 2412.5 -8505 {}
L 1 2407.5 -8502.5 2412.5 -8502.5 {}
L 1 520 -4490 760 -4490 {}
L 1 820 -3010 820 -2680 {}
L 1 1360 -3010 1360 -2680 {}
L 1 1900 -2840 1900 -2680 {}
L 1 820 -2490 820 -2390 {}
L 1 710 -2490 710 -2390 {}
L 1 930 -2490 930 -2390 {}
L 1 820 -3370 820 -3220 {}
L 1 1360 -3370 1360 -3220 {}
L 1 1900 -3370 1900 -3260 {}
L 1 1487.5 -4862.5 1492.5 -4862.5 {}
L 1 1487.5 -4860 1492.5 -4860 {}
L 1 1487.5 -4857.5 1492.5 -4857.5 {}
L 1 1487.5 -4855 1492.5 -4855 {}
L 1 1487.5 -4852.5 1492.5 -4852.5 {}
L 1 1487.5 -4850 1492.5 -4850 {}
L 1 1487.5 -4847.5 1492.5 -4847.5 {}
L 1 1487.5 -4845 1492.5 -4845 {}
L 1 1487.5 -4842.5 1492.5 -4842.5 {}
L 1 1937.5 -4932.5 1942.5 -4932.5 {}
L 1 1937.5 -4930 1942.5 -4930 {}
L 1 1937.5 -4927.5 1942.5 -4927.5 {}
L 1 1937.5 -4925 1942.5 -4925 {}
L 1 1937.5 -4922.5 1942.5 -4922.5 {}
L 1 1937.5 -4920 1942.5 -4920 {}
L 1 1937.5 -4917.5 1942.5 -4917.5 {}
L 1 1937.5 -4915 1942.5 -4915 {}
L 1 1937.5 -4912.5 1942.5 -4912.5 {}
L 1 2557.5 -4842.5 2562.5 -4842.5 {}
L 1 2557.5 -4840 2562.5 -4840 {}
L 1 2557.5 -4837.5 2562.5 -4837.5 {}
L 1 2557.5 -4835 2562.5 -4835 {}
L 1 2557.5 -4832.5 2562.5 -4832.5 {}
L 1 2557.5 -4830 2562.5 -4830 {}
L 1 2557.5 -4827.5 2562.5 -4827.5 {}
L 1 2557.5 -4825 2562.5 -4825 {}
L 1 2557.5 -4822.5 2562.5 -4822.5 {}
L 1 687.5 -6662.5 692.5 -6662.5 {}
L 1 687.5 -6660 692.5 -6660 {}
L 1 687.5 -6657.5 692.5 -6657.5 {}
L 1 687.5 -6655 692.5 -6655 {}
L 1 687.5 -6652.5 692.5 -6652.5 {}
L 1 687.5 -6650 692.5 -6650 {}
L 1 687.5 -6647.5 692.5 -6647.5 {}
L 1 687.5 -6645 692.5 -6645 {}
L 1 687.5 -6642.5 692.5 -6642.5 {}
L 1 1347.5 -6682.5 1352.5 -6682.5 {}
L 1 1347.5 -6680 1352.5 -6680 {}
L 1 1347.5 -6677.5 1352.5 -6677.5 {}
L 1 1347.5 -6675 1352.5 -6675 {}
L 1 1347.5 -6672.5 1352.5 -6672.5 {}
L 1 1347.5 -6670 1352.5 -6670 {}
L 1 1347.5 -6667.5 1352.5 -6667.5 {}
L 1 1347.5 -6665 1352.5 -6665 {}
L 1 1347.5 -6662.5 1352.5 -6662.5 {}
L 1 2537.5 -6732.5 2542.5 -6732.5 {}
L 1 2537.5 -6730 2542.5 -6730 {}
L 1 2537.5 -6727.5 2542.5 -6727.5 {}
L 1 2537.5 -6725 2542.5 -6725 {}
L 1 2537.5 -6722.5 2542.5 -6722.5 {}
L 1 2537.5 -6720 2542.5 -6720 {}
L 1 2537.5 -6717.5 2542.5 -6717.5 {}
L 1 2537.5 -6715 2542.5 -6715 {}
L 1 2537.5 -6712.5 2542.5 -6712.5 {}
L 1 1387.5 -4122.5 1392.5 -4122.5 {}
L 1 1387.5 -4120 1392.5 -4120 {}
L 1 1387.5 -4117.5 1392.5 -4117.5 {}
L 1 1387.5 -4115 1392.5 -4115 {}
L 1 1387.5 -4112.5 1392.5 -4112.5 {}
L 1 1387.5 -4110 1392.5 -4110 {}
L 1 1387.5 -4107.5 1392.5 -4107.5 {}
L 1 1387.5 -4105 1392.5 -4105 {}
L 1 1387.5 -4102.5 1392.5 -4102.5 {}
L 1 1787.5 -4072.5 1792.5 -4072.5 {}
L 1 1787.5 -4070 1792.5 -4070 {}
L 1 1787.5 -4067.5 1792.5 -4067.5 {}
L 1 1787.5 -4065 1792.5 -4065 {}
L 1 1787.5 -4062.5 1792.5 -4062.5 {}
L 1 1787.5 -4060 1792.5 -4060 {}
L 1 1787.5 -4057.5 1792.5 -4057.5 {}
L 1 1787.5 -4055 1792.5 -4055 {}
L 1 1787.5 -4052.5 1792.5 -4052.5 {}
L 1 2347.5 -4102.5 2352.5 -4102.5 {}
L 1 2347.5 -4100 2352.5 -4100 {}
L 1 2347.5 -4097.5 2352.5 -4097.5 {}
L 1 2347.5 -4095 2352.5 -4095 {}
L 1 2347.5 -4092.5 2352.5 -4092.5 {}
L 1 2347.5 -4090 2352.5 -4090 {}
L 1 2347.5 -4087.5 2352.5 -4087.5 {}
L 1 2347.5 -4085 2352.5 -4085 {}
L 1 2347.5 -4082.5 2352.5 -4082.5 {}
L 1 1427.5 -3552.5 1432.5 -3552.5 {}
L 1 1427.5 -3550 1432.5 -3550 {}
L 1 1427.5 -3547.5 1432.5 -3547.5 {}
L 1 1427.5 -3545 1432.5 -3545 {}
L 1 1427.5 -3542.5 1432.5 -3542.5 {}
L 1 1427.5 -3540 1432.5 -3540 {}
L 1 1427.5 -3537.5 1432.5 -3537.5 {}
L 1 1427.5 -3535 1432.5 -3535 {}
L 1 1427.5 -3532.5 1432.5 -3532.5 {}
L 1 1697.5 -3552.5 1702.5 -3552.5 {}
L 1 1697.5 -3550 1702.5 -3550 {}
L 1 1697.5 -3547.5 1702.5 -3547.5 {}
L 1 1697.5 -3545 1702.5 -3545 {}
L 1 1697.5 -3542.5 1702.5 -3542.5 {}
L 1 1697.5 -3540 1702.5 -3540 {}
L 1 1697.5 -3537.5 1702.5 -3537.5 {}
L 1 1697.5 -3535 1702.5 -3535 {}
L 1 1697.5 -3532.5 1702.5 -3532.5 {}
L 1 2297.5 -3552.5 2302.5 -3552.5 {}
L 1 2297.5 -3550 2302.5 -3550 {}
L 1 2297.5 -3547.5 2302.5 -3547.5 {}
L 1 2297.5 -3545 2302.5 -3545 {}
L 1 2297.5 -3542.5 2302.5 -3542.5 {}
L 1 2297.5 -3540 2302.5 -3540 {}
L 1 2297.5 -3537.5 2302.5 -3537.5 {}
L 1 2297.5 -3535 2302.5 -3535 {}
L 1 2297.5 -3532.5 2302.5 -3532.5 {}
L 1 1427.5 -3172.5 1432.5 -3172.5 {}
L 1 1427.5 -3170 1432.5 -3170 {}
L 1 1427.5 -3167.5 1432.5 -3167.5 {}
L 1 1427.5 -3165 1432.5 -3165 {}
L 1 1427.5 -3162.5 1432.5 -3162.5 {}
L 1 1427.5 -3160 1432.5 -3160 {}
L 1 1427.5 -3157.5 1432.5 -3157.5 {}
L 1 1427.5 -3155 1432.5 -3155 {}
L 1 1427.5 -3152.5 1432.5 -3152.5 {}
L 1 820 -560 820 -460 {}
L 1 710 -560 710 -460 {}
L 1 930 -560 930 -460 {}
L 1 820 -400 820 -370 {}
L 1 710 -400 710 -370 {}
L 1 930 -400 930 -370 {}
L 1 2077.5 -442.5 2082.5 -442.5 {}
L 1 2077.5 -440 2082.5 -440 {}
L 1 2077.5 -437.5 2082.5 -437.5 {}
L 1 2077.5 -435 2082.5 -435 {}
L 1 2077.5 -432.5 2082.5 -432.5 {}
L 1 2077.5 -430 2082.5 -430 {}
L 1 2077.5 -427.5 2082.5 -427.5 {}
L 1 2077.5 -425 2082.5 -425 {}
L 1 2077.5 -422.5 2082.5 -422.5 {}
L 1 1567.5 -412.5 1572.5 -412.5 {}
L 1 1567.5 -410 1572.5 -410 {}
L 1 1567.5 -407.5 1572.5 -407.5 {}
L 1 1567.5 -405 1572.5 -405 {}
L 1 1567.5 -402.5 1572.5 -402.5 {}
L 1 1567.5 -400 1572.5 -400 {}
L 1 1567.5 -397.5 1572.5 -397.5 {}
L 1 1567.5 -395 1572.5 -395 {}
L 1 1567.5 -392.5 1572.5 -392.5 {}
L 1 1427.5 -2812.5 1432.5 -2812.5 {}
L 1 1427.5 -2810 1432.5 -2810 {}
L 1 1427.5 -2807.5 1432.5 -2807.5 {}
L 1 1427.5 -2805 1432.5 -2805 {}
L 1 1427.5 -2802.5 1432.5 -2802.5 {}
L 1 1427.5 -2800 1432.5 -2800 {}
L 1 1427.5 -2797.5 1432.5 -2797.5 {}
L 1 1427.5 -2795 1432.5 -2795 {}
L 1 1427.5 -2792.5 1432.5 -2792.5 {}
L 1 1957.5 -2922.5 1962.5 -2922.5 {}
L 1 1957.5 -2920 1962.5 -2920 {}
L 1 1957.5 -2917.5 1962.5 -2917.5 {}
L 1 1957.5 -2915 1962.5 -2915 {}
L 1 1957.5 -2912.5 1962.5 -2912.5 {}
L 1 1957.5 -2910 1962.5 -2910 {}
L 1 1957.5 -2907.5 1962.5 -2907.5 {}
L 1 1957.5 -2905 1962.5 -2905 {}
L 1 1957.5 -2902.5 1962.5 -2902.5 {}
L 1 1577.5 -2402.5 1582.5 -2402.5 {}
L 1 1577.5 -2400 1582.5 -2400 {}
L 1 1577.5 -2397.5 1582.5 -2397.5 {}
L 1 1577.5 -2395 1582.5 -2395 {}
L 1 1577.5 -2392.5 1582.5 -2392.5 {}
L 1 1577.5 -2390 1582.5 -2390 {}
L 1 1577.5 -2387.5 1582.5 -2387.5 {}
L 1 1577.5 -2385 1582.5 -2385 {}
L 1 1577.5 -2382.5 1582.5 -2382.5 {}
L 1 2067.5 -2462.5 2072.5 -2462.5 {}
L 1 2067.5 -2460 2072.5 -2460 {}
L 1 2067.5 -2457.5 2072.5 -2457.5 {}
L 1 2067.5 -2455 2072.5 -2455 {}
L 1 2067.5 -2452.5 2072.5 -2452.5 {}
L 1 2067.5 -2450 2072.5 -2450 {}
L 1 2067.5 -2447.5 2072.5 -2447.5 {}
L 1 2067.5 -2445 2072.5 -2445 {}
L 1 2067.5 -2442.5 2072.5 -2442.5 {}
L 1 2597.5 -2592.5 2602.5 -2592.5 {}
L 1 2597.5 -2590 2602.5 -2590 {}
L 1 2597.5 -2587.5 2602.5 -2587.5 {}
L 1 2597.5 -2585 2602.5 -2585 {}
L 1 2597.5 -2582.5 2602.5 -2582.5 {}
L 1 2597.5 -2580 2602.5 -2580 {}
L 1 2597.5 -2577.5 2602.5 -2577.5 {}
L 1 2597.5 -2575 2602.5 -2575 {}
L 1 2597.5 -2572.5 2602.5 -2572.5 {}
L 1 987.5 -8812.5 992.5 -8812.5 {}
L 1 987.5 -8810 992.5 -8810 {}
L 1 987.5 -8807.5 992.5 -8807.5 {}
L 1 987.5 -8805 992.5 -8805 {}
L 1 987.5 -8802.5 992.5 -8802.5 {}
L 1 987.5 -8800 992.5 -8800 {}
L 1 987.5 -8797.5 992.5 -8797.5 {}
L 1 987.5 -8795 992.5 -8795 {}
L 1 987.5 -8792.5 992.5 -8792.5 {}
L 1 820 -180 820 -80 {}
L 1 710 -180 710 -80 {}
L 1 930 -180 930 -80 {}
L 1 1567.5 -32.5 1572.5 -32.5 {}
L 1 1567.5 -30 1572.5 -30 {}
L 1 1567.5 -27.5 1572.5 -27.5 {}
L 1 1567.5 -25 1572.5 -25 {}
L 1 1567.5 -22.5 1572.5 -22.5 {}
L 1 1567.5 -20 1572.5 -20 {}
L 1 1567.5 -17.5 1572.5 -17.5 {}
L 1 1567.5 -15 1572.5 -15 {}
L 1 1567.5 -12.5 1572.5 -12.5 {}
L 1 2077.5 17.5 2082.5 17.5 {}
L 1 2077.5 20 2082.5 20 {}
L 1 2077.5 22.5 2082.5 22.5 {}
L 1 2077.5 25 2082.5 25 {}
L 1 2077.5 27.5 2082.5 27.5 {}
L 1 2077.5 30 2082.5 30 {}
L 1 2077.5 32.5 2082.5 32.5 {}
L 1 2077.5 35 2082.5 35 {}
L 1 2077.5 37.5 2082.5 37.5 {}
L 1 620 -1760 870 -1760 {}
L 1 1340 -1760 1410 -1760 {}
L 1 1160 -1760 1220 -1760 {}
L 1 1790 -1760 2040 -1760 {}
L 1 2340 -1760 2590 -1760 {}
L 1 620 -1480 870 -1480 {}
L 1 1160 -1480 1410 -1480 {}
L 1 1790 -1480 2040 -1480 {}
L 1 1910 -1600 1910 -1480 {}
L 1 2460 -1480 2590 -1480 {}
L 1 2460 -1600 2460 -1480 {}
L 1 2360 -2840 2360 -2680 {}
L 1 2497.5 -2842.5 2502.5 -2842.5 {}
L 1 2497.5 -2840 2502.5 -2840 {}
L 1 2497.5 -2837.5 2502.5 -2837.5 {}
L 1 2497.5 -2835 2502.5 -2835 {}
L 1 2497.5 -2832.5 2502.5 -2832.5 {}
L 1 2497.5 -2830 2502.5 -2830 {}
L 1 2497.5 -2827.5 2502.5 -2827.5 {}
L 1 2497.5 -2825 2502.5 -2825 {}
L 1 2497.5 -2822.5 2502.5 -2822.5 {}
L 1 1160 -900 1410 -900 {}
L 1 1880 -770 1950 -770 {}
L 1 1700 -770 1760 -770 {}
L 1 1817.5 -882.5 1822.5 -882.5 {}
L 1 1817.5 -880 1822.5 -880 {}
L 1 1817.5 -877.5 1822.5 -877.5 {}
L 1 1817.5 -875 1822.5 -875 {}
L 1 1817.5 -872.5 1822.5 -872.5 {}
L 1 1817.5 -870 1822.5 -870 {}
L 1 1817.5 -867.5 1822.5 -867.5 {}
L 1 1817.5 -865 1822.5 -865 {}
L 1 1817.5 -862.5 1822.5 -862.5 {}
L 1 620 -900 870 -900 {}
L 1 667.5 -812.5 672.5 -812.5 {}
L 1 667.5 -810 672.5 -810 {}
L 1 667.5 -807.5 672.5 -807.5 {}
L 1 667.5 -805 672.5 -805 {}
L 1 667.5 -802.5 672.5 -802.5 {}
L 1 667.5 -800 672.5 -800 {}
L 1 667.5 -797.5 672.5 -797.5 {}
L 1 667.5 -795 672.5 -795 {}
L 1 667.5 -792.5 672.5 -792.5 {}
L 1 787.5 -812.5 792.5 -812.5 {}
L 1 787.5 -810 792.5 -810 {}
L 1 787.5 -807.5 792.5 -807.5 {}
L 1 787.5 -805 792.5 -805 {}
L 1 787.5 -802.5 792.5 -802.5 {}
L 1 787.5 -800 792.5 -800 {}
L 1 787.5 -797.5 792.5 -797.5 {}
L 1 787.5 -795 792.5 -795 {}
L 1 787.5 -792.5 792.5 -792.5 {}
L 1 1647.5 517.5 1652.5 517.5 {}
L 1 1647.5 520 1652.5 520 {}
L 1 1647.5 522.5 1652.5 522.5 {}
L 1 1647.5 525 1652.5 525 {}
L 1 1647.5 527.5 1652.5 527.5 {}
L 1 1647.5 530 1652.5 530 {}
L 1 1647.5 532.5 1652.5 532.5 {}
L 1 1647.5 535 1652.5 535 {}
L 1 1647.5 537.5 1652.5 537.5 {}
L 1 620 -1080 870 -1080 {}
L 1 1160 -1080 1410 -1080 {}
L 1 1790 -1080 2040 -1080 {}
L 1 1830 -1250 1830 -1130 {}
L 1 457.5 -4302.5 462.5 -4302.5 {}
L 1 457.5 -4300 462.5 -4300 {}
L 1 457.5 -4297.5 462.5 -4297.5 {}
L 1 457.5 -4295 462.5 -4295 {}
L 1 457.5 -4292.5 462.5 -4292.5 {}
L 1 457.5 -4290 462.5 -4290 {}
L 1 457.5 -4287.5 462.5 -4287.5 {}
L 1 457.5 -4285 462.5 -4285 {}
L 1 457.5 -4282.5 462.5 -4282.5 {}
L 1 1060 -4490 1300 -4490 {}
L 1 997.5 -4482.5 1002.5 -4482.5 {}
L 1 997.5 -4480 1002.5 -4480 {}
L 1 997.5 -4477.5 1002.5 -4477.5 {}
L 1 997.5 -4475 1002.5 -4475 {}
L 1 997.5 -4472.5 1002.5 -4472.5 {}
L 1 997.5 -4470 1002.5 -4470 {}
L 1 997.5 -4467.5 1002.5 -4467.5 {}
L 1 997.5 -4465 1002.5 -4465 {}
L 1 997.5 -4462.5 1002.5 -4462.5 {}
L 1 1620 -4490 1860 -4490 {}
L 1 2007.5 -4272.5 2012.5 -4272.5 {}
L 1 2007.5 -4270 2012.5 -4270 {}
L 1 2007.5 -4267.5 2012.5 -4267.5 {}
L 1 2007.5 -4265 2012.5 -4265 {}
L 1 2007.5 -4262.5 2012.5 -4262.5 {}
L 1 2007.5 -4260 2012.5 -4260 {}
L 1 2007.5 -4257.5 2012.5 -4257.5 {}
L 1 2007.5 -4255 2012.5 -4255 {}
L 1 2007.5 -4252.5 2012.5 -4252.5 {}
L 1 1620 -4490 1620 -4310 {}
L 1 2190 -4490 2430 -4490 {}
L 1 2577.5 -4272.5 2582.5 -4272.5 {}
L 1 2577.5 -4270 2582.5 -4270 {}
L 1 2577.5 -4267.5 2582.5 -4267.5 {}
L 1 2577.5 -4265 2582.5 -4265 {}
L 1 2577.5 -4262.5 2582.5 -4262.5 {}
L 1 2577.5 -4260 2582.5 -4260 {}
L 1 2577.5 -4257.5 2582.5 -4257.5 {}
L 1 2577.5 -4255 2582.5 -4255 {}
L 1 2577.5 -4252.5 2582.5 -4252.5 {}
L 1 2190 -4490 2190 -4310 {}
L 1 2277.5 -5062.5 2282.5 -5062.5 {}
L 1 2277.5 -5060 2282.5 -5060 {}
L 1 2277.5 -5057.5 2282.5 -5057.5 {}
L 1 2277.5 -5055 2282.5 -5055 {}
L 1 2277.5 -5052.5 2282.5 -5052.5 {}
L 1 2277.5 -5050 2282.5 -5050 {}
L 1 2277.5 -5047.5 2282.5 -5047.5 {}
L 1 2277.5 -5045 2282.5 -5045 {}
L 1 2277.5 -5042.5 2282.5 -5042.5 {}
L 1 1977.5 -3172.5 1982.5 -3172.5 {}
L 1 1977.5 -3170 1982.5 -3170 {}
L 1 1977.5 -3167.5 1982.5 -3167.5 {}
L 1 1977.5 -3165 1982.5 -3165 {}
L 1 1977.5 -3162.5 1982.5 -3162.5 {}
L 1 1977.5 -3160 1982.5 -3160 {}
L 1 1977.5 -3157.5 1982.5 -3157.5 {}
L 1 1977.5 -3155 1982.5 -3155 {}
L 1 1977.5 -3152.5 1982.5 -3152.5 {}
L 1 2337.5 -1472.5 2342.5 -1472.5 {}
L 1 2337.5 -1470 2342.5 -1470 {}
L 1 2337.5 -1467.5 2342.5 -1467.5 {}
L 1 2337.5 -1465 2342.5 -1465 {}
L 1 2337.5 -1462.5 2342.5 -1462.5 {}
L 1 2337.5 -1460 2342.5 -1460 {}
L 1 2337.5 -1457.5 2342.5 -1457.5 {}
L 1 2337.5 -1455 2342.5 -1455 {}
L 1 2337.5 -1452.5 2342.5 -1452.5 {}
L 1 807.5 -1592.5 812.5 -1592.5 {}
L 1 807.5 -1590 812.5 -1590 {}
L 1 807.5 -1587.5 812.5 -1587.5 {}
L 1 807.5 -1585 812.5 -1585 {}
L 1 807.5 -1582.5 812.5 -1582.5 {}
L 1 807.5 -1580 812.5 -1580 {}
L 1 807.5 -1577.5 812.5 -1577.5 {}
L 1 807.5 -1575 812.5 -1575 {}
L 1 807.5 -1572.5 812.5 -1572.5 {}
L 1 1347.5 -1572.5 1352.5 -1572.5 {}
L 1 1347.5 -1570 1352.5 -1570 {}
L 1 1347.5 -1567.5 1352.5 -1567.5 {}
L 1 1347.5 -1565 1352.5 -1565 {}
L 1 1347.5 -1562.5 1352.5 -1562.5 {}
L 1 1347.5 -1560 1352.5 -1560 {}
L 1 1347.5 -1557.5 1352.5 -1557.5 {}
L 1 1347.5 -1555 1352.5 -1555 {}
L 1 1347.5 -1552.5 1352.5 -1552.5 {}
L 1 2320 -1250 2320 -1130 {}
L 1 1257.5 -1192.5 1262.5 -1192.5 {}
L 1 1257.5 -1190 1262.5 -1190 {}
L 1 1257.5 -1187.5 1262.5 -1187.5 {}
L 1 1257.5 -1185 1262.5 -1185 {}
L 1 1257.5 -1182.5 1262.5 -1182.5 {}
L 1 1257.5 -1180 1262.5 -1180 {}
L 1 1257.5 -1177.5 1262.5 -1177.5 {}
L 1 1257.5 -1175 1262.5 -1175 {}
L 1 1257.5 -1172.5 1262.5 -1172.5 {}
L 1 2517.5 -1142.5 2522.5 -1142.5 {}
L 1 2517.5 -1140 2522.5 -1140 {}
L 1 2517.5 -1137.5 2522.5 -1137.5 {}
L 1 2517.5 -1135 2522.5 -1135 {}
L 1 2517.5 -1132.5 2522.5 -1132.5 {}
L 1 2517.5 -1130 2522.5 -1130 {}
L 1 2517.5 -1127.5 2522.5 -1127.5 {}
L 1 2517.5 -1125 2522.5 -1125 {}
L 1 2517.5 -1122.5 2522.5 -1122.5 {}
L 1 2477.5 267.5 2482.5 267.5 {}
L 1 2477.5 270 2482.5 270 {}
L 1 2477.5 272.5 2482.5 272.5 {}
L 1 2477.5 275 2482.5 275 {}
L 1 2477.5 277.5 2482.5 277.5 {}
L 1 2477.5 280 2482.5 280 {}
L 1 2477.5 282.5 2482.5 282.5 {}
L 1 2477.5 285 2482.5 285 {}
L 1 2477.5 287.5 2482.5 287.5 {}
L 1 457.5 -3962.5 462.5 -3962.5 {}
L 1 457.5 -3960 462.5 -3960 {}
L 1 457.5 -3957.5 462.5 -3957.5 {}
L 1 457.5 -3955 462.5 -3955 {}
L 1 457.5 -3952.5 462.5 -3952.5 {}
L 1 457.5 -3950 462.5 -3950 {}
L 1 457.5 -3947.5 462.5 -3947.5 {}
L 1 457.5 -3945 462.5 -3945 {}
L 1 457.5 -3942.5 462.5 -3942.5 {}
L 1 817.5 -4832.5 822.5 -4832.5 {}
L 1 817.5 -4830 822.5 -4830 {}
L 1 817.5 -4827.5 822.5 -4827.5 {}
L 1 817.5 -4825 822.5 -4825 {}
L 1 817.5 -4822.5 822.5 -4822.5 {}
L 1 817.5 -4820 822.5 -4820 {}
L 1 817.5 -4817.5 822.5 -4817.5 {}
L 1 817.5 -4815 822.5 -4815 {}
L 1 817.5 -4812.5 822.5 -4812.5 {}
L 1 477.5 -6992.5 482.5 -6992.5 {}
L 1 477.5 -6990 482.5 -6990 {}
L 1 477.5 -6987.5 482.5 -6987.5 {}
L 1 477.5 -6985 482.5 -6985 {}
L 1 477.5 -6982.5 482.5 -6982.5 {}
L 1 477.5 -6980 482.5 -6980 {}
L 1 477.5 -6977.5 482.5 -6977.5 {}
L 1 477.5 -6975 482.5 -6975 {}
L 1 477.5 -6972.5 482.5 -6972.5 {}
L 1 667.5 -7102.5 672.5 -7102.5 {}
L 1 667.5 -7100 672.5 -7100 {}
L 1 667.5 -7097.5 672.5 -7097.5 {}
L 1 667.5 -7095 672.5 -7095 {}
L 1 667.5 -7092.5 672.5 -7092.5 {}
L 1 667.5 -7090 672.5 -7090 {}
L 1 667.5 -7087.5 672.5 -7087.5 {}
L 1 667.5 -7085 672.5 -7085 {}
L 1 667.5 -7082.5 672.5 -7082.5 {}
L 1 897.5 -7062.5 902.5 -7062.5 {}
L 1 897.5 -7060 902.5 -7060 {}
L 1 897.5 -7057.5 902.5 -7057.5 {}
L 1 897.5 -7055 902.5 -7055 {}
L 1 897.5 -7052.5 902.5 -7052.5 {}
L 1 897.5 -7050 902.5 -7050 {}
L 1 897.5 -7047.5 902.5 -7047.5 {}
L 1 897.5 -7045 902.5 -7045 {}
L 1 897.5 -7042.5 902.5 -7042.5 {}
L 1 800 -7100 800 -6990 {}
L 1 1107.5 -7102.5 1112.5 -7102.5 {}
L 1 1107.5 -7100 1112.5 -7100 {}
L 1 1107.5 -7097.5 1112.5 -7097.5 {}
L 1 1107.5 -7095 1112.5 -7095 {}
L 1 1107.5 -7092.5 1112.5 -7092.5 {}
L 1 1107.5 -7090 1112.5 -7090 {}
L 1 1107.5 -7087.5 1112.5 -7087.5 {}
L 1 1107.5 -7085 1112.5 -7085 {}
L 1 1107.5 -7082.5 1112.5 -7082.5 {}
L 1 1050 -7100 1050 -6990 {}
L 1 1377.5 -7102.5 1382.5 -7102.5 {}
L 1 1377.5 -7100 1382.5 -7100 {}
L 1 1377.5 -7097.5 1382.5 -7097.5 {}
L 1 1377.5 -7095 1382.5 -7095 {}
L 1 1377.5 -7092.5 1382.5 -7092.5 {}
L 1 1377.5 -7090 1382.5 -7090 {}
L 1 1377.5 -7087.5 1382.5 -7087.5 {}
L 1 1377.5 -7085 1382.5 -7085 {}
L 1 1377.5 -7082.5 1382.5 -7082.5 {}
L 1 1240 -7100 1240 -6990 {}
L 1 1717.5 -6962.5 1722.5 -6962.5 {}
L 1 1717.5 -6960 1722.5 -6960 {}
L 1 1717.5 -6957.5 1722.5 -6957.5 {}
L 1 1717.5 -6955 1722.5 -6955 {}
L 1 1717.5 -6952.5 1722.5 -6952.5 {}
L 1 1717.5 -6950 1722.5 -6950 {}
L 1 1717.5 -6947.5 1722.5 -6947.5 {}
L 1 1717.5 -6945 1722.5 -6945 {}
L 1 1717.5 -6942.5 1722.5 -6942.5 {}
L 1 1530 -7100 1530 -6990 {}
L 1 1530 -7100 1610 -7100 {}
L 1 1967.5 -7072.5 1972.5 -7072.5 {}
L 1 1967.5 -7070 1972.5 -7070 {}
L 1 1967.5 -7067.5 1972.5 -7067.5 {}
L 1 1967.5 -7065 1972.5 -7065 {}
L 1 1967.5 -7062.5 1972.5 -7062.5 {}
L 1 1967.5 -7060 1972.5 -7060 {}
L 1 1967.5 -7057.5 1972.5 -7057.5 {}
L 1 1967.5 -7055 1972.5 -7055 {}
L 1 1967.5 -7052.5 1972.5 -7052.5 {}
L 1 1860 -7100 1860 -6990 {}
L 1 2587.5 -7072.5 2592.5 -7072.5 {}
L 1 2587.5 -7070 2592.5 -7070 {}
L 1 2587.5 -7067.5 2592.5 -7067.5 {}
L 1 2587.5 -7065 2592.5 -7065 {}
L 1 2587.5 -7062.5 2592.5 -7062.5 {}
L 1 2587.5 -7060 2592.5 -7060 {}
L 1 2587.5 -7057.5 2592.5 -7057.5 {}
L 1 2587.5 -7055 2592.5 -7055 {}
L 1 2587.5 -7052.5 2592.5 -7052.5 {}
L 1 2400 -7100 2400 -6990 {}
L 1 2247.5 -7072.5 2252.5 -7072.5 {}
L 1 2247.5 -7070 2252.5 -7070 {}
L 1 2247.5 -7067.5 2252.5 -7067.5 {}
L 1 2247.5 -7065 2252.5 -7065 {}
L 1 2247.5 -7062.5 2252.5 -7062.5 {}
L 1 2247.5 -7060 2252.5 -7060 {}
L 1 2247.5 -7057.5 2252.5 -7057.5 {}
L 1 2247.5 -7055 2252.5 -7055 {}
L 1 2247.5 -7052.5 2252.5 -7052.5 {}
L 1 2110 -7100 2110 -6990 {}
L 1 2380 -3600 2500 -3600 {}
L 1 2380 -3540 2500 -3540 {}
L 2 1255 -8250 1255 -8190 {}
L 2 1255 -8240 1270 -8240 {}
L 2 1270 -8250 1270 -8240 {}
L 2 1255 -8200 1270 -8200 {}
L 2 1270 -8200 1270 -8190 {}
L 2 1245 -8235 1245 -8205 {}
L 2 1245 -8220 1245 -8215 {}
L 2 1230 -8220 1237.5 -8220 {}
L 2 1230 -8220 1245 -8220 {}
L 2 1260 -8220 1270 -8220 {}
L 2 1255 -8225 1260 -8220 {}
L 2 1255 -8215 1260 -8220 {}
L 2 1270 -8290 1270 -8280 {}
L 2 1270 -8290 1277.5 -8292.5 {}
L 2 1262.5 -8297.5 1277.5 -8292.5 {}
L 2 1262.5 -8297.5 1277.5 -8302.5 {}
L 2 1262.5 -8307.5 1277.5 -8302.5 {}
L 2 1262.5 -8307.5 1277.5 -8312.5 {}
L 2 1262.5 -8317.5 1277.5 -8312.5 {}
L 2 1262.5 -8317.5 1277.5 -8322.5 {}
L 2 1262.5 -8327.5 1277.5 -8322.5 {}
L 2 1262.5 -8327.5 1270 -8330 {}
L 2 1270 -8340 1270 -8330 {}
L 2 1272.5 -8332.5 1277.5 -8332.5 {}
L 2 1275 -8335 1275 -8330 {}
L 2 1360 -8215 1360 -8190 {}
L 2 1360 -8250 1360 -8225 {}
L 2 1350 -8225 1370 -8225 {}
L 2 1350 -8215 1370 -8215 {}
L 2 1362.5 -8242.5 1367.5 -8242.5 {}
L 2 1365 -8245 1365 -8240 {}
L 2 1270 -8280 1270 -8250 {}
L 2 1270 -8370 1270 -8340 {}
L 2 1360 -8190 1360 -8110 {}
L 2 1270 -8220 1270 -8110 {}
L 2 1270 -8110 1360 -8110 {}
L 2 2035 -8260 2035 -8200 {}
L 2 2035 -8250 2050 -8250 {}
L 2 2050 -8260 2050 -8250 {}
L 2 2035 -8210 2050 -8210 {}
L 2 2050 -8210 2050 -8200 {}
L 2 2025 -8245 2025 -8215 {}
L 2 2025 -8230 2025 -8225 {}
L 2 2010 -8230 2017.5 -8230 {}
L 2 2010 -8230 2025 -8230 {}
L 2 2040 -8230 2050 -8230 {}
L 2 2035 -8235 2040 -8230 {}
L 2 2035 -8225 2040 -8230 {}
L 2 2050 -8300 2050 -8290 {}
L 2 2050 -8300 2057.5 -8302.5 {}
L 2 2042.5 -8307.5 2057.5 -8302.5 {}
L 2 2042.5 -8307.5 2057.5 -8312.5 {}
L 2 2042.5 -8317.5 2057.5 -8312.5 {}
L 2 2042.5 -8317.5 2057.5 -8322.5 {}
L 2 2042.5 -8327.5 2057.5 -8322.5 {}
L 2 2042.5 -8327.5 2057.5 -8332.5 {}
L 2 2042.5 -8337.5 2057.5 -8332.5 {}
L 2 2042.5 -8337.5 2050 -8340 {}
L 2 2050 -8350 2050 -8340 {}
L 2 2052.5 -8342.5 2057.5 -8342.5 {}
L 2 2055 -8345 2055 -8340 {}
L 2 2140 -8225 2140 -8200 {}
L 2 2140 -8260 2140 -8235 {}
L 2 2130 -8235 2150 -8235 {}
L 2 2130 -8225 2150 -8225 {}
L 2 2142.5 -8252.5 2147.5 -8252.5 {}
L 2 2145 -8255 2145 -8250 {}
L 2 2050 -8290 2050 -8260 {}
L 2 2050 -8380 2050 -8350 {}
L 2 2140 -8200 2140 -8120 {}
L 2 2050 -8230 2050 -8120 {}
L 2 2050 -8120 2140 -8120 {}
L 2 1360 -7830 1360 -7820 {}
L 2 1360 -7830 1367.5 -7832.5 {}
L 2 1352.5 -7837.5 1367.5 -7832.5 {}
L 2 1352.5 -7837.5 1367.5 -7842.5 {}
L 2 1352.5 -7847.5 1367.5 -7842.5 {}
L 2 1352.5 -7847.5 1367.5 -7852.5 {}
L 2 1352.5 -7857.5 1367.5 -7852.5 {}
L 2 1352.5 -7857.5 1367.5 -7862.5 {}
L 2 1352.5 -7867.5 1367.5 -7862.5 {}
L 2 1352.5 -7867.5 1360 -7870 {}
L 2 1360 -7880 1360 -7870 {}
L 2 1362.5 -7872.5 1367.5 -7872.5 {}
L 2 1365 -7875 1365 -7870 {}
L 2 1360 -6210 1360 -6200 {}
L 2 1360 -6210 1367.5 -6212.5 {}
L 2 1352.5 -6217.5 1367.5 -6212.5 {}
L 2 1352.5 -6217.5 1367.5 -6222.5 {}
L 2 1352.5 -6227.5 1367.5 -6222.5 {}
L 2 1352.5 -6227.5 1367.5 -6232.5 {}
L 2 1352.5 -6237.5 1367.5 -6232.5 {}
L 2 1352.5 -6237.5 1367.5 -6242.5 {}
L 2 1352.5 -6247.5 1367.5 -6242.5 {}
L 2 1352.5 -6247.5 1360 -6250 {}
L 2 1360 -6260 1360 -6250 {}
L 2 1362.5 -6252.5 1367.5 -6252.5 {}
L 2 1365 -6255 1365 -6250 {}
L 2 1280 -6260 1360 -6260 {}
L 2 1280 -6200 1360 -6200 {}
L 2 1360 -5720 1360 -5710 {}
L 2 1360 -5720 1367.5 -5722.5 {}
L 2 1352.5 -5727.5 1367.5 -5722.5 {}
L 2 1352.5 -5727.5 1367.5 -5732.5 {}
L 2 1352.5 -5737.5 1367.5 -5732.5 {}
L 2 1352.5 -5737.5 1367.5 -5742.5 {}
L 2 1352.5 -5747.5 1367.5 -5742.5 {}
L 2 1352.5 -5747.5 1367.5 -5752.5 {}
L 2 1352.5 -5757.5 1367.5 -5752.5 {}
L 2 1352.5 -5757.5 1360 -5760 {}
L 2 1360 -5770 1360 -5760 {}
L 2 1362.5 -5762.5 1367.5 -5762.5 {}
L 2 1365 -5765 1365 -5760 {}
L 2 1280 -5680 1360 -5710 {}
L 2 1280 -5800 1360 -5770 {}
L 2 725 -8250 725 -8190 {}
L 2 725 -8240 740 -8240 {}
L 2 740 -8250 740 -8240 {}
L 2 725 -8200 740 -8200 {}
L 2 740 -8200 740 -8190 {}
L 2 715 -8235 715 -8205 {}
L 2 715 -8220 715 -8215 {}
L 2 700 -8220 707.5 -8220 {}
L 2 700 -8220 715 -8220 {}
L 2 730 -8220 740 -8220 {}
L 2 725 -8225 730 -8220 {}
L 2 725 -8215 730 -8220 {}
L 2 740 -8290 740 -8280 {}
L 2 740 -8290 747.5 -8292.5 {}
L 2 732.5 -8297.5 747.5 -8292.5 {}
L 2 732.5 -8297.5 747.5 -8302.5 {}
L 2 732.5 -8307.5 747.5 -8302.5 {}
L 2 732.5 -8307.5 747.5 -8312.5 {}
L 2 732.5 -8317.5 747.5 -8312.5 {}
L 2 732.5 -8317.5 747.5 -8322.5 {}
L 2 732.5 -8327.5 747.5 -8322.5 {}
L 2 732.5 -8327.5 740 -8330 {}
L 2 740 -8340 740 -8330 {}
L 2 742.5 -8332.5 747.5 -8332.5 {}
L 2 745 -8335 745 -8330 {}
L 2 830 -8215 830 -8190 {}
L 2 830 -8250 830 -8225 {}
L 2 820 -8225 840 -8225 {}
L 2 820 -8215 840 -8215 {}
L 2 832.5 -8242.5 837.5 -8242.5 {}
L 2 835 -8245 835 -8240 {}
L 2 740 -8280 740 -8250 {}
L 2 740 -8370 740 -8340 {}
L 2 830 -8190 830 -8110 {}
L 2 740 -8220 740 -8110 {}
L 2 740 -8110 830 -8110 {}
L 2 725 -5190 725 -5130 {}
L 2 725 -5180 740 -5180 {}
L 2 740 -5190 740 -5180 {}
L 2 725 -5140 740 -5140 {}
L 2 740 -5140 740 -5130 {}
L 2 715 -5175 715 -5145 {}
L 2 715 -5160 715 -5155 {}
L 2 700 -5160 707.5 -5160 {}
L 2 700 -5160 715 -5160 {}
L 2 730 -5160 740 -5160 {}
L 2 725 -5165 730 -5160 {}
L 2 725 -5155 730 -5160 {}
L 2 740 -5230 740 -5220 {}
L 2 740 -5230 747.5 -5232.5 {}
L 2 732.5 -5237.5 747.5 -5232.5 {}
L 2 732.5 -5237.5 747.5 -5242.5 {}
L 2 732.5 -5247.5 747.5 -5242.5 {}
L 2 732.5 -5247.5 747.5 -5252.5 {}
L 2 732.5 -5257.5 747.5 -5252.5 {}
L 2 732.5 -5257.5 747.5 -5262.5 {}
L 2 732.5 -5267.5 747.5 -5262.5 {}
L 2 732.5 -5267.5 740 -5270 {}
L 2 740 -5280 740 -5270 {}
L 2 742.5 -5272.5 747.5 -5272.5 {}
L 2 745 -5275 745 -5270 {}
L 2 830 -5155 830 -5130 {}
L 2 830 -5190 830 -5165 {}
L 2 820 -5165 840 -5165 {}
L 2 820 -5155 840 -5155 {}
L 2 832.5 -5182.5 837.5 -5182.5 {}
L 2 835 -5185 835 -5180 {}
L 2 740 -5220 740 -5190 {}
L 2 740 -5310 740 -5280 {}
L 2 830 -5130 830 -5050 {}
L 2 740 -5160 740 -5050 {}
L 2 740 -5050 830 -5050 {}
L 2 880 -5190 888.75 -5190 {}
L 2 740 -5190 880 -5190 {}
L 2 1265 -5190 1265 -5130 {}
L 2 1265 -5180 1280 -5180 {}
L 2 1280 -5190 1280 -5180 {}
L 2 1265 -5140 1280 -5140 {}
L 2 1280 -5140 1280 -5130 {}
L 2 1255 -5175 1255 -5145 {}
L 2 1255 -5160 1255 -5155 {}
L 2 1240 -5160 1247.5 -5160 {}
L 2 1240 -5160 1255 -5160 {}
L 2 1270 -5160 1280 -5160 {}
L 2 1265 -5165 1270 -5160 {}
L 2 1265 -5155 1270 -5160 {}
L 2 1280 -5230 1280 -5220 {}
L 2 1280 -5230 1287.5 -5232.5 {}
L 2 1272.5 -5237.5 1287.5 -5232.5 {}
L 2 1272.5 -5237.5 1287.5 -5242.5 {}
L 2 1272.5 -5247.5 1287.5 -5242.5 {}
L 2 1272.5 -5247.5 1287.5 -5252.5 {}
L 2 1272.5 -5257.5 1287.5 -5252.5 {}
L 2 1272.5 -5257.5 1287.5 -5262.5 {}
L 2 1272.5 -5267.5 1287.5 -5262.5 {}
L 2 1272.5 -5267.5 1280 -5270 {}
L 2 1280 -5280 1280 -5270 {}
L 2 1282.5 -5272.5 1287.5 -5272.5 {}
L 2 1285 -5275 1285 -5270 {}
L 2 1370 -5155 1370 -5130 {}
L 2 1370 -5190 1370 -5165 {}
L 2 1360 -5165 1380 -5165 {}
L 2 1360 -5155 1380 -5155 {}
L 2 1372.5 -5182.5 1377.5 -5182.5 {}
L 2 1375 -5185 1375 -5180 {}
L 2 1420 -5190 1428.75 -5190 {}
L 2 1280 -5220 1280 -5190 {}
L 2 1280 -5310 1280 -5280 {}
L 2 1280 -5190 1420 -5190 {}
L 2 1370 -5130 1370 -5050 {}
L 2 1280 -5160 1280 -5050 {}
L 2 1280 -5050 1370 -5050 {}
L 2 2105 -5190 2105 -5130 {}
L 2 2105 -5180 2120 -5180 {}
L 2 2120 -5190 2120 -5180 {}
L 2 2105 -5140 2120 -5140 {}
L 2 2120 -5140 2120 -5130 {}
L 2 2095 -5175 2095 -5145 {}
L 2 2095 -5160 2095 -5155 {}
L 2 2080 -5160 2087.5 -5160 {}
L 2 2080 -5160 2095 -5160 {}
L 2 2110 -5160 2120 -5160 {}
L 2 2105 -5165 2110 -5160 {}
L 2 2105 -5155 2110 -5160 {}
L 2 2120 -5230 2120 -5220 {}
L 2 2120 -5230 2127.5 -5232.5 {}
L 2 2112.5 -5237.5 2127.5 -5232.5 {}
L 2 2112.5 -5237.5 2127.5 -5242.5 {}
L 2 2112.5 -5247.5 2127.5 -5242.5 {}
L 2 2112.5 -5247.5 2127.5 -5252.5 {}
L 2 2112.5 -5257.5 2127.5 -5252.5 {}
L 2 2112.5 -5257.5 2127.5 -5262.5 {}
L 2 2112.5 -5267.5 2127.5 -5262.5 {}
L 2 2112.5 -5267.5 2120 -5270 {}
L 2 2120 -5280 2120 -5270 {}
L 2 2122.5 -5272.5 2127.5 -5272.5 {}
L 2 2125 -5275 2125 -5270 {}
L 2 2210 -5155 2210 -5130 {}
L 2 2210 -5190 2210 -5165 {}
L 2 2200 -5165 2220 -5165 {}
L 2 2200 -5155 2220 -5155 {}
L 2 2212.5 -5182.5 2217.5 -5182.5 {}
L 2 2215 -5185 2215 -5180 {}
L 2 2260 -5190 2268.75 -5190 {}
L 2 2120 -5220 2120 -5190 {}
L 2 2120 -5310 2120 -5280 {}
L 2 2120 -5190 2260 -5190 {}
L 2 2210 -5130 2210 -5050 {}
L 2 2120 -5160 2120 -5050 {}
L 2 2120 -5050 2210 -5050 {}
L 2 1770 -5160 2080 -5160 {}
L 2 1690 -5310 2120 -5310 {}
L 2 1690 -5050 2120 -5050 {}
L 2 1255 -7420 1255 -7360 {}
L 2 1255 -7410 1270 -7410 {}
L 2 1270 -7420 1270 -7410 {}
L 2 1255 -7370 1270 -7370 {}
L 2 1270 -7370 1270 -7360 {}
L 2 1245 -7405 1245 -7375 {}
L 2 1245 -7390 1245 -7385 {}
L 2 1230 -7390 1237.5 -7390 {}
L 2 1230 -7390 1245 -7390 {}
L 2 1260 -7390 1270 -7390 {}
L 2 1255 -7395 1260 -7390 {}
L 2 1255 -7385 1260 -7390 {}
L 2 1270 -7460 1270 -7450 {}
L 2 1270 -7460 1277.5 -7462.5 {}
L 2 1262.5 -7467.5 1277.5 -7462.5 {}
L 2 1262.5 -7467.5 1277.5 -7472.5 {}
L 2 1262.5 -7477.5 1277.5 -7472.5 {}
L 2 1262.5 -7477.5 1277.5 -7482.5 {}
L 2 1262.5 -7487.5 1277.5 -7482.5 {}
L 2 1262.5 -7487.5 1277.5 -7492.5 {}
L 2 1262.5 -7497.5 1277.5 -7492.5 {}
L 2 1262.5 -7497.5 1270 -7500 {}
L 2 1270 -7510 1270 -7500 {}
L 2 1272.5 -7502.5 1277.5 -7502.5 {}
L 2 1275 -7505 1275 -7500 {}
L 2 1360 -7385 1360 -7360 {}
L 2 1360 -7420 1360 -7395 {}
L 2 1350 -7395 1370 -7395 {}
L 2 1350 -7385 1370 -7385 {}
L 2 1362.5 -7412.5 1367.5 -7412.5 {}
L 2 1365 -7415 1365 -7410 {}
L 2 1270 -7450 1270 -7420 {}
L 2 1270 -7540 1270 -7510 {}
L 2 1360 -7360 1360 -7280 {}
L 2 1270 -7390 1270 -7280 {}
L 2 1270 -7280 1360 -7280 {}
L 2 2035 -7430 2035 -7370 {}
L 2 2035 -7420 2050 -7420 {}
L 2 2050 -7430 2050 -7420 {}
L 2 2035 -7380 2050 -7380 {}
L 2 2050 -7380 2050 -7370 {}
L 2 2025 -7415 2025 -7385 {}
L 2 2025 -7400 2025 -7395 {}
L 2 2010 -7400 2017.5 -7400 {}
L 2 2010 -7400 2025 -7400 {}
L 2 2040 -7400 2050 -7400 {}
L 2 2035 -7405 2040 -7400 {}
L 2 2035 -7395 2040 -7400 {}
L 2 2050 -7470 2050 -7460 {}
L 2 2050 -7470 2057.5 -7472.5 {}
L 2 2042.5 -7477.5 2057.5 -7472.5 {}
L 2 2042.5 -7477.5 2057.5 -7482.5 {}
L 2 2042.5 -7487.5 2057.5 -7482.5 {}
L 2 2042.5 -7487.5 2057.5 -7492.5 {}
L 2 2042.5 -7497.5 2057.5 -7492.5 {}
L 2 2042.5 -7497.5 2057.5 -7502.5 {}
L 2 2042.5 -7507.5 2057.5 -7502.5 {}
L 2 2042.5 -7507.5 2050 -7510 {}
L 2 2050 -7520 2050 -7510 {}
L 2 2052.5 -7512.5 2057.5 -7512.5 {}
L 2 2055 -7515 2055 -7510 {}
L 2 2140 -7395 2140 -7370 {}
L 2 2140 -7430 2140 -7405 {}
L 2 2130 -7405 2150 -7405 {}
L 2 2130 -7395 2150 -7395 {}
L 2 2142.5 -7422.5 2147.5 -7422.5 {}
L 2 2145 -7425 2145 -7420 {}
L 2 2050 -7460 2050 -7430 {}
L 2 2050 -7550 2050 -7520 {}
L 2 2140 -7370 2140 -7290 {}
L 2 2050 -7400 2050 -7290 {}
L 2 2050 -7290 2140 -7290 {}
L 2 725 -7420 725 -7360 {}
L 2 725 -7410 740 -7410 {}
L 2 740 -7420 740 -7410 {}
L 2 725 -7370 740 -7370 {}
L 2 740 -7370 740 -7360 {}
L 2 715 -7405 715 -7375 {}
L 2 715 -7390 715 -7385 {}
L 2 700 -7390 707.5 -7390 {}
L 2 700 -7390 715 -7390 {}
L 2 730 -7390 740 -7390 {}
L 2 725 -7395 730 -7390 {}
L 2 725 -7385 730 -7390 {}
L 2 740 -7460 740 -7450 {}
L 2 740 -7460 747.5 -7462.5 {}
L 2 732.5 -7467.5 747.5 -7462.5 {}
L 2 732.5 -7467.5 747.5 -7472.5 {}
L 2 732.5 -7477.5 747.5 -7472.5 {}
L 2 732.5 -7477.5 747.5 -7482.5 {}
L 2 732.5 -7487.5 747.5 -7482.5 {}
L 2 732.5 -7487.5 747.5 -7492.5 {}
L 2 732.5 -7497.5 747.5 -7492.5 {}
L 2 732.5 -7497.5 740 -7500 {}
L 2 740 -7510 740 -7500 {}
L 2 742.5 -7502.5 747.5 -7502.5 {}
L 2 745 -7505 745 -7500 {}
L 2 830 -7385 830 -7360 {}
L 2 830 -7420 830 -7395 {}
L 2 820 -7395 840 -7395 {}
L 2 820 -7385 840 -7385 {}
L 2 832.5 -7412.5 837.5 -7412.5 {}
L 2 835 -7415 835 -7410 {}
L 2 740 -7450 740 -7420 {}
L 2 740 -7540 740 -7510 {}
L 2 830 -7360 830 -7280 {}
L 2 740 -7390 740 -7280 {}
L 2 740 -7280 830 -7280 {}
L 2 1795 -8720 1795 -8660 {}
L 2 1795 -8710 1810 -8710 {}
L 2 1810 -8720 1810 -8710 {}
L 2 1795 -8670 1810 -8670 {}
L 2 1810 -8670 1810 -8660 {}
L 2 1785 -8705 1785 -8675 {}
L 2 1785 -8690 1785 -8685 {}
L 2 1770 -8690 1777.5 -8690 {}
L 2 1770 -8690 1785 -8690 {}
L 2 1800 -8690 1810 -8690 {}
L 2 1795 -8695 1800 -8690 {}
L 2 1795 -8685 1800 -8690 {}
L 2 1810 -8760 1810 -8750 {}
L 2 1810 -8760 1817.5 -8762.5 {}
L 2 1802.5 -8767.5 1817.5 -8762.5 {}
L 2 1802.5 -8767.5 1817.5 -8772.5 {}
L 2 1802.5 -8777.5 1817.5 -8772.5 {}
L 2 1802.5 -8777.5 1817.5 -8782.5 {}
L 2 1802.5 -8787.5 1817.5 -8782.5 {}
L 2 1802.5 -8787.5 1817.5 -8792.5 {}
L 2 1802.5 -8797.5 1817.5 -8792.5 {}
L 2 1802.5 -8797.5 1810 -8800 {}
L 2 1810 -8810 1810 -8800 {}
L 2 1812.5 -8802.5 1817.5 -8802.5 {}
L 2 1815 -8805 1815 -8800 {}
L 2 1900 -8685 1900 -8660 {}
L 2 1900 -8720 1900 -8695 {}
L 2 1890 -8695 1910 -8695 {}
L 2 1890 -8685 1910 -8685 {}
L 2 1902.5 -8712.5 1907.5 -8712.5 {}
L 2 1905 -8715 1905 -8710 {}
L 2 1810 -8750 1810 -8720 {}
L 2 1810 -8840 1810 -8810 {}
L 2 1900 -8660 1900 -8580 {}
L 2 1810 -8690 1810 -8580 {}
L 2 1810 -8580 1900 -8580 {}
L 2 725 -8720 725 -8660 {}
L 2 725 -8710 740 -8710 {}
L 2 740 -8720 740 -8710 {}
L 2 725 -8670 740 -8670 {}
L 2 740 -8670 740 -8660 {}
L 2 715 -8705 715 -8675 {}
L 2 715 -8690 715 -8685 {}
L 2 700 -8690 707.5 -8690 {}
L 2 700 -8690 715 -8690 {}
L 2 730 -8690 740 -8690 {}
L 2 725 -8695 730 -8690 {}
L 2 725 -8685 730 -8690 {}
L 2 740 -8760 740 -8750 {}
L 2 740 -8760 747.5 -8762.5 {}
L 2 732.5 -8767.5 747.5 -8762.5 {}
L 2 732.5 -8767.5 747.5 -8772.5 {}
L 2 732.5 -8777.5 747.5 -8772.5 {}
L 2 732.5 -8777.5 747.5 -8782.5 {}
L 2 732.5 -8787.5 747.5 -8782.5 {}
L 2 732.5 -8787.5 747.5 -8792.5 {}
L 2 732.5 -8797.5 747.5 -8792.5 {}
L 2 732.5 -8797.5 740 -8800 {}
L 2 740 -8810 740 -8800 {}
L 2 742.5 -8802.5 747.5 -8802.5 {}
L 2 745 -8805 745 -8800 {}
L 2 830 -8685 830 -8660 {}
L 2 830 -8720 830 -8695 {}
L 2 820 -8695 840 -8695 {}
L 2 820 -8685 840 -8685 {}
L 2 832.5 -8712.5 837.5 -8712.5 {}
L 2 835 -8715 835 -8710 {}
L 2 740 -8750 740 -8720 {}
L 2 740 -8840 740 -8810 {}
L 2 830 -8660 830 -8580 {}
L 2 740 -8690 740 -8580 {}
L 2 740 -8580 830 -8580 {}
L 2 1572.5 -8652.5 1577.5 -8652.5 {}
L 2 1575 -8655 1575 -8650 {}
L 2 1570 -8660 1570 -8600 {}
L 2 1570 -8600 1570 -8580 {}
L 2 1570 -8840 1570 -8660 {}
L 2 2255 -8720 2255 -8660 {}
L 2 2255 -8710 2270 -8710 {}
L 2 2270 -8720 2270 -8710 {}
L 2 2255 -8670 2270 -8670 {}
L 2 2270 -8670 2270 -8660 {}
L 2 2245 -8705 2245 -8675 {}
L 2 2245 -8690 2245 -8685 {}
L 2 2230 -8690 2237.5 -8690 {}
L 2 2230 -8690 2245 -8690 {}
L 2 2260 -8690 2270 -8690 {}
L 2 2255 -8695 2260 -8690 {}
L 2 2255 -8685 2260 -8690 {}
L 2 2270 -8760 2270 -8750 {}
L 2 2270 -8760 2277.5 -8762.5 {}
L 2 2262.5 -8767.5 2277.5 -8762.5 {}
L 2 2262.5 -8767.5 2277.5 -8772.5 {}
L 2 2262.5 -8777.5 2277.5 -8772.5 {}
L 2 2262.5 -8777.5 2277.5 -8782.5 {}
L 2 2262.5 -8787.5 2277.5 -8782.5 {}
L 2 2262.5 -8787.5 2277.5 -8792.5 {}
L 2 2262.5 -8797.5 2277.5 -8792.5 {}
L 2 2262.5 -8797.5 2270 -8800 {}
L 2 2270 -8810 2270 -8800 {}
L 2 2272.5 -8802.5 2277.5 -8802.5 {}
L 2 2275 -8805 2275 -8800 {}
L 2 2270 -8750 2270 -8720 {}
L 2 2270 -8840 2270 -8810 {}
L 2 2270 -8690 2270 -8580 {}
L 2 2270 -8580 2360 -8580 {}
L 2 2032.5 -8652.5 2037.5 -8652.5 {}
L 2 2035 -8655 2035 -8650 {}
L 2 2030 -8660 2030 -8600 {}
L 2 2030 -8600 2030 -8580 {}
L 2 2030 -8840 2030 -8660 {}
L 2 1300 -4840 1430 -4840 {}
L 2 1860 -4840 1990 -4840 {}
L 2 2430 -4870 2560 -4870 {}
L 2 520 -6700 760 -6700 {}
L 2 1060 -6700 1300 -6700 {}
L 2 2190 -6700 2500 -6770 {}
L 2 1300 -4030 1300 -4020 {}
L 2 1300 -4030 1307.5 -4032.5 {}
L 2 1292.5 -4037.5 1307.5 -4032.5 {}
L 2 1292.5 -4037.5 1307.5 -4042.5 {}
L 2 1292.5 -4047.5 1307.5 -4042.5 {}
L 2 1292.5 -4047.5 1307.5 -4052.5 {}
L 2 1292.5 -4057.5 1307.5 -4052.5 {}
L 2 1292.5 -4057.5 1307.5 -4062.5 {}
L 2 1292.5 -4067.5 1307.5 -4062.5 {}
L 2 1292.5 -4067.5 1300 -4070 {}
L 2 1300 -4080 1300 -4070 {}
L 2 1302.5 -4072.5 1307.5 -4072.5 {}
L 2 1305 -4075 1305 -4070 {}
L 2 1170 -4130 1170 -4110 {}
L 2 1160 -4130 1180 -4130 {}
L 2 1300 -4110 1300 -4080 {}
L 2 1060 -4110 1300 -4110 {}
L 2 1060 -4110 1060 -3930 {}
L 2 1300 -4020 1300 -3990 {}
L 2 2400 -4060 2400 -4050 {}
L 2 2400 -4060 2407.5 -4062.5 {}
L 2 2392.5 -4067.5 2407.5 -4062.5 {}
L 2 2392.5 -4067.5 2407.5 -4072.5 {}
L 2 2392.5 -4077.5 2407.5 -4072.5 {}
L 2 2392.5 -4077.5 2407.5 -4082.5 {}
L 2 2392.5 -4087.5 2407.5 -4082.5 {}
L 2 2392.5 -4087.5 2407.5 -4092.5 {}
L 2 2392.5 -4097.5 2407.5 -4092.5 {}
L 2 2392.5 -4097.5 2400 -4100 {}
L 2 2400 -4110 2400 -4100 {}
L 2 2402.5 -4102.5 2407.5 -4102.5 {}
L 2 2405 -4105 2405 -4100 {}
L 2 2270 -4160 2270 -4140 {}
L 2 2260 -4160 2280 -4160 {}
L 2 2400 -4140 2400 -4110 {}
L 2 2160 -4140 2400 -4140 {}
L 2 2160 -4140 2160 -3930 {}
L 2 2400 -4050 2400 -3990 {}
L 2 1840 -4030 1840 -4020 {}
L 2 1840 -4030 1847.5 -4032.5 {}
L 2 1832.5 -4037.5 1847.5 -4032.5 {}
L 2 1832.5 -4037.5 1847.5 -4042.5 {}
L 2 1832.5 -4047.5 1847.5 -4042.5 {}
L 2 1832.5 -4047.5 1847.5 -4052.5 {}
L 2 1832.5 -4057.5 1847.5 -4052.5 {}
L 2 1832.5 -4057.5 1847.5 -4062.5 {}
L 2 1832.5 -4067.5 1847.5 -4062.5 {}
L 2 1832.5 -4067.5 1840 -4070 {}
L 2 1840 -4080 1840 -4070 {}
L 2 1842.5 -4072.5 1847.5 -4072.5 {}
L 2 1845 -4075 1845 -4070 {}
L 2 1710 -4130 1710 -4110 {}
L 2 1700 -4130 1720 -4130 {}
L 2 1840 -4110 1840 -4080 {}
L 2 1600 -4110 1840 -4110 {}
L 2 1600 -4110 1600 -3930 {}
L 2 1840 -4020 1840 -3990 {}
L 2 1360 -3170 1360 -3160 {}
L 2 1360 -3170 1367.5 -3172.5 {}
L 2 1352.5 -3177.5 1367.5 -3172.5 {}
L 2 1352.5 -3177.5 1367.5 -3182.5 {}
L 2 1352.5 -3187.5 1367.5 -3182.5 {}
L 2 1352.5 -3187.5 1367.5 -3192.5 {}
L 2 1352.5 -3197.5 1367.5 -3192.5 {}
L 2 1352.5 -3197.5 1367.5 -3202.5 {}
L 2 1352.5 -3207.5 1367.5 -3202.5 {}
L 2 1352.5 -3207.5 1360 -3210 {}
L 2 1360 -3220 1360 -3210 {}
L 2 1362.5 -3212.5 1367.5 -3212.5 {}
L 2 1365 -3215 1365 -3210 {}
L 2 1900 -3200 1900 -3160 {}
L 2 1360 -3550 1360 -3540 {}
L 2 1360 -3550 1367.5 -3552.5 {}
L 2 1352.5 -3557.5 1367.5 -3552.5 {}
L 2 1352.5 -3557.5 1367.5 -3562.5 {}
L 2 1352.5 -3567.5 1367.5 -3562.5 {}
L 2 1352.5 -3567.5 1367.5 -3572.5 {}
L 2 1352.5 -3577.5 1367.5 -3572.5 {}
L 2 1352.5 -3577.5 1367.5 -3582.5 {}
L 2 1352.5 -3587.5 1367.5 -3582.5 {}
L 2 1352.5 -3587.5 1360 -3590 {}
L 2 1360 -3600 1360 -3590 {}
L 2 1362.5 -3592.5 1367.5 -3592.5 {}
L 2 1365 -3595 1365 -3590 {}
L 2 1360 -3610 1360 -3600 {}
L 2 1780 -3600 1900 -3600 {}
L 2 1780 -3540 1900 -3540 {}
L 2 1780 -3550 1780 -3540 {}
L 2 1780 -3550 1787.5 -3552.5 {}
L 2 1772.5 -3557.5 1787.5 -3552.5 {}
L 2 1772.5 -3557.5 1787.5 -3562.5 {}
L 2 1772.5 -3567.5 1787.5 -3562.5 {}
L 2 1772.5 -3567.5 1787.5 -3572.5 {}
L 2 1772.5 -3577.5 1787.5 -3572.5 {}
L 2 1772.5 -3577.5 1787.5 -3582.5 {}
L 2 1772.5 -3587.5 1787.5 -3582.5 {}
L 2 1772.5 -3587.5 1780 -3590 {}
L 2 1780 -3600 1780 -3590 {}
L 2 1782.5 -3592.5 1787.5 -3592.5 {}
L 2 1785 -3595 1785 -3590 {}
L 2 1360 -2490 1360 -2390 {}
L 2 1250 -2490 1250 -2390 {}
L 2 1470 -2490 1470 -2390 {}
L 2 1900 -2490 1900 -2390 {}
L 2 1790 -2490 1790 -2390 {}
L 2 2010 -2490 2010 -2390 {}
L 2 2430 -2590 2430 -2390 {}
L 2 2320 -2590 2320 -2390 {}
L 2 2540 -2590 2540 -2390 {}
L 2 1360 -560 1360 -460 {}
L 2 1250 -560 1250 -460 {}
L 2 1470 -560 1470 -460 {}
L 2 1250 -410 1250 -400 {}
L 2 1250 -410 1257.5 -412.5 {}
L 2 1242.5 -417.5 1257.5 -412.5 {}
L 2 1242.5 -417.5 1257.5 -422.5 {}
L 2 1242.5 -427.5 1257.5 -422.5 {}
L 2 1242.5 -427.5 1257.5 -432.5 {}
L 2 1242.5 -437.5 1257.5 -432.5 {}
L 2 1242.5 -437.5 1257.5 -442.5 {}
L 2 1242.5 -447.5 1257.5 -442.5 {}
L 2 1242.5 -447.5 1250 -450 {}
L 2 1250 -460 1250 -450 {}
L 2 1252.5 -452.5 1257.5 -452.5 {}
L 2 1255 -455 1255 -450 {}
L 2 1360 -410 1360 -400 {}
L 2 1360 -410 1367.5 -412.5 {}
L 2 1352.5 -417.5 1367.5 -412.5 {}
L 2 1352.5 -417.5 1367.5 -422.5 {}
L 2 1352.5 -427.5 1367.5 -422.5 {}
L 2 1352.5 -427.5 1367.5 -432.5 {}
L 2 1352.5 -437.5 1367.5 -432.5 {}
L 2 1352.5 -437.5 1367.5 -442.5 {}
L 2 1352.5 -447.5 1367.5 -442.5 {}
L 2 1352.5 -447.5 1360 -450 {}
L 2 1360 -460 1360 -450 {}
L 2 1362.5 -452.5 1367.5 -452.5 {}
L 2 1365 -455 1365 -450 {}
L 2 1470 -410 1470 -400 {}
L 2 1470 -410 1477.5 -412.5 {}
L 2 1462.5 -417.5 1477.5 -412.5 {}
L 2 1462.5 -417.5 1477.5 -422.5 {}
L 2 1462.5 -427.5 1477.5 -422.5 {}
L 2 1462.5 -427.5 1477.5 -432.5 {}
L 2 1462.5 -437.5 1477.5 -432.5 {}
L 2 1462.5 -437.5 1477.5 -442.5 {}
L 2 1462.5 -447.5 1477.5 -442.5 {}
L 2 1462.5 -447.5 1470 -450 {}
L 2 1470 -460 1470 -450 {}
L 2 1472.5 -452.5 1477.5 -452.5 {}
L 2 1475 -455 1475 -450 {}
L 2 1360 -400 1360 -370 {}
L 2 1250 -400 1250 -370 {}
L 2 1470 -400 1470 -370 {}
L 2 1900 -560 1900 -510 {}
L 2 1790 -560 1790 -510 {}
L 2 2010 -560 2010 -510 {}
L 2 1790 -460 1790 -450 {}
L 2 1790 -460 1797.5 -462.5 {}
L 2 1782.5 -467.5 1797.5 -462.5 {}
L 2 1782.5 -467.5 1797.5 -472.5 {}
L 2 1782.5 -477.5 1797.5 -472.5 {}
L 2 1782.5 -477.5 1797.5 -482.5 {}
L 2 1782.5 -487.5 1797.5 -482.5 {}
L 2 1782.5 -487.5 1797.5 -492.5 {}
L 2 1782.5 -497.5 1797.5 -492.5 {}
L 2 1782.5 -497.5 1790 -500 {}
L 2 1790 -510 1790 -500 {}
L 2 1792.5 -502.5 1797.5 -502.5 {}
L 2 1795 -505 1795 -500 {}
L 2 1900 -460 1900 -450 {}
L 2 1900 -460 1907.5 -462.5 {}
L 2 1892.5 -467.5 1907.5 -462.5 {}
L 2 1892.5 -467.5 1907.5 -472.5 {}
L 2 1892.5 -477.5 1907.5 -472.5 {}
L 2 1892.5 -477.5 1907.5 -482.5 {}
L 2 1892.5 -487.5 1907.5 -482.5 {}
L 2 1892.5 -487.5 1907.5 -492.5 {}
L 2 1892.5 -497.5 1907.5 -492.5 {}
L 2 1892.5 -497.5 1900 -500 {}
L 2 1900 -510 1900 -500 {}
L 2 1902.5 -502.5 1907.5 -502.5 {}
L 2 1905 -505 1905 -500 {}
L 2 2010 -460 2010 -450 {}
L 2 2010 -460 2017.5 -462.5 {}
L 2 2002.5 -467.5 2017.5 -462.5 {}
L 2 2002.5 -467.5 2017.5 -472.5 {}
L 2 2002.5 -477.5 2017.5 -472.5 {}
L 2 2002.5 -477.5 2017.5 -482.5 {}
L 2 2002.5 -487.5 2017.5 -482.5 {}
L 2 2002.5 -487.5 2017.5 -492.5 {}
L 2 2002.5 -497.5 2017.5 -492.5 {}
L 2 2002.5 -497.5 2010 -500 {}
L 2 2010 -510 2010 -500 {}
L 2 2012.5 -502.5 2017.5 -502.5 {}
L 2 2015 -505 2015 -500 {}
L 2 1900 -450 1900 -370 {}
L 2 1790 -450 1790 -370 {}
L 2 2010 -450 2010 -370 {}
L 2 635 -2130 635 -2070 {}
L 2 635 -2120 650 -2120 {}
L 2 650 -2130 650 -2120 {}
L 2 635 -2080 650 -2080 {}
L 2 650 -2080 650 -2070 {}
L 2 625 -2115 625 -2085 {}
L 2 625 -2100 625 -2095 {}
L 2 610 -2100 617.5 -2100 {}
L 2 610 -2100 625 -2100 {}
L 2 640 -2100 650 -2100 {}
L 2 635 -2105 640 -2100 {}
L 2 635 -2095 640 -2100 {}
L 2 1215 -2130 1215 -2070 {}
L 2 1215 -2120 1230 -2120 {}
L 2 1230 -2130 1230 -2120 {}
L 2 1215 -2080 1230 -2080 {}
L 2 1230 -2080 1230 -2070 {}
L 2 1205 -2115 1205 -2085 {}
L 2 1205 -2100 1205 -2095 {}
L 2 1190 -2100 1197.5 -2100 {}
L 2 1190 -2100 1205 -2100 {}
L 2 1220 -2100 1230 -2100 {}
L 2 1215 -2105 1220 -2100 {}
L 2 1215 -2095 1220 -2100 {}
L 2 1255 -8720 1255 -8660 {}
L 2 1255 -8710 1270 -8710 {}
L 2 1270 -8720 1270 -8710 {}
L 2 1255 -8670 1270 -8670 {}
L 2 1270 -8670 1270 -8660 {}
L 2 1245 -8705 1245 -8675 {}
L 2 1245 -8690 1245 -8685 {}
L 2 1230 -8690 1237.5 -8690 {}
L 2 1230 -8690 1245 -8690 {}
L 2 1260 -8690 1270 -8690 {}
L 2 1255 -8695 1260 -8690 {}
L 2 1255 -8685 1260 -8690 {}
L 2 1270 -8760 1270 -8750 {}
L 2 1270 -8760 1277.5 -8762.5 {}
L 2 1262.5 -8767.5 1277.5 -8762.5 {}
L 2 1262.5 -8767.5 1277.5 -8772.5 {}
L 2 1262.5 -8777.5 1277.5 -8772.5 {}
L 2 1262.5 -8777.5 1277.5 -8782.5 {}
L 2 1262.5 -8787.5 1277.5 -8782.5 {}
L 2 1262.5 -8787.5 1277.5 -8792.5 {}
L 2 1262.5 -8797.5 1277.5 -8792.5 {}
L 2 1262.5 -8797.5 1270 -8800 {}
L 2 1270 -8810 1270 -8800 {}
L 2 1272.5 -8802.5 1277.5 -8802.5 {}
L 2 1275 -8805 1275 -8800 {}
L 2 1360 -8685 1360 -8660 {}
L 2 1360 -8720 1360 -8695 {}
L 2 1350 -8695 1370 -8695 {}
L 2 1350 -8685 1370 -8685 {}
L 2 1362.5 -8712.5 1367.5 -8712.5 {}
L 2 1365 -8715 1365 -8710 {}
L 2 1270 -8750 1270 -8720 {}
L 2 1270 -8840 1270 -8810 {}
L 2 1360 -8660 1360 -8580 {}
L 2 1270 -8690 1270 -8580 {}
L 2 1270 -8580 1360 -8580 {}
L 2 1360 -180 1360 -80 {}
L 2 1250 -180 1250 -80 {}
L 2 1470 -180 1470 -80 {}
L 2 1250 -30 1250 -20 {}
L 2 1250 -30 1257.5 -32.5 {}
L 2 1242.5 -37.5 1257.5 -32.5 {}
L 2 1242.5 -37.5 1257.5 -42.5 {}
L 2 1242.5 -47.5 1257.5 -42.5 {}
L 2 1242.5 -47.5 1257.5 -52.5 {}
L 2 1242.5 -57.5 1257.5 -52.5 {}
L 2 1242.5 -57.5 1257.5 -62.5 {}
L 2 1242.5 -67.5 1257.5 -62.5 {}
L 2 1242.5 -67.5 1250 -70 {}
L 2 1250 -80 1250 -70 {}
L 2 1252.5 -72.5 1257.5 -72.5 {}
L 2 1255 -75 1255 -70 {}
L 2 1360 -30 1360 -20 {}
L 2 1360 -30 1367.5 -32.5 {}
L 2 1352.5 -37.5 1367.5 -32.5 {}
L 2 1352.5 -37.5 1367.5 -42.5 {}
L 2 1352.5 -47.5 1367.5 -42.5 {}
L 2 1352.5 -47.5 1367.5 -52.5 {}
L 2 1352.5 -57.5 1367.5 -52.5 {}
L 2 1352.5 -57.5 1367.5 -62.5 {}
L 2 1352.5 -67.5 1367.5 -62.5 {}
L 2 1352.5 -67.5 1360 -70 {}
L 2 1360 -80 1360 -70 {}
L 2 1362.5 -72.5 1367.5 -72.5 {}
L 2 1365 -75 1365 -70 {}
L 2 1470 -30 1470 -20 {}
L 2 1470 -30 1477.5 -32.5 {}
L 2 1462.5 -37.5 1477.5 -32.5 {}
L 2 1462.5 -37.5 1477.5 -42.5 {}
L 2 1462.5 -47.5 1477.5 -42.5 {}
L 2 1462.5 -47.5 1477.5 -52.5 {}
L 2 1462.5 -57.5 1477.5 -52.5 {}
L 2 1462.5 -57.5 1477.5 -62.5 {}
L 2 1462.5 -67.5 1477.5 -62.5 {}
L 2 1462.5 -67.5 1470 -70 {}
L 2 1470 -80 1470 -70 {}
L 2 1472.5 -72.5 1477.5 -72.5 {}
L 2 1475 -75 1475 -70 {}
L 2 1900 -180 1900 -130 {}
L 2 1790 -180 1790 -130 {}
L 2 2010 -180 2010 -130 {}
L 2 1790 -80 1790 -70 {}
L 2 1790 -80 1797.5 -82.5 {}
L 2 1782.5 -87.5 1797.5 -82.5 {}
L 2 1782.5 -87.5 1797.5 -92.5 {}
L 2 1782.5 -97.5 1797.5 -92.5 {}
L 2 1782.5 -97.5 1797.5 -102.5 {}
L 2 1782.5 -107.5 1797.5 -102.5 {}
L 2 1782.5 -107.5 1797.5 -112.5 {}
L 2 1782.5 -117.5 1797.5 -112.5 {}
L 2 1782.5 -117.5 1790 -120 {}
L 2 1790 -130 1790 -120 {}
L 2 1792.5 -122.5 1797.5 -122.5 {}
L 2 1795 -125 1795 -120 {}
L 2 1900 -80 1900 -70 {}
L 2 1900 -80 1907.5 -82.5 {}
L 2 1892.5 -87.5 1907.5 -82.5 {}
L 2 1892.5 -87.5 1907.5 -92.5 {}
L 2 1892.5 -97.5 1907.5 -92.5 {}
L 2 1892.5 -97.5 1907.5 -102.5 {}
L 2 1892.5 -107.5 1907.5 -102.5 {}
L 2 1892.5 -107.5 1907.5 -112.5 {}
L 2 1892.5 -117.5 1907.5 -112.5 {}
L 2 1892.5 -117.5 1900 -120 {}
L 2 1900 -130 1900 -120 {}
L 2 1902.5 -122.5 1907.5 -122.5 {}
L 2 1905 -125 1905 -120 {}
L 2 2010 -80 2010 -70 {}
L 2 2010 -80 2017.5 -82.5 {}
L 2 2002.5 -87.5 2017.5 -82.5 {}
L 2 2002.5 -87.5 2017.5 -92.5 {}
L 2 2002.5 -97.5 2017.5 -92.5 {}
L 2 2002.5 -97.5 2017.5 -102.5 {}
L 2 2002.5 -107.5 2017.5 -102.5 {}
L 2 2002.5 -107.5 2017.5 -112.5 {}
L 2 2002.5 -117.5 2017.5 -112.5 {}
L 2 2002.5 -117.5 2010 -120 {}
L 2 2010 -130 2010 -120 {}
L 2 2012.5 -122.5 2017.5 -122.5 {}
L 2 2015 -125 2015 -120 {}
L 2 1900 -70 1900 10 {}
L 2 1790 -70 1790 10 {}
L 2 2010 -70 2010 10 {}
L 2 600 -1850 720 -1850 {}
L 2 1220 -1760 1340 -1760 {}
L 2 740 -1630 740 -1510 {}
L 2 1280 -1600 1280 -1480 {}
L 2 2280 -1520 2410 -1520 {}
L 2 2360 -3010 2440 -2840 {}
L 2 1900 -3010 1900 -2840 {}
L 2 1760 -800 1880 -800 {}
L 2 680 -850 680 -840 {}
L 2 680 -850 687.5 -852.5 {}
L 2 672.5 -857.5 687.5 -852.5 {}
L 2 672.5 -857.5 687.5 -862.5 {}
L 2 672.5 -867.5 687.5 -862.5 {}
L 2 672.5 -867.5 687.5 -872.5 {}
L 2 672.5 -877.5 687.5 -872.5 {}
L 2 672.5 -877.5 687.5 -882.5 {}
L 2 672.5 -887.5 687.5 -882.5 {}
L 2 672.5 -887.5 680 -890 {}
L 2 680 -900 680 -890 {}
L 2 682.5 -892.5 687.5 -892.5 {}
L 2 685 -895 685 -890 {}
L 2 800 -850 800 -840 {}
L 2 800 -850 807.5 -852.5 {}
L 2 792.5 -857.5 807.5 -852.5 {}
L 2 792.5 -857.5 807.5 -862.5 {}
L 2 792.5 -867.5 807.5 -862.5 {}
L 2 792.5 -867.5 807.5 -872.5 {}
L 2 792.5 -877.5 807.5 -872.5 {}
L 2 792.5 -877.5 807.5 -882.5 {}
L 2 792.5 -887.5 807.5 -882.5 {}
L 2 792.5 -887.5 800 -890 {}
L 2 800 -900 800 -890 {}
L 2 802.5 -892.5 807.5 -892.5 {}
L 2 805 -895 805 -890 {}
L 2 1220 -850 1220 -840 {}
L 2 1220 -850 1227.5 -852.5 {}
L 2 1212.5 -857.5 1227.5 -852.5 {}
L 2 1212.5 -857.5 1227.5 -862.5 {}
L 2 1212.5 -867.5 1227.5 -862.5 {}
L 2 1212.5 -867.5 1227.5 -872.5 {}
L 2 1212.5 -877.5 1227.5 -872.5 {}
L 2 1212.5 -877.5 1227.5 -882.5 {}
L 2 1212.5 -887.5 1227.5 -882.5 {}
L 2 1212.5 -887.5 1220 -890 {}
L 2 1220 -900 1220 -890 {}
L 2 1222.5 -892.5 1227.5 -892.5 {}
L 2 1225 -895 1225 -890 {}
L 2 1340 -850 1340 -840 {}
L 2 1340 -850 1347.5 -852.5 {}
L 2 1332.5 -857.5 1347.5 -852.5 {}
L 2 1332.5 -857.5 1347.5 -862.5 {}
L 2 1332.5 -867.5 1347.5 -862.5 {}
L 2 1332.5 -867.5 1347.5 -872.5 {}
L 2 1332.5 -877.5 1347.5 -872.5 {}
L 2 1332.5 -877.5 1347.5 -882.5 {}
L 2 1332.5 -887.5 1347.5 -882.5 {}
L 2 1332.5 -887.5 1340 -890 {}
L 2 1340 -900 1340 -890 {}
L 2 1342.5 -892.5 1347.5 -892.5 {}
L 2 1345 -895 1345 -890 {}
L 2 1560 415 1560 440 {}
L 2 1560 380 1560 405 {}
L 2 1550 405 1570 405 {}
L 2 1550 415 1570 415 {}
L 2 1562.5 387.5 1567.5 387.5 {}
L 2 1565 385 1565 390 {}
L 2 1560 440 1560 520 {}
L 2 1230 500 1230 520 {}
L 2 1470 410 1470 520 {}
L 2 1470 520 1560 520 {}
L 2 1230 520 1470 520 {}
L 2 1470 380 1610 380 {}
L 2 740 -1200 740 -1080 {}
L 2 1200 -1250 1200 -1130 {}
L 2 1060 -4490 1060 -4310 {}
L 2 2520 -4280 2520 -4230 {}
L 2 2360 -1160 2610 -1160 {}
L 2 2430 235 2430 260 {}
L 2 2430 200 2430 225 {}
L 2 2420 225 2440 225 {}
L 2 2420 235 2440 235 {}
L 2 2432.5 207.5 2437.5 207.5 {}
L 2 2435 205 2435 210 {}
L 2 2430 260 2430 340 {}
L 2 2100 320 2100 340 {}
L 2 2340 230 2340 340 {}
L 2 2340 340 2430 340 {}
L 2 2100 340 2340 340 {}
L 2 2340 200 2480 200 {}
L 2 760 -4030 760 -4020 {}
L 2 760 -4030 767.5 -4032.5 {}
L 2 752.5 -4037.5 767.5 -4032.5 {}
L 2 752.5 -4037.5 767.5 -4042.5 {}
L 2 752.5 -4047.5 767.5 -4042.5 {}
L 2 752.5 -4047.5 767.5 -4052.5 {}
L 2 752.5 -4057.5 767.5 -4052.5 {}
L 2 752.5 -4057.5 767.5 -4062.5 {}
L 2 752.5 -4067.5 767.5 -4062.5 {}
L 2 752.5 -4067.5 760 -4070 {}
L 2 760 -4080 760 -4070 {}
L 2 762.5 -4072.5 767.5 -4072.5 {}
L 2 765 -4075 765 -4070 {}
L 2 630 -4130 630 -4110 {}
L 2 620 -4130 640 -4130 {}
L 2 760 -4110 760 -4080 {}
L 2 520 -4110 760 -4110 {}
L 2 520 -4110 520 -3930 {}
L 2 760 -4020 760 -3990 {}
L 2 610 -7100 610 -6990 {}
L 2 1240 -7100 1320 -7100 {}
L 2 1860 -7100 1940 -7100 {}
L 2 2400 -7100 2530 -7100 {}
L 2 2110 -7100 2190 -7100 {}
L 4 1032.5 -8182.5 1037.5 -8182.5 {}
L 4 1035 -8185 1035 -8180 {}
L 4 1030 -8190 1030 -8130 {}
L 4 1140 -8110 1140 -8097.5 {}
L 4 1135 -8097.5 1145 -8097.5 {}
L 4 1140 -8092.5 1145 -8097.5 {}
L 4 1135 -8097.5 1140 -8092.5 {}
L 4 1140 -8390 1140 -8370 {}
L 4 1130 -8390 1150 -8390 {}
L 4 1572.5 -8182.5 1577.5 -8182.5 {}
L 4 1575 -8185 1575 -8180 {}
L 4 1570 -8190 1570 -8130 {}
L 4 1680 -8110 1680 -8097.5 {}
L 4 1675 -8097.5 1685 -8097.5 {}
L 4 1680 -8092.5 1685 -8097.5 {}
L 4 1675 -8097.5 1680 -8092.5 {}
L 4 1680 -8390 1680 -8370 {}
L 4 1670 -8390 1690 -8390 {}
L 4 502.5 -8182.5 507.5 -8182.5 {}
L 4 505 -8185 505 -8180 {}
L 4 500 -8190 500 -8130 {}
L 4 610 -8110 610 -8097.5 {}
L 4 605 -8097.5 615 -8097.5 {}
L 4 610 -8092.5 615 -8097.5 {}
L 4 605 -8097.5 610 -8092.5 {}
L 4 610 -8390 610 -8370 {}
L 4 600 -8390 620 -8390 {}
L 4 725 -7790 725 -7730 {}
L 4 725 -7780 740 -7780 {}
L 4 740 -7790 740 -7780 {}
L 4 725 -7740 740 -7740 {}
L 4 740 -7740 740 -7730 {}
L 4 715 -7775 715 -7745 {}
L 4 715 -7760 715 -7755 {}
L 4 700 -7760 707.5 -7760 {}
L 4 700 -7760 715 -7760 {}
L 4 730 -7760 740 -7760 {}
L 4 725 -7765 730 -7760 {}
L 4 725 -7755 730 -7760 {}
L 4 740 -7830 740 -7820 {}
L 4 740 -7830 747.5 -7832.5 {}
L 4 732.5 -7837.5 747.5 -7832.5 {}
L 4 732.5 -7837.5 747.5 -7842.5 {}
L 4 732.5 -7847.5 747.5 -7842.5 {}
L 4 732.5 -7847.5 747.5 -7852.5 {}
L 4 732.5 -7857.5 747.5 -7852.5 {}
L 4 732.5 -7857.5 747.5 -7862.5 {}
L 4 732.5 -7867.5 747.5 -7862.5 {}
L 4 732.5 -7867.5 740 -7870 {}
L 4 740 -7880 740 -7870 {}
L 4 742.5 -7872.5 747.5 -7872.5 {}
L 4 745 -7875 745 -7870 {}
L 4 830 -7755 830 -7730 {}
L 4 830 -7790 830 -7765 {}
L 4 820 -7765 840 -7765 {}
L 4 820 -7755 840 -7755 {}
L 4 832.5 -7782.5 837.5 -7782.5 {}
L 4 835 -7785 835 -7780 {}
L 4 502.5 -7722.5 507.5 -7722.5 {}
L 4 505 -7725 505 -7720 {}
L 4 500 -7730 500 -7670 {}
L 4 610 -7650 610 -7637.5 {}
L 4 605 -7637.5 615 -7637.5 {}
L 4 610 -7632.5 615 -7637.5 {}
L 4 605 -7637.5 610 -7632.5 {}
L 4 610 -7930 610 -7910 {}
L 4 600 -7930 620 -7930 {}
L 4 1265 -7790 1265 -7730 {}
L 4 1265 -7780 1280 -7780 {}
L 4 1280 -7790 1280 -7780 {}
L 4 1265 -7740 1280 -7740 {}
L 4 1280 -7740 1280 -7730 {}
L 4 1255 -7775 1255 -7745 {}
L 4 1255 -7760 1255 -7755 {}
L 4 1240 -7760 1247.5 -7760 {}
L 4 1240 -7760 1255 -7760 {}
L 4 1270 -7760 1280 -7760 {}
L 4 1265 -7765 1270 -7760 {}
L 4 1265 -7755 1270 -7760 {}
L 4 1370 -7755 1370 -7730 {}
L 4 1370 -7790 1370 -7765 {}
L 4 1360 -7765 1380 -7765 {}
L 4 1360 -7755 1380 -7755 {}
L 4 1372.5 -7782.5 1377.5 -7782.5 {}
L 4 1375 -7785 1375 -7780 {}
L 4 1042.5 -7722.5 1047.5 -7722.5 {}
L 4 1045 -7725 1045 -7720 {}
L 4 1040 -7730 1040 -7670 {}
L 4 1150 -7650 1150 -7637.5 {}
L 4 1145 -7637.5 1155 -7637.5 {}
L 4 1150 -7632.5 1155 -7637.5 {}
L 4 1145 -7637.5 1150 -7632.5 {}
L 4 1150 -7930 1150 -7910 {}
L 4 1140 -7930 1160 -7930 {}
L 4 725 -6170 725 -6110 {}
L 4 725 -6160 740 -6160 {}
L 4 740 -6170 740 -6160 {}
L 4 725 -6120 740 -6120 {}
L 4 740 -6120 740 -6110 {}
L 4 715 -6155 715 -6125 {}
L 4 715 -6140 715 -6135 {}
L 4 700 -6140 707.5 -6140 {}
L 4 700 -6140 715 -6140 {}
L 4 730 -6140 740 -6140 {}
L 4 725 -6145 730 -6140 {}
L 4 725 -6135 730 -6140 {}
L 4 740 -6210 740 -6200 {}
L 4 740 -6210 747.5 -6212.5 {}
L 4 732.5 -6217.5 747.5 -6212.5 {}
L 4 732.5 -6217.5 747.5 -6222.5 {}
L 4 732.5 -6227.5 747.5 -6222.5 {}
L 4 732.5 -6227.5 747.5 -6232.5 {}
L 4 732.5 -6237.5 747.5 -6232.5 {}
L 4 732.5 -6237.5 747.5 -6242.5 {}
L 4 732.5 -6247.5 747.5 -6242.5 {}
L 4 732.5 -6247.5 740 -6250 {}
L 4 740 -6260 740 -6250 {}
L 4 742.5 -6252.5 747.5 -6252.5 {}
L 4 745 -6255 745 -6250 {}
L 4 830 -6135 830 -6110 {}
L 4 830 -6170 830 -6145 {}
L 4 820 -6145 840 -6145 {}
L 4 820 -6135 840 -6135 {}
L 4 832.5 -6162.5 837.5 -6162.5 {}
L 4 835 -6165 835 -6160 {}
L 4 502.5 -6102.5 507.5 -6102.5 {}
L 4 505 -6105 505 -6100 {}
L 4 500 -6110 500 -6050 {}
L 4 610 -6030 610 -6017.5 {}
L 4 605 -6017.5 615 -6017.5 {}
L 4 610 -6012.5 615 -6017.5 {}
L 4 605 -6017.5 610 -6012.5 {}
L 4 610 -6310 610 -6290 {}
L 4 600 -6310 620 -6310 {}
L 4 1265 -6170 1265 -6110 {}
L 4 1265 -6160 1280 -6160 {}
L 4 1280 -6170 1280 -6160 {}
L 4 1265 -6120 1280 -6120 {}
L 4 1280 -6120 1280 -6110 {}
L 4 1255 -6155 1255 -6125 {}
L 4 1255 -6140 1255 -6135 {}
L 4 1240 -6140 1247.5 -6140 {}
L 4 1240 -6140 1255 -6140 {}
L 4 1270 -6140 1280 -6140 {}
L 4 1265 -6145 1270 -6140 {}
L 4 1265 -6135 1270 -6140 {}
L 4 1370 -6135 1370 -6110 {}
L 4 1370 -6170 1370 -6145 {}
L 4 1360 -6145 1380 -6145 {}
L 4 1360 -6135 1380 -6135 {}
L 4 1372.5 -6162.5 1377.5 -6162.5 {}
L 4 1375 -6165 1375 -6160 {}
L 4 1042.5 -6102.5 1047.5 -6102.5 {}
L 4 1045 -6105 1045 -6100 {}
L 4 1040 -6110 1040 -6050 {}
L 4 1150 -6030 1150 -6017.5 {}
L 4 1145 -6017.5 1155 -6017.5 {}
L 4 1150 -6012.5 1155 -6017.5 {}
L 4 1145 -6017.5 1150 -6012.5 {}
L 4 1150 -6310 1150 -6290 {}
L 4 1140 -6310 1160 -6310 {}
L 4 725 -5680 725 -5620 {}
L 4 725 -5670 740 -5670 {}
L 4 740 -5680 740 -5670 {}
L 4 725 -5630 740 -5630 {}
L 4 740 -5630 740 -5620 {}
L 4 715 -5665 715 -5635 {}
L 4 715 -5650 715 -5645 {}
L 4 700 -5650 707.5 -5650 {}
L 4 700 -5650 715 -5650 {}
L 4 730 -5650 740 -5650 {}
L 4 725 -5655 730 -5650 {}
L 4 725 -5645 730 -5650 {}
L 4 740 -5720 740 -5710 {}
L 4 740 -5720 747.5 -5722.5 {}
L 4 732.5 -5727.5 747.5 -5722.5 {}
L 4 732.5 -5727.5 747.5 -5732.5 {}
L 4 732.5 -5737.5 747.5 -5732.5 {}
L 4 732.5 -5737.5 747.5 -5742.5 {}
L 4 732.5 -5747.5 747.5 -5742.5 {}
L 4 732.5 -5747.5 747.5 -5752.5 {}
L 4 732.5 -5757.5 747.5 -5752.5 {}
L 4 732.5 -5757.5 740 -5760 {}
L 4 740 -5770 740 -5760 {}
L 4 742.5 -5762.5 747.5 -5762.5 {}
L 4 745 -5765 745 -5760 {}
L 4 830 -5645 830 -5620 {}
L 4 830 -5680 830 -5655 {}
L 4 820 -5655 840 -5655 {}
L 4 820 -5645 840 -5645 {}
L 4 832.5 -5672.5 837.5 -5672.5 {}
L 4 835 -5675 835 -5670 {}
L 4 502.5 -5612.5 507.5 -5612.5 {}
L 4 505 -5615 505 -5610 {}
L 4 500 -5620 500 -5560 {}
L 4 610 -5540 610 -5527.5 {}
L 4 605 -5527.5 615 -5527.5 {}
L 4 610 -5522.5 615 -5527.5 {}
L 4 605 -5527.5 610 -5522.5 {}
L 4 610 -5820 610 -5800 {}
L 4 600 -5820 620 -5820 {}
L 4 1265 -5680 1265 -5620 {}
L 4 1265 -5670 1280 -5670 {}
L 4 1280 -5680 1280 -5670 {}
L 4 1265 -5630 1280 -5630 {}
L 4 1280 -5630 1280 -5620 {}
L 4 1255 -5665 1255 -5635 {}
L 4 1255 -5650 1255 -5645 {}
L 4 1240 -5650 1247.5 -5650 {}
L 4 1240 -5650 1255 -5650 {}
L 4 1270 -5650 1280 -5650 {}
L 4 1265 -5655 1270 -5650 {}
L 4 1265 -5645 1270 -5650 {}
L 4 1370 -5645 1370 -5620 {}
L 4 1370 -5680 1370 -5655 {}
L 4 1360 -5655 1380 -5655 {}
L 4 1360 -5645 1380 -5645 {}
L 4 1372.5 -5672.5 1377.5 -5672.5 {}
L 4 1375 -5675 1375 -5670 {}
L 4 1042.5 -5612.5 1047.5 -5612.5 {}
L 4 1045 -5615 1045 -5610 {}
L 4 1040 -5620 1040 -5560 {}
L 4 1150 -5540 1150 -5527.5 {}
L 4 1145 -5527.5 1155 -5527.5 {}
L 4 1150 -5522.5 1155 -5527.5 {}
L 4 1145 -5527.5 1150 -5522.5 {}
L 4 1150 -5820 1150 -5800 {}
L 4 1140 -5820 1160 -5820 {}
L 4 502.5 -5122.5 507.5 -5122.5 {}
L 4 505 -5125 505 -5120 {}
L 4 500 -5130 500 -5070 {}
L 4 610 -5050 610 -5037.5 {}
L 4 605 -5037.5 615 -5037.5 {}
L 4 610 -5032.5 615 -5037.5 {}
L 4 605 -5037.5 610 -5032.5 {}
L 4 610 -5330 610 -5310 {}
L 4 600 -5330 620 -5330 {}
L 4 1692.5 -5122.5 1697.5 -5122.5 {}
L 4 1695 -5125 1695 -5120 {}
L 4 1690 -5130 1690 -5070 {}
L 4 1800 -5050 1800 -5037.5 {}
L 4 1795 -5037.5 1805 -5037.5 {}
L 4 1800 -5032.5 1805 -5037.5 {}
L 4 1795 -5037.5 1800 -5032.5 {}
L 4 1800 -5330 1800 -5310 {}
L 4 1790 -5330 1810 -5330 {}
L 4 1042.5 -5122.5 1047.5 -5122.5 {}
L 4 1045 -5125 1045 -5120 {}
L 4 1040 -5130 1040 -5070 {}
L 4 1150 -5050 1150 -5037.5 {}
L 4 1145 -5037.5 1155 -5037.5 {}
L 4 1150 -5032.5 1155 -5037.5 {}
L 4 1145 -5037.5 1150 -5032.5 {}
L 4 1150 -5330 1150 -5310 {}
L 4 1140 -5330 1160 -5330 {}
L 4 1032.5 -7352.5 1037.5 -7352.5 {}
L 4 1035 -7355 1035 -7350 {}
L 4 1030 -7360 1030 -7300 {}
L 4 1140 -7280 1140 -7267.5 {}
L 4 1135 -7267.5 1145 -7267.5 {}
L 4 1140 -7262.5 1145 -7267.5 {}
L 4 1135 -7267.5 1140 -7262.5 {}
L 4 1140 -7560 1140 -7540 {}
L 4 1130 -7560 1150 -7560 {}
L 4 502.5 -7352.5 507.5 -7352.5 {}
L 4 505 -7355 505 -7350 {}
L 4 500 -7360 500 -7300 {}
L 4 610 -7280 610 -7267.5 {}
L 4 605 -7267.5 615 -7267.5 {}
L 4 610 -7262.5 615 -7267.5 {}
L 4 605 -7267.5 610 -7262.5 {}
L 4 610 -7560 610 -7540 {}
L 4 600 -7560 620 -7560 {}
L 4 1755 -7420 1755 -7360 {}
L 4 1755 -7410 1770 -7410 {}
L 4 1770 -7420 1770 -7410 {}
L 4 1755 -7370 1770 -7370 {}
L 4 1770 -7370 1770 -7360 {}
L 4 1745 -7405 1745 -7375 {}
L 4 1745 -7390 1745 -7385 {}
L 4 1730 -7390 1737.5 -7390 {}
L 4 1730 -7390 1745 -7390 {}
L 4 1760 -7390 1770 -7390 {}
L 4 1755 -7395 1760 -7390 {}
L 4 1755 -7385 1760 -7390 {}
L 4 1770 -7460 1770 -7450 {}
L 4 1770 -7460 1777.5 -7462.5 {}
L 4 1762.5 -7467.5 1777.5 -7462.5 {}
L 4 1762.5 -7467.5 1777.5 -7472.5 {}
L 4 1762.5 -7477.5 1777.5 -7472.5 {}
L 4 1762.5 -7477.5 1777.5 -7482.5 {}
L 4 1762.5 -7487.5 1777.5 -7482.5 {}
L 4 1762.5 -7487.5 1777.5 -7492.5 {}
L 4 1762.5 -7497.5 1777.5 -7492.5 {}
L 4 1762.5 -7497.5 1770 -7500 {}
L 4 1770 -7510 1770 -7500 {}
L 4 1772.5 -7502.5 1777.5 -7502.5 {}
L 4 1775 -7505 1775 -7500 {}
L 4 1860 -7385 1860 -7360 {}
L 4 1860 -7420 1860 -7395 {}
L 4 1850 -7395 1870 -7395 {}
L 4 1850 -7385 1870 -7385 {}
L 4 1862.5 -7412.5 1867.5 -7412.5 {}
L 4 1865 -7415 1865 -7410 {}
L 4 1532.5 -7352.5 1537.5 -7352.5 {}
L 4 1535 -7355 1535 -7350 {}
L 4 1530 -7360 1530 -7300 {}
L 4 1640 -7280 1640 -7267.5 {}
L 4 1635 -7267.5 1645 -7267.5 {}
L 4 1640 -7262.5 1645 -7267.5 {}
L 4 1635 -7267.5 1640 -7262.5 {}
L 4 1640 -7560 1640 -7540 {}
L 4 1630 -7560 1650 -7560 {}
L 4 1680 -8580 1680 -8567.5 {}
L 4 1675 -8567.5 1685 -8567.5 {}
L 4 1680 -8562.5 1685 -8567.5 {}
L 4 1675 -8567.5 1680 -8562.5 {}
L 4 1680 -8860 1680 -8840 {}
L 4 1670 -8860 1690 -8860 {}
L 4 502.5 -8652.5 507.5 -8652.5 {}
L 4 505 -8655 505 -8650 {}
L 4 500 -8660 500 -8600 {}
L 4 610 -8580 610 -8567.5 {}
L 4 605 -8567.5 615 -8567.5 {}
L 4 610 -8562.5 615 -8567.5 {}
L 4 605 -8567.5 610 -8562.5 {}
L 4 610 -8860 610 -8840 {}
L 4 600 -8860 620 -8860 {}
L 4 2140 -8580 2140 -8567.5 {}
L 4 2135 -8567.5 2145 -8567.5 {}
L 4 2140 -8562.5 2145 -8567.5 {}
L 4 2135 -8567.5 2140 -8562.5 {}
L 4 2140 -8860 2140 -8840 {}
L 4 2130 -8860 2150 -8860 {}
L 4 2360 -8685 2360 -8660 {}
L 4 2360 -8720 2360 -8695 {}
L 4 2350 -8695 2370 -8695 {}
L 4 2350 -8685 2370 -8685 {}
L 4 2362.5 -8712.5 2367.5 -8712.5 {}
L 4 2365 -8715 2365 -8710 {}
L 4 745 -4750 745 -4690 {}
L 4 745 -4740 760 -4740 {}
L 4 760 -4750 760 -4740 {}
L 4 745 -4700 760 -4700 {}
L 4 760 -4700 760 -4690 {}
L 4 735 -4735 735 -4705 {}
L 4 735 -4720 735 -4715 {}
L 4 720 -4720 727.5 -4720 {}
L 4 720 -4720 735 -4720 {}
L 4 750 -4720 760 -4720 {}
L 4 745 -4725 750 -4720 {}
L 4 745 -4715 750 -4720 {}
L 4 760 -4790 760 -4780 {}
L 4 760 -4790 767.5 -4792.5 {}
L 4 752.5 -4797.5 767.5 -4792.5 {}
L 4 752.5 -4797.5 767.5 -4802.5 {}
L 4 752.5 -4807.5 767.5 -4802.5 {}
L 4 752.5 -4807.5 767.5 -4812.5 {}
L 4 752.5 -4817.5 767.5 -4812.5 {}
L 4 752.5 -4817.5 767.5 -4822.5 {}
L 4 752.5 -4827.5 767.5 -4822.5 {}
L 4 752.5 -4827.5 760 -4830 {}
L 4 760 -4840 760 -4830 {}
L 4 762.5 -4832.5 767.5 -4832.5 {}
L 4 765 -4835 765 -4830 {}
L 4 850 -4715 850 -4690 {}
L 4 850 -4750 850 -4725 {}
L 4 840 -4725 860 -4725 {}
L 4 840 -4715 860 -4715 {}
L 4 852.5 -4742.5 857.5 -4742.5 {}
L 4 855 -4745 855 -4740 {}
L 4 522.5 -4682.5 527.5 -4682.5 {}
L 4 525 -4685 525 -4680 {}
L 4 520 -4690 520 -4630 {}
L 4 630 -4610 630 -4597.5 {}
L 4 625 -4597.5 635 -4597.5 {}
L 4 630 -4592.5 635 -4597.5 {}
L 4 625 -4597.5 630 -4592.5 {}
L 4 630 -4890 630 -4870 {}
L 4 620 -4890 640 -4890 {}
L 4 1285 -4750 1285 -4690 {}
L 4 1285 -4740 1300 -4740 {}
L 4 1300 -4750 1300 -4740 {}
L 4 1285 -4700 1300 -4700 {}
L 4 1300 -4700 1300 -4690 {}
L 4 1275 -4735 1275 -4705 {}
L 4 1275 -4720 1275 -4715 {}
L 4 1260 -4720 1267.5 -4720 {}
L 4 1260 -4720 1275 -4720 {}
L 4 1290 -4720 1300 -4720 {}
L 4 1285 -4725 1290 -4720 {}
L 4 1285 -4715 1290 -4720 {}
L 4 1300 -4790 1300 -4780 {}
L 4 1300 -4790 1307.5 -4792.5 {}
L 4 1292.5 -4797.5 1307.5 -4792.5 {}
L 4 1292.5 -4797.5 1307.5 -4802.5 {}
L 4 1292.5 -4807.5 1307.5 -4802.5 {}
L 4 1292.5 -4807.5 1307.5 -4812.5 {}
L 4 1292.5 -4817.5 1307.5 -4812.5 {}
L 4 1292.5 -4817.5 1307.5 -4822.5 {}
L 4 1292.5 -4827.5 1307.5 -4822.5 {}
L 4 1292.5 -4827.5 1300 -4830 {}
L 4 1300 -4840 1300 -4830 {}
L 4 1302.5 -4832.5 1307.5 -4832.5 {}
L 4 1305 -4835 1305 -4830 {}
L 4 1390 -4715 1390 -4690 {}
L 4 1390 -4750 1390 -4725 {}
L 4 1380 -4725 1400 -4725 {}
L 4 1380 -4715 1400 -4715 {}
L 4 1392.5 -4742.5 1397.5 -4742.5 {}
L 4 1395 -4745 1395 -4740 {}
L 4 1062.5 -4682.5 1067.5 -4682.5 {}
L 4 1065 -4685 1065 -4680 {}
L 4 1060 -4690 1060 -4630 {}
L 4 1170 -4610 1170 -4597.5 {}
L 4 1165 -4597.5 1175 -4597.5 {}
L 4 1170 -4592.5 1175 -4597.5 {}
L 4 1165 -4597.5 1170 -4592.5 {}
L 4 1170 -4890 1170 -4870 {}
L 4 1160 -4890 1180 -4890 {}
L 4 1845 -4750 1845 -4690 {}
L 4 1845 -4740 1860 -4740 {}
L 4 1860 -4750 1860 -4740 {}
L 4 1845 -4700 1860 -4700 {}
L 4 1860 -4700 1860 -4690 {}
L 4 1835 -4735 1835 -4705 {}
L 4 1835 -4720 1835 -4715 {}
L 4 1820 -4720 1827.5 -4720 {}
L 4 1820 -4720 1835 -4720 {}
L 4 1850 -4720 1860 -4720 {}
L 4 1845 -4725 1850 -4720 {}
L 4 1845 -4715 1850 -4720 {}
L 4 1860 -4790 1860 -4780 {}
L 4 1860 -4790 1867.5 -4792.5 {}
L 4 1852.5 -4797.5 1867.5 -4792.5 {}
L 4 1852.5 -4797.5 1867.5 -4802.5 {}
L 4 1852.5 -4807.5 1867.5 -4802.5 {}
L 4 1852.5 -4807.5 1867.5 -4812.5 {}
L 4 1852.5 -4817.5 1867.5 -4812.5 {}
L 4 1852.5 -4817.5 1867.5 -4822.5 {}
L 4 1852.5 -4827.5 1867.5 -4822.5 {}
L 4 1852.5 -4827.5 1860 -4830 {}
L 4 1860 -4840 1860 -4830 {}
L 4 1862.5 -4832.5 1867.5 -4832.5 {}
L 4 1865 -4835 1865 -4830 {}
L 4 1950 -4715 1950 -4690 {}
L 4 1950 -4750 1950 -4725 {}
L 4 1940 -4725 1960 -4725 {}
L 4 1940 -4715 1960 -4715 {}
L 4 1952.5 -4742.5 1957.5 -4742.5 {}
L 4 1955 -4745 1955 -4740 {}
L 4 1622.5 -4682.5 1627.5 -4682.5 {}
L 4 1625 -4685 1625 -4680 {}
L 4 1620 -4690 1620 -4630 {}
L 4 1730 -4610 1730 -4597.5 {}
L 4 1725 -4597.5 1735 -4597.5 {}
L 4 1730 -4592.5 1735 -4597.5 {}
L 4 1725 -4597.5 1730 -4592.5 {}
L 4 1730 -4890 1730 -4870 {}
L 4 1720 -4890 1740 -4890 {}
L 4 2415 -4750 2415 -4690 {}
L 4 2415 -4740 2430 -4740 {}
L 4 2430 -4750 2430 -4740 {}
L 4 2415 -4700 2430 -4700 {}
L 4 2430 -4700 2430 -4690 {}
L 4 2405 -4735 2405 -4705 {}
L 4 2405 -4720 2405 -4715 {}
L 4 2390 -4720 2397.5 -4720 {}
L 4 2390 -4720 2405 -4720 {}
L 4 2420 -4720 2430 -4720 {}
L 4 2415 -4725 2420 -4720 {}
L 4 2415 -4715 2420 -4720 {}
L 4 2430 -4790 2430 -4780 {}
L 4 2430 -4790 2437.5 -4792.5 {}
L 4 2422.5 -4797.5 2437.5 -4792.5 {}
L 4 2422.5 -4797.5 2437.5 -4802.5 {}
L 4 2422.5 -4807.5 2437.5 -4802.5 {}
L 4 2422.5 -4807.5 2437.5 -4812.5 {}
L 4 2422.5 -4817.5 2437.5 -4812.5 {}
L 4 2422.5 -4817.5 2437.5 -4822.5 {}
L 4 2422.5 -4827.5 2437.5 -4822.5 {}
L 4 2422.5 -4827.5 2430 -4830 {}
L 4 2430 -4840 2430 -4830 {}
L 4 2432.5 -4832.5 2437.5 -4832.5 {}
L 4 2435 -4835 2435 -4830 {}
L 4 2520 -4715 2520 -4690 {}
L 4 2520 -4750 2520 -4725 {}
L 4 2510 -4725 2530 -4725 {}
L 4 2510 -4715 2530 -4715 {}
L 4 2522.5 -4742.5 2527.5 -4742.5 {}
L 4 2525 -4745 2525 -4740 {}
L 4 2192.5 -4682.5 2197.5 -4682.5 {}
L 4 2195 -4685 2195 -4680 {}
L 4 2190 -4690 2190 -4630 {}
L 4 2300 -4610 2300 -4597.5 {}
L 4 2295 -4597.5 2305 -4597.5 {}
L 4 2300 -4592.5 2305 -4597.5 {}
L 4 2295 -4597.5 2300 -4592.5 {}
L 4 2300 -4890 2300 -4870 {}
L 4 2290 -4890 2310 -4890 {}
L 4 745 -6580 745 -6520 {}
L 4 745 -6570 760 -6570 {}
L 4 760 -6580 760 -6570 {}
L 4 745 -6530 760 -6530 {}
L 4 760 -6530 760 -6520 {}
L 4 735 -6565 735 -6535 {}
L 4 735 -6550 735 -6545 {}
L 4 720 -6550 727.5 -6550 {}
L 4 720 -6550 735 -6550 {}
L 4 750 -6550 760 -6550 {}
L 4 745 -6555 750 -6550 {}
L 4 745 -6545 750 -6550 {}
L 4 760 -6620 760 -6610 {}
L 4 760 -6620 767.5 -6622.5 {}
L 4 752.5 -6627.5 767.5 -6622.5 {}
L 4 752.5 -6627.5 767.5 -6632.5 {}
L 4 752.5 -6637.5 767.5 -6632.5 {}
L 4 752.5 -6637.5 767.5 -6642.5 {}
L 4 752.5 -6647.5 767.5 -6642.5 {}
L 4 752.5 -6647.5 767.5 -6652.5 {}
L 4 752.5 -6657.5 767.5 -6652.5 {}
L 4 752.5 -6657.5 760 -6660 {}
L 4 760 -6670 760 -6660 {}
L 4 762.5 -6662.5 767.5 -6662.5 {}
L 4 765 -6665 765 -6660 {}
L 4 850 -6545 850 -6520 {}
L 4 850 -6580 850 -6555 {}
L 4 840 -6555 860 -6555 {}
L 4 840 -6545 860 -6545 {}
L 4 852.5 -6572.5 857.5 -6572.5 {}
L 4 855 -6575 855 -6570 {}
L 4 522.5 -6512.5 527.5 -6512.5 {}
L 4 525 -6515 525 -6510 {}
L 4 520 -6520 520 -6460 {}
L 4 630 -6440 630 -6427.5 {}
L 4 625 -6427.5 635 -6427.5 {}
L 4 630 -6422.5 635 -6427.5 {}
L 4 625 -6427.5 630 -6422.5 {}
L 4 630 -6720 630 -6700 {}
L 4 620 -6720 640 -6720 {}
L 4 1285 -6580 1285 -6520 {}
L 4 1285 -6570 1300 -6570 {}
L 4 1300 -6580 1300 -6570 {}
L 4 1285 -6530 1300 -6530 {}
L 4 1300 -6530 1300 -6520 {}
L 4 1275 -6565 1275 -6535 {}
L 4 1275 -6550 1275 -6545 {}
L 4 1260 -6550 1267.5 -6550 {}
L 4 1260 -6550 1275 -6550 {}
L 4 1290 -6550 1300 -6550 {}
L 4 1285 -6555 1290 -6550 {}
L 4 1285 -6545 1290 -6550 {}
L 4 1300 -6620 1300 -6610 {}
L 4 1300 -6620 1307.5 -6622.5 {}
L 4 1292.5 -6627.5 1307.5 -6622.5 {}
L 4 1292.5 -6627.5 1307.5 -6632.5 {}
L 4 1292.5 -6637.5 1307.5 -6632.5 {}
L 4 1292.5 -6637.5 1307.5 -6642.5 {}
L 4 1292.5 -6647.5 1307.5 -6642.5 {}
L 4 1292.5 -6647.5 1307.5 -6652.5 {}
L 4 1292.5 -6657.5 1307.5 -6652.5 {}
L 4 1292.5 -6657.5 1300 -6660 {}
L 4 1300 -6670 1300 -6660 {}
L 4 1302.5 -6662.5 1307.5 -6662.5 {}
L 4 1305 -6665 1305 -6660 {}
L 4 1390 -6545 1390 -6520 {}
L 4 1390 -6580 1390 -6555 {}
L 4 1380 -6555 1400 -6555 {}
L 4 1380 -6545 1400 -6545 {}
L 4 1392.5 -6572.5 1397.5 -6572.5 {}
L 4 1395 -6575 1395 -6570 {}
L 4 1062.5 -6512.5 1067.5 -6512.5 {}
L 4 1065 -6515 1065 -6510 {}
L 4 1060 -6520 1060 -6460 {}
L 4 1170 -6440 1170 -6427.5 {}
L 4 1165 -6427.5 1175 -6427.5 {}
L 4 1170 -6422.5 1175 -6427.5 {}
L 4 1165 -6427.5 1170 -6422.5 {}
L 4 1170 -6720 1170 -6700 {}
L 4 1160 -6720 1180 -6720 {}
L 4 2415 -6580 2415 -6520 {}
L 4 2415 -6570 2430 -6570 {}
L 4 2430 -6580 2430 -6570 {}
L 4 2415 -6530 2430 -6530 {}
L 4 2430 -6530 2430 -6520 {}
L 4 2405 -6565 2405 -6535 {}
L 4 2405 -6550 2405 -6545 {}
L 4 2390 -6550 2397.5 -6550 {}
L 4 2390 -6550 2405 -6550 {}
L 4 2420 -6550 2430 -6550 {}
L 4 2415 -6555 2420 -6550 {}
L 4 2415 -6545 2420 -6550 {}
L 4 2430 -6620 2430 -6610 {}
L 4 2430 -6620 2437.5 -6622.5 {}
L 4 2422.5 -6627.5 2437.5 -6622.5 {}
L 4 2422.5 -6627.5 2437.5 -6632.5 {}
L 4 2422.5 -6637.5 2437.5 -6632.5 {}
L 4 2422.5 -6637.5 2437.5 -6642.5 {}
L 4 2422.5 -6647.5 2437.5 -6642.5 {}
L 4 2422.5 -6647.5 2437.5 -6652.5 {}
L 4 2422.5 -6657.5 2437.5 -6652.5 {}
L 4 2422.5 -6657.5 2430 -6660 {}
L 4 2430 -6670 2430 -6660 {}
L 4 2432.5 -6662.5 2437.5 -6662.5 {}
L 4 2435 -6665 2435 -6660 {}
L 4 2520 -6545 2520 -6520 {}
L 4 2520 -6580 2520 -6555 {}
L 4 2510 -6555 2530 -6555 {}
L 4 2510 -6545 2530 -6545 {}
L 4 2522.5 -6572.5 2527.5 -6572.5 {}
L 4 2525 -6575 2525 -6570 {}
L 4 2192.5 -6512.5 2197.5 -6512.5 {}
L 4 2195 -6515 2195 -6510 {}
L 4 2190 -6520 2190 -6460 {}
L 4 2300 -6440 2300 -6427.5 {}
L 4 2295 -6427.5 2305 -6427.5 {}
L 4 2300 -6422.5 2305 -6427.5 {}
L 4 2295 -6427.5 2300 -6422.5 {}
L 4 2300 -6720 2300 -6700 {}
L 4 2290 -6720 2310 -6720 {}
L 4 745 -4370 745 -4310 {}
L 4 745 -4360 760 -4360 {}
L 4 760 -4370 760 -4360 {}
L 4 745 -4320 760 -4320 {}
L 4 760 -4320 760 -4310 {}
L 4 735 -4355 735 -4325 {}
L 4 735 -4340 735 -4335 {}
L 4 720 -4340 727.5 -4340 {}
L 4 720 -4340 735 -4340 {}
L 4 750 -4340 760 -4340 {}
L 4 745 -4345 750 -4340 {}
L 4 745 -4335 750 -4340 {}
L 4 760 -4410 760 -4400 {}
L 4 760 -4410 767.5 -4412.5 {}
L 4 752.5 -4417.5 767.5 -4412.5 {}
L 4 752.5 -4417.5 767.5 -4422.5 {}
L 4 752.5 -4427.5 767.5 -4422.5 {}
L 4 752.5 -4427.5 767.5 -4432.5 {}
L 4 752.5 -4437.5 767.5 -4432.5 {}
L 4 752.5 -4437.5 767.5 -4442.5 {}
L 4 752.5 -4447.5 767.5 -4442.5 {}
L 4 752.5 -4447.5 760 -4450 {}
L 4 760 -4460 760 -4450 {}
L 4 762.5 -4452.5 767.5 -4452.5 {}
L 4 765 -4455 765 -4450 {}
L 4 850 -4335 850 -4310 {}
L 4 850 -4370 850 -4345 {}
L 4 840 -4345 860 -4345 {}
L 4 840 -4335 860 -4335 {}
L 4 852.5 -4362.5 857.5 -4362.5 {}
L 4 855 -4365 855 -4360 {}
L 4 522.5 -4302.5 527.5 -4302.5 {}
L 4 525 -4305 525 -4300 {}
L 4 520 -4310 520 -4250 {}
L 4 630 -4230 630 -4217.5 {}
L 4 625 -4217.5 635 -4217.5 {}
L 4 630 -4212.5 635 -4217.5 {}
L 4 625 -4217.5 630 -4212.5 {}
L 4 630 -4510 630 -4490 {}
L 4 620 -4510 640 -4510 {}
L 4 1285 -3990 1285 -3930 {}
L 4 1285 -3980 1300 -3980 {}
L 4 1300 -3990 1300 -3980 {}
L 4 1285 -3940 1300 -3940 {}
L 4 1300 -3940 1300 -3930 {}
L 4 1275 -3975 1275 -3945 {}
L 4 1275 -3960 1275 -3955 {}
L 4 1260 -3960 1267.5 -3960 {}
L 4 1260 -3960 1275 -3960 {}
L 4 1290 -3960 1300 -3960 {}
L 4 1285 -3965 1290 -3960 {}
L 4 1285 -3955 1290 -3960 {}
L 4 1390 -3955 1390 -3930 {}
L 4 1390 -3990 1390 -3965 {}
L 4 1380 -3965 1400 -3965 {}
L 4 1380 -3955 1400 -3955 {}
L 4 1392.5 -3982.5 1397.5 -3982.5 {}
L 4 1395 -3985 1395 -3980 {}
L 4 1062.5 -3922.5 1067.5 -3922.5 {}
L 4 1065 -3925 1065 -3920 {}
L 4 1060 -3930 1060 -3870 {}
L 4 1170 -3850 1170 -3837.5 {}
L 4 1165 -3837.5 1175 -3837.5 {}
L 4 1170 -3832.5 1175 -3837.5 {}
L 4 1165 -3837.5 1170 -3832.5 {}
L 4 2385 -3990 2385 -3930 {}
L 4 2385 -3980 2400 -3980 {}
L 4 2400 -3990 2400 -3980 {}
L 4 2385 -3940 2400 -3940 {}
L 4 2400 -3940 2400 -3930 {}
L 4 2375 -3975 2375 -3945 {}
L 4 2375 -3960 2375 -3955 {}
L 4 2360 -3960 2367.5 -3960 {}
L 4 2360 -3960 2375 -3960 {}
L 4 2390 -3960 2400 -3960 {}
L 4 2385 -3965 2390 -3960 {}
L 4 2385 -3955 2390 -3960 {}
L 4 2490 -3955 2490 -3930 {}
L 4 2490 -3990 2490 -3965 {}
L 4 2480 -3965 2500 -3965 {}
L 4 2480 -3955 2500 -3955 {}
L 4 2492.5 -3982.5 2497.5 -3982.5 {}
L 4 2495 -3985 2495 -3980 {}
L 4 2162.5 -3922.5 2167.5 -3922.5 {}
L 4 2165 -3925 2165 -3920 {}
L 4 2160 -3930 2160 -3870 {}
L 4 2270 -3850 2270 -3837.5 {}
L 4 2265 -3837.5 2275 -3837.5 {}
L 4 2270 -3832.5 2275 -3837.5 {}
L 4 2265 -3837.5 2270 -3832.5 {}
L 4 1825 -3990 1825 -3930 {}
L 4 1825 -3980 1840 -3980 {}
L 4 1840 -3990 1840 -3980 {}
L 4 1825 -3940 1840 -3940 {}
L 4 1840 -3940 1840 -3930 {}
L 4 1815 -3975 1815 -3945 {}
L 4 1815 -3960 1815 -3955 {}
L 4 1800 -3960 1807.5 -3960 {}
L 4 1800 -3960 1815 -3960 {}
L 4 1830 -3960 1840 -3960 {}
L 4 1825 -3965 1830 -3960 {}
L 4 1825 -3955 1830 -3960 {}
L 4 1930 -3955 1930 -3930 {}
L 4 1930 -3990 1930 -3965 {}
L 4 1920 -3965 1940 -3965 {}
L 4 1920 -3955 1940 -3955 {}
L 4 1932.5 -3982.5 1937.5 -3982.5 {}
L 4 1935 -3985 1935 -3980 {}
L 4 1602.5 -3922.5 1607.5 -3922.5 {}
L 4 1605 -3925 1605 -3920 {}
L 4 1600 -3930 1600 -3870 {}
L 4 1710 -3850 1710 -3837.5 {}
L 4 1705 -3837.5 1715 -3837.5 {}
L 4 1710 -3832.5 1715 -3837.5 {}
L 4 1705 -3837.5 1710 -3832.5 {}
L 4 820 -3170 820 -3160 {}
L 4 820 -3170 827.5 -3172.5 {}
L 4 812.5 -3177.5 827.5 -3172.5 {}
L 4 812.5 -3177.5 827.5 -3182.5 {}
L 4 812.5 -3187.5 827.5 -3182.5 {}
L 4 812.5 -3187.5 827.5 -3192.5 {}
L 4 812.5 -3197.5 827.5 -3192.5 {}
L 4 812.5 -3197.5 827.5 -3202.5 {}
L 4 812.5 -3207.5 827.5 -3202.5 {}
L 4 812.5 -3207.5 820 -3210 {}
L 4 820 -3220 820 -3210 {}
L 4 822.5 -3212.5 827.5 -3212.5 {}
L 4 825 -3215 825 -3210 {}
L 4 820 -3110 820 -3100 {}
L 4 820 -3110 827.5 -3112.5 {}
L 4 812.5 -3117.5 827.5 -3112.5 {}
L 4 812.5 -3117.5 827.5 -3122.5 {}
L 4 812.5 -3127.5 827.5 -3122.5 {}
L 4 812.5 -3127.5 827.5 -3132.5 {}
L 4 812.5 -3137.5 827.5 -3132.5 {}
L 4 812.5 -3137.5 827.5 -3142.5 {}
L 4 812.5 -3147.5 827.5 -3142.5 {}
L 4 812.5 -3147.5 820 -3150 {}
L 4 820 -3160 820 -3150 {}
L 4 822.5 -3152.5 827.5 -3152.5 {}
L 4 825 -3155 825 -3150 {}
L 4 1360 -3110 1360 -3100 {}
L 4 1360 -3110 1367.5 -3112.5 {}
L 4 1352.5 -3117.5 1367.5 -3112.5 {}
L 4 1352.5 -3117.5 1367.5 -3122.5 {}
L 4 1352.5 -3127.5 1367.5 -3122.5 {}
L 4 1352.5 -3127.5 1367.5 -3132.5 {}
L 4 1352.5 -3137.5 1367.5 -3132.5 {}
L 4 1352.5 -3137.5 1367.5 -3142.5 {}
L 4 1352.5 -3147.5 1367.5 -3142.5 {}
L 4 1352.5 -3147.5 1360 -3150 {}
L 4 1360 -3160 1360 -3150 {}
L 4 1362.5 -3152.5 1367.5 -3152.5 {}
L 4 1365 -3155 1365 -3150 {}
L 4 1900 -3210 1900 -3200 {}
L 4 1900 -3210 1907.5 -3212.5 {}
L 4 1892.5 -3217.5 1907.5 -3212.5 {}
L 4 1892.5 -3217.5 1907.5 -3222.5 {}
L 4 1892.5 -3227.5 1907.5 -3222.5 {}
L 4 1892.5 -3227.5 1907.5 -3232.5 {}
L 4 1892.5 -3237.5 1907.5 -3232.5 {}
L 4 1892.5 -3237.5 1907.5 -3242.5 {}
L 4 1892.5 -3247.5 1907.5 -3242.5 {}
L 4 1892.5 -3247.5 1900 -3250 {}
L 4 1900 -3260 1900 -3250 {}
L 4 1902.5 -3252.5 1907.5 -3252.5 {}
L 4 1905 -3255 1905 -3250 {}
L 4 1900 -3110 1900 -3100 {}
L 4 1900 -3110 1907.5 -3112.5 {}
L 4 1892.5 -3117.5 1907.5 -3112.5 {}
L 4 1892.5 -3117.5 1907.5 -3122.5 {}
L 4 1892.5 -3127.5 1907.5 -3122.5 {}
L 4 1892.5 -3127.5 1907.5 -3132.5 {}
L 4 1892.5 -3137.5 1907.5 -3132.5 {}
L 4 1892.5 -3137.5 1907.5 -3142.5 {}
L 4 1892.5 -3147.5 1907.5 -3142.5 {}
L 4 1892.5 -3147.5 1900 -3150 {}
L 4 1900 -3160 1900 -3150 {}
L 4 1902.5 -3152.5 1907.5 -3152.5 {}
L 4 1905 -3155 1905 -3150 {}
L 4 820 -3490 820 -3480 {}
L 4 820 -3490 827.5 -3492.5 {}
L 4 812.5 -3497.5 827.5 -3492.5 {}
L 4 812.5 -3497.5 827.5 -3502.5 {}
L 4 812.5 -3507.5 827.5 -3502.5 {}
L 4 812.5 -3507.5 827.5 -3512.5 {}
L 4 812.5 -3517.5 827.5 -3512.5 {}
L 4 812.5 -3517.5 827.5 -3522.5 {}
L 4 812.5 -3527.5 827.5 -3522.5 {}
L 4 812.5 -3527.5 820 -3530 {}
L 4 820 -3540 820 -3530 {}
L 4 822.5 -3532.5 827.5 -3532.5 {}
L 4 825 -3535 825 -3530 {}
L 4 820 -3550 820 -3540 {}
L 4 820 -3550 827.5 -3552.5 {}
L 4 812.5 -3557.5 827.5 -3552.5 {}
L 4 812.5 -3557.5 827.5 -3562.5 {}
L 4 812.5 -3567.5 827.5 -3562.5 {}
L 4 812.5 -3567.5 827.5 -3572.5 {}
L 4 812.5 -3577.5 827.5 -3572.5 {}
L 4 812.5 -3577.5 827.5 -3582.5 {}
L 4 812.5 -3587.5 827.5 -3582.5 {}
L 4 812.5 -3587.5 820 -3590 {}
L 4 820 -3600 820 -3590 {}
L 4 822.5 -3592.5 827.5 -3592.5 {}
L 4 825 -3595 825 -3590 {}
L 4 820 -3610 820 -3600 {}
L 4 820 -3610 827.5 -3612.5 {}
L 4 812.5 -3617.5 827.5 -3612.5 {}
L 4 812.5 -3617.5 827.5 -3622.5 {}
L 4 812.5 -3627.5 827.5 -3622.5 {}
L 4 812.5 -3627.5 827.5 -3632.5 {}
L 4 812.5 -3637.5 827.5 -3632.5 {}
L 4 812.5 -3637.5 827.5 -3642.5 {}
L 4 812.5 -3647.5 827.5 -3642.5 {}
L 4 812.5 -3647.5 820 -3650 {}
L 4 820 -3660 820 -3650 {}
L 4 822.5 -3652.5 827.5 -3652.5 {}
L 4 825 -3655 825 -3650 {}
L 4 1360 -3490 1360 -3480 {}
L 4 1360 -3490 1367.5 -3492.5 {}
L 4 1352.5 -3497.5 1367.5 -3492.5 {}
L 4 1352.5 -3497.5 1367.5 -3502.5 {}
L 4 1352.5 -3507.5 1367.5 -3502.5 {}
L 4 1352.5 -3507.5 1367.5 -3512.5 {}
L 4 1352.5 -3517.5 1367.5 -3512.5 {}
L 4 1352.5 -3517.5 1367.5 -3522.5 {}
L 4 1352.5 -3527.5 1367.5 -3522.5 {}
L 4 1352.5 -3527.5 1360 -3530 {}
L 4 1360 -3540 1360 -3530 {}
L 4 1362.5 -3532.5 1367.5 -3532.5 {}
L 4 1365 -3535 1365 -3530 {}
L 4 1360 -3610 1367.5 -3612.5 {}
L 4 1352.5 -3617.5 1367.5 -3612.5 {}
L 4 1352.5 -3617.5 1367.5 -3622.5 {}
L 4 1352.5 -3627.5 1367.5 -3622.5 {}
L 4 1352.5 -3627.5 1367.5 -3632.5 {}
L 4 1352.5 -3637.5 1367.5 -3632.5 {}
L 4 1352.5 -3637.5 1367.5 -3642.5 {}
L 4 1352.5 -3647.5 1367.5 -3642.5 {}
L 4 1352.5 -3647.5 1360 -3650 {}
L 4 1360 -3660 1360 -3650 {}
L 4 1362.5 -3652.5 1367.5 -3652.5 {}
L 4 1365 -3655 1365 -3650 {}
L 4 1900 -3490 1900 -3480 {}
L 4 1900 -3490 1907.5 -3492.5 {}
L 4 1892.5 -3497.5 1907.5 -3492.5 {}
L 4 1892.5 -3497.5 1907.5 -3502.5 {}
L 4 1892.5 -3507.5 1907.5 -3502.5 {}
L 4 1892.5 -3507.5 1907.5 -3512.5 {}
L 4 1892.5 -3517.5 1907.5 -3512.5 {}
L 4 1892.5 -3517.5 1907.5 -3522.5 {}
L 4 1892.5 -3527.5 1907.5 -3522.5 {}
L 4 1892.5 -3527.5 1900 -3530 {}
L 4 1900 -3540 1900 -3530 {}
L 4 1902.5 -3532.5 1907.5 -3532.5 {}
L 4 1905 -3535 1905 -3530 {}
L 4 1900 -3610 1900 -3600 {}
L 4 1900 -3610 1907.5 -3612.5 {}
L 4 1892.5 -3617.5 1907.5 -3612.5 {}
L 4 1892.5 -3617.5 1907.5 -3622.5 {}
L 4 1892.5 -3627.5 1907.5 -3622.5 {}
L 4 1892.5 -3627.5 1907.5 -3632.5 {}
L 4 1892.5 -3637.5 1907.5 -3632.5 {}
L 4 1892.5 -3637.5 1907.5 -3642.5 {}
L 4 1892.5 -3647.5 1907.5 -3642.5 {}
L 4 1892.5 -3647.5 1900 -3650 {}
L 4 1900 -3660 1900 -3650 {}
L 4 1902.5 -3652.5 1907.5 -3652.5 {}
L 4 1905 -3655 1905 -3650 {}
L 4 710 -2340 710 -2330 {}
L 4 710 -2340 717.5 -2342.5 {}
L 4 702.5 -2347.5 717.5 -2342.5 {}
L 4 702.5 -2347.5 717.5 -2352.5 {}
L 4 702.5 -2357.5 717.5 -2352.5 {}
L 4 702.5 -2357.5 717.5 -2362.5 {}
L 4 702.5 -2367.5 717.5 -2362.5 {}
L 4 702.5 -2367.5 717.5 -2372.5 {}
L 4 702.5 -2377.5 717.5 -2372.5 {}
L 4 702.5 -2377.5 710 -2380 {}
L 4 710 -2390 710 -2380 {}
L 4 712.5 -2382.5 717.5 -2382.5 {}
L 4 715 -2385 715 -2380 {}
L 4 820 -2340 820 -2330 {}
L 4 820 -2340 827.5 -2342.5 {}
L 4 812.5 -2347.5 827.5 -2342.5 {}
L 4 812.5 -2347.5 827.5 -2352.5 {}
L 4 812.5 -2357.5 827.5 -2352.5 {}
L 4 812.5 -2357.5 827.5 -2362.5 {}
L 4 812.5 -2367.5 827.5 -2362.5 {}
L 4 812.5 -2367.5 827.5 -2372.5 {}
L 4 812.5 -2377.5 827.5 -2372.5 {}
L 4 812.5 -2377.5 820 -2380 {}
L 4 820 -2390 820 -2380 {}
L 4 822.5 -2382.5 827.5 -2382.5 {}
L 4 825 -2385 825 -2380 {}
L 4 930 -2340 930 -2330 {}
L 4 930 -2340 937.5 -2342.5 {}
L 4 922.5 -2347.5 937.5 -2342.5 {}
L 4 922.5 -2347.5 937.5 -2352.5 {}
L 4 922.5 -2357.5 937.5 -2352.5 {}
L 4 922.5 -2357.5 937.5 -2362.5 {}
L 4 922.5 -2367.5 937.5 -2362.5 {}
L 4 922.5 -2367.5 937.5 -2372.5 {}
L 4 922.5 -2377.5 937.5 -2372.5 {}
L 4 922.5 -2377.5 930 -2380 {}
L 4 930 -2390 930 -2380 {}
L 4 932.5 -2382.5 937.5 -2382.5 {}
L 4 935 -2385 935 -2380 {}
L 4 1250 -2340 1250 -2330 {}
L 4 1250 -2340 1257.5 -2342.5 {}
L 4 1242.5 -2347.5 1257.5 -2342.5 {}
L 4 1242.5 -2347.5 1257.5 -2352.5 {}
L 4 1242.5 -2357.5 1257.5 -2352.5 {}
L 4 1242.5 -2357.5 1257.5 -2362.5 {}
L 4 1242.5 -2367.5 1257.5 -2362.5 {}
L 4 1242.5 -2367.5 1257.5 -2372.5 {}
L 4 1242.5 -2377.5 1257.5 -2372.5 {}
L 4 1242.5 -2377.5 1250 -2380 {}
L 4 1250 -2390 1250 -2380 {}
L 4 1252.5 -2382.5 1257.5 -2382.5 {}
L 4 1255 -2385 1255 -2380 {}
L 4 1360 -2340 1360 -2330 {}
L 4 1360 -2340 1367.5 -2342.5 {}
L 4 1352.5 -2347.5 1367.5 -2342.5 {}
L 4 1352.5 -2347.5 1367.5 -2352.5 {}
L 4 1352.5 -2357.5 1367.5 -2352.5 {}
L 4 1352.5 -2357.5 1367.5 -2362.5 {}
L 4 1352.5 -2367.5 1367.5 -2362.5 {}
L 4 1352.5 -2367.5 1367.5 -2372.5 {}
L 4 1352.5 -2377.5 1367.5 -2372.5 {}
L 4 1352.5 -2377.5 1360 -2380 {}
L 4 1360 -2390 1360 -2380 {}
L 4 1362.5 -2382.5 1367.5 -2382.5 {}
L 4 1365 -2385 1365 -2380 {}
L 4 1470 -2340 1470 -2330 {}
L 4 1470 -2340 1477.5 -2342.5 {}
L 4 1462.5 -2347.5 1477.5 -2342.5 {}
L 4 1462.5 -2347.5 1477.5 -2352.5 {}
L 4 1462.5 -2357.5 1477.5 -2352.5 {}
L 4 1462.5 -2357.5 1477.5 -2362.5 {}
L 4 1462.5 -2367.5 1477.5 -2362.5 {}
L 4 1462.5 -2367.5 1477.5 -2372.5 {}
L 4 1462.5 -2377.5 1477.5 -2372.5 {}
L 4 1462.5 -2377.5 1470 -2380 {}
L 4 1470 -2390 1470 -2380 {}
L 4 1472.5 -2382.5 1477.5 -2382.5 {}
L 4 1475 -2385 1475 -2380 {}
L 4 1790 -2340 1790 -2330 {}
L 4 1790 -2340 1797.5 -2342.5 {}
L 4 1782.5 -2347.5 1797.5 -2342.5 {}
L 4 1782.5 -2347.5 1797.5 -2352.5 {}
L 4 1782.5 -2357.5 1797.5 -2352.5 {}
L 4 1782.5 -2357.5 1797.5 -2362.5 {}
L 4 1782.5 -2367.5 1797.5 -2362.5 {}
L 4 1782.5 -2367.5 1797.5 -2372.5 {}
L 4 1782.5 -2377.5 1797.5 -2372.5 {}
L 4 1782.5 -2377.5 1790 -2380 {}
L 4 1790 -2390 1790 -2380 {}
L 4 1792.5 -2382.5 1797.5 -2382.5 {}
L 4 1795 -2385 1795 -2380 {}
L 4 1900 -2340 1900 -2330 {}
L 4 1900 -2340 1907.5 -2342.5 {}
L 4 1892.5 -2347.5 1907.5 -2342.5 {}
L 4 1892.5 -2347.5 1907.5 -2352.5 {}
L 4 1892.5 -2357.5 1907.5 -2352.5 {}
L 4 1892.5 -2357.5 1907.5 -2362.5 {}
L 4 1892.5 -2367.5 1907.5 -2362.5 {}
L 4 1892.5 -2367.5 1907.5 -2372.5 {}
L 4 1892.5 -2377.5 1907.5 -2372.5 {}
L 4 1892.5 -2377.5 1900 -2380 {}
L 4 1900 -2390 1900 -2380 {}
L 4 1902.5 -2382.5 1907.5 -2382.5 {}
L 4 1905 -2385 1905 -2380 {}
L 4 2010 -2340 2010 -2330 {}
L 4 2010 -2340 2017.5 -2342.5 {}
L 4 2002.5 -2347.5 2017.5 -2342.5 {}
L 4 2002.5 -2347.5 2017.5 -2352.5 {}
L 4 2002.5 -2357.5 2017.5 -2352.5 {}
L 4 2002.5 -2357.5 2017.5 -2362.5 {}
L 4 2002.5 -2367.5 2017.5 -2362.5 {}
L 4 2002.5 -2367.5 2017.5 -2372.5 {}
L 4 2002.5 -2377.5 2017.5 -2372.5 {}
L 4 2002.5 -2377.5 2010 -2380 {}
L 4 2010 -2390 2010 -2380 {}
L 4 2012.5 -2382.5 2017.5 -2382.5 {}
L 4 2015 -2385 2015 -2380 {}
L 4 2320 -2340 2320 -2330 {}
L 4 2320 -2340 2327.5 -2342.5 {}
L 4 2312.5 -2347.5 2327.5 -2342.5 {}
L 4 2312.5 -2347.5 2327.5 -2352.5 {}
L 4 2312.5 -2357.5 2327.5 -2352.5 {}
L 4 2312.5 -2357.5 2327.5 -2362.5 {}
L 4 2312.5 -2367.5 2327.5 -2362.5 {}
L 4 2312.5 -2367.5 2327.5 -2372.5 {}
L 4 2312.5 -2377.5 2327.5 -2372.5 {}
L 4 2312.5 -2377.5 2320 -2380 {}
L 4 2320 -2390 2320 -2380 {}
L 4 2322.5 -2382.5 2327.5 -2382.5 {}
L 4 2325 -2385 2325 -2380 {}
L 4 2430 -2340 2430 -2330 {}
L 4 2430 -2340 2437.5 -2342.5 {}
L 4 2422.5 -2347.5 2437.5 -2342.5 {}
L 4 2422.5 -2347.5 2437.5 -2352.5 {}
L 4 2422.5 -2357.5 2437.5 -2352.5 {}
L 4 2422.5 -2357.5 2437.5 -2362.5 {}
L 4 2422.5 -2367.5 2437.5 -2362.5 {}
L 4 2422.5 -2367.5 2437.5 -2372.5 {}
L 4 2422.5 -2377.5 2437.5 -2372.5 {}
L 4 2422.5 -2377.5 2430 -2380 {}
L 4 2430 -2390 2430 -2380 {}
L 4 2432.5 -2382.5 2437.5 -2382.5 {}
L 4 2435 -2385 2435 -2380 {}
L 4 2540 -2340 2540 -2330 {}
L 4 2540 -2340 2547.5 -2342.5 {}
L 4 2532.5 -2347.5 2547.5 -2342.5 {}
L 4 2532.5 -2347.5 2547.5 -2352.5 {}
L 4 2532.5 -2357.5 2547.5 -2352.5 {}
L 4 2532.5 -2357.5 2547.5 -2362.5 {}
L 4 2532.5 -2367.5 2547.5 -2362.5 {}
L 4 2532.5 -2367.5 2547.5 -2372.5 {}
L 4 2532.5 -2377.5 2547.5 -2372.5 {}
L 4 2532.5 -2377.5 2540 -2380 {}
L 4 2540 -2390 2540 -2380 {}
L 4 2542.5 -2382.5 2547.5 -2382.5 {}
L 4 2545 -2385 2545 -2380 {}
L 4 2500 -3490 2500 -3480 {}
L 4 2500 -3490 2507.5 -3492.5 {}
L 4 2492.5 -3497.5 2507.5 -3492.5 {}
L 4 2492.5 -3497.5 2507.5 -3502.5 {}
L 4 2492.5 -3507.5 2507.5 -3502.5 {}
L 4 2492.5 -3507.5 2507.5 -3512.5 {}
L 4 2492.5 -3517.5 2507.5 -3512.5 {}
L 4 2492.5 -3517.5 2507.5 -3522.5 {}
L 4 2492.5 -3527.5 2507.5 -3522.5 {}
L 4 2492.5 -3527.5 2500 -3530 {}
L 4 2500 -3540 2500 -3530 {}
L 4 2502.5 -3532.5 2507.5 -3532.5 {}
L 4 2505 -3535 2505 -3530 {}
L 4 2500 -3610 2500 -3600 {}
L 4 2500 -3610 2507.5 -3612.5 {}
L 4 2492.5 -3617.5 2507.5 -3612.5 {}
L 4 2492.5 -3617.5 2507.5 -3622.5 {}
L 4 2492.5 -3627.5 2507.5 -3622.5 {}
L 4 2492.5 -3627.5 2507.5 -3632.5 {}
L 4 2492.5 -3637.5 2507.5 -3632.5 {}
L 4 2492.5 -3637.5 2507.5 -3642.5 {}
L 4 2492.5 -3647.5 2507.5 -3642.5 {}
L 4 2492.5 -3647.5 2500 -3650 {}
L 4 2500 -3660 2500 -3650 {}
L 4 2502.5 -3652.5 2507.5 -3652.5 {}
L 4 2505 -3655 2505 -3650 {}
L 4 710 -410 710 -400 {}
L 4 710 -410 717.5 -412.5 {}
L 4 702.5 -417.5 717.5 -412.5 {}
L 4 702.5 -417.5 717.5 -422.5 {}
L 4 702.5 -427.5 717.5 -422.5 {}
L 4 702.5 -427.5 717.5 -432.5 {}
L 4 702.5 -437.5 717.5 -432.5 {}
L 4 702.5 -437.5 717.5 -442.5 {}
L 4 702.5 -447.5 717.5 -442.5 {}
L 4 702.5 -447.5 710 -450 {}
L 4 710 -460 710 -450 {}
L 4 712.5 -452.5 717.5 -452.5 {}
L 4 715 -455 715 -450 {}
L 4 820 -410 820 -400 {}
L 4 820 -410 827.5 -412.5 {}
L 4 812.5 -417.5 827.5 -412.5 {}
L 4 812.5 -417.5 827.5 -422.5 {}
L 4 812.5 -427.5 827.5 -422.5 {}
L 4 812.5 -427.5 827.5 -432.5 {}
L 4 812.5 -437.5 827.5 -432.5 {}
L 4 812.5 -437.5 827.5 -442.5 {}
L 4 812.5 -447.5 827.5 -442.5 {}
L 4 812.5 -447.5 820 -450 {}
L 4 820 -460 820 -450 {}
L 4 822.5 -452.5 827.5 -452.5 {}
L 4 825 -455 825 -450 {}
L 4 930 -410 930 -400 {}
L 4 930 -410 937.5 -412.5 {}
L 4 922.5 -417.5 937.5 -412.5 {}
L 4 922.5 -417.5 937.5 -422.5 {}
L 4 922.5 -427.5 937.5 -422.5 {}
L 4 922.5 -427.5 937.5 -432.5 {}
L 4 922.5 -437.5 937.5 -432.5 {}
L 4 922.5 -437.5 937.5 -442.5 {}
L 4 922.5 -447.5 937.5 -442.5 {}
L 4 922.5 -447.5 930 -450 {}
L 4 930 -460 930 -450 {}
L 4 932.5 -452.5 937.5 -452.5 {}
L 4 935 -455 935 -450 {}
L 4 710 -320 710 -310 {}
L 4 710 -320 717.5 -322.5 {}
L 4 702.5 -327.5 717.5 -322.5 {}
L 4 702.5 -327.5 717.5 -332.5 {}
L 4 702.5 -337.5 717.5 -332.5 {}
L 4 702.5 -337.5 717.5 -342.5 {}
L 4 702.5 -347.5 717.5 -342.5 {}
L 4 702.5 -347.5 717.5 -352.5 {}
L 4 702.5 -357.5 717.5 -352.5 {}
L 4 702.5 -357.5 710 -360 {}
L 4 710 -370 710 -360 {}
L 4 712.5 -362.5 717.5 -362.5 {}
L 4 715 -365 715 -360 {}
L 4 820 -320 820 -310 {}
L 4 820 -320 827.5 -322.5 {}
L 4 812.5 -327.5 827.5 -322.5 {}
L 4 812.5 -327.5 827.5 -332.5 {}
L 4 812.5 -337.5 827.5 -332.5 {}
L 4 812.5 -337.5 827.5 -342.5 {}
L 4 812.5 -347.5 827.5 -342.5 {}
L 4 812.5 -347.5 827.5 -352.5 {}
L 4 812.5 -357.5 827.5 -352.5 {}
L 4 812.5 -357.5 820 -360 {}
L 4 820 -370 820 -360 {}
L 4 822.5 -362.5 827.5 -362.5 {}
L 4 825 -365 825 -360 {}
L 4 930 -320 930 -310 {}
L 4 930 -320 937.5 -322.5 {}
L 4 922.5 -327.5 937.5 -322.5 {}
L 4 922.5 -327.5 937.5 -332.5 {}
L 4 922.5 -337.5 937.5 -332.5 {}
L 4 922.5 -337.5 937.5 -342.5 {}
L 4 922.5 -347.5 937.5 -342.5 {}
L 4 922.5 -347.5 937.5 -352.5 {}
L 4 922.5 -357.5 937.5 -352.5 {}
L 4 922.5 -357.5 930 -360 {}
L 4 930 -370 930 -360 {}
L 4 932.5 -362.5 937.5 -362.5 {}
L 4 935 -365 935 -360 {}
L 4 1250 -320 1250 -310 {}
L 4 1250 -320 1257.5 -322.5 {}
L 4 1242.5 -327.5 1257.5 -322.5 {}
L 4 1242.5 -327.5 1257.5 -332.5 {}
L 4 1242.5 -337.5 1257.5 -332.5 {}
L 4 1242.5 -337.5 1257.5 -342.5 {}
L 4 1242.5 -347.5 1257.5 -342.5 {}
L 4 1242.5 -347.5 1257.5 -352.5 {}
L 4 1242.5 -357.5 1257.5 -352.5 {}
L 4 1242.5 -357.5 1250 -360 {}
L 4 1250 -370 1250 -360 {}
L 4 1252.5 -362.5 1257.5 -362.5 {}
L 4 1255 -365 1255 -360 {}
L 4 1360 -320 1360 -310 {}
L 4 1360 -320 1367.5 -322.5 {}
L 4 1352.5 -327.5 1367.5 -322.5 {}
L 4 1352.5 -327.5 1367.5 -332.5 {}
L 4 1352.5 -337.5 1367.5 -332.5 {}
L 4 1352.5 -337.5 1367.5 -342.5 {}
L 4 1352.5 -347.5 1367.5 -342.5 {}
L 4 1352.5 -347.5 1367.5 -352.5 {}
L 4 1352.5 -357.5 1367.5 -352.5 {}
L 4 1352.5 -357.5 1360 -360 {}
L 4 1360 -370 1360 -360 {}
L 4 1362.5 -362.5 1367.5 -362.5 {}
L 4 1365 -365 1365 -360 {}
L 4 1470 -320 1470 -310 {}
L 4 1470 -320 1477.5 -322.5 {}
L 4 1462.5 -327.5 1477.5 -322.5 {}
L 4 1462.5 -327.5 1477.5 -332.5 {}
L 4 1462.5 -337.5 1477.5 -332.5 {}
L 4 1462.5 -337.5 1477.5 -342.5 {}
L 4 1462.5 -347.5 1477.5 -342.5 {}
L 4 1462.5 -347.5 1477.5 -352.5 {}
L 4 1462.5 -357.5 1477.5 -352.5 {}
L 4 1462.5 -357.5 1470 -360 {}
L 4 1470 -370 1470 -360 {}
L 4 1472.5 -362.5 1477.5 -362.5 {}
L 4 1475 -365 1475 -360 {}
L 4 1790 -320 1790 -310 {}
L 4 1790 -320 1797.5 -322.5 {}
L 4 1782.5 -327.5 1797.5 -322.5 {}
L 4 1782.5 -327.5 1797.5 -332.5 {}
L 4 1782.5 -337.5 1797.5 -332.5 {}
L 4 1782.5 -337.5 1797.5 -342.5 {}
L 4 1782.5 -347.5 1797.5 -342.5 {}
L 4 1782.5 -347.5 1797.5 -352.5 {}
L 4 1782.5 -357.5 1797.5 -352.5 {}
L 4 1782.5 -357.5 1790 -360 {}
L 4 1790 -370 1790 -360 {}
L 4 1792.5 -362.5 1797.5 -362.5 {}
L 4 1795 -365 1795 -360 {}
L 4 1900 -320 1900 -310 {}
L 4 1900 -320 1907.5 -322.5 {}
L 4 1892.5 -327.5 1907.5 -322.5 {}
L 4 1892.5 -327.5 1907.5 -332.5 {}
L 4 1892.5 -337.5 1907.5 -332.5 {}
L 4 1892.5 -337.5 1907.5 -342.5 {}
L 4 1892.5 -347.5 1907.5 -342.5 {}
L 4 1892.5 -347.5 1907.5 -352.5 {}
L 4 1892.5 -357.5 1907.5 -352.5 {}
L 4 1892.5 -357.5 1900 -360 {}
L 4 1900 -370 1900 -360 {}
L 4 1902.5 -362.5 1907.5 -362.5 {}
L 4 1905 -365 1905 -360 {}
L 4 2010 -320 2010 -310 {}
L 4 2010 -320 2017.5 -322.5 {}
L 4 2002.5 -327.5 2017.5 -322.5 {}
L 4 2002.5 -327.5 2017.5 -332.5 {}
L 4 2002.5 -337.5 2017.5 -332.5 {}
L 4 2002.5 -337.5 2017.5 -342.5 {}
L 4 2002.5 -347.5 2017.5 -342.5 {}
L 4 2002.5 -347.5 2017.5 -352.5 {}
L 4 2002.5 -357.5 2017.5 -352.5 {}
L 4 2002.5 -357.5 2010 -360 {}
L 4 2010 -370 2010 -360 {}
L 4 2012.5 -362.5 2017.5 -362.5 {}
L 4 2015 -365 2015 -360 {}
L 4 1865 -2130 1865 -2070 {}
L 4 1865 -2120 1880 -2120 {}
L 4 1880 -2130 1880 -2120 {}
L 4 1865 -2080 1880 -2080 {}
L 4 1880 -2080 1880 -2070 {}
L 4 1855 -2115 1855 -2085 {}
L 4 1855 -2100 1855 -2095 {}
L 4 1840 -2100 1847.5 -2100 {}
L 4 1840 -2100 1855 -2100 {}
L 4 1870 -2100 1880 -2100 {}
L 4 1865 -2105 1870 -2100 {}
L 4 1865 -2095 1870 -2100 {}
L 4 1140 -8580 1140 -8567.5 {}
L 4 1135 -8567.5 1145 -8567.5 {}
L 4 1140 -8562.5 1145 -8567.5 {}
L 4 1135 -8567.5 1140 -8562.5 {}
L 4 1140 -8860 1140 -8840 {}
L 4 1130 -8860 1150 -8860 {}
L 4 1032.5 -8652.5 1037.5 -8652.5 {}
L 4 1035 -8655 1035 -8650 {}
L 4 1030 -8660 1030 -8600 {}
L 4 710 -30 710 -20 {}
L 4 710 -30 717.5 -32.5 {}
L 4 702.5 -37.5 717.5 -32.5 {}
L 4 702.5 -37.5 717.5 -42.5 {}
L 4 702.5 -47.5 717.5 -42.5 {}
L 4 702.5 -47.5 717.5 -52.5 {}
L 4 702.5 -57.5 717.5 -52.5 {}
L 4 702.5 -57.5 717.5 -62.5 {}
L 4 702.5 -67.5 717.5 -62.5 {}
L 4 702.5 -67.5 710 -70 {}
L 4 710 -80 710 -70 {}
L 4 712.5 -72.5 717.5 -72.5 {}
L 4 715 -75 715 -70 {}
L 4 820 -30 820 -20 {}
L 4 820 -30 827.5 -32.5 {}
L 4 812.5 -37.5 827.5 -32.5 {}
L 4 812.5 -37.5 827.5 -42.5 {}
L 4 812.5 -47.5 827.5 -42.5 {}
L 4 812.5 -47.5 827.5 -52.5 {}
L 4 812.5 -57.5 827.5 -52.5 {}
L 4 812.5 -57.5 827.5 -62.5 {}
L 4 812.5 -67.5 827.5 -62.5 {}
L 4 812.5 -67.5 820 -70 {}
L 4 820 -80 820 -70 {}
L 4 822.5 -72.5 827.5 -72.5 {}
L 4 825 -75 825 -70 {}
L 4 930 -30 930 -20 {}
L 4 930 -30 937.5 -32.5 {}
L 4 922.5 -37.5 937.5 -32.5 {}
L 4 922.5 -37.5 937.5 -42.5 {}
L 4 922.5 -47.5 937.5 -42.5 {}
L 4 922.5 -47.5 937.5 -52.5 {}
L 4 922.5 -57.5 937.5 -52.5 {}
L 4 922.5 -57.5 937.5 -62.5 {}
L 4 922.5 -67.5 937.5 -62.5 {}
L 4 922.5 -67.5 930 -70 {}
L 4 930 -80 930 -70 {}
L 4 932.5 -72.5 937.5 -72.5 {}
L 4 935 -75 935 -70 {}
L 4 710 30 710 40 {}
L 4 710 30 717.5 27.5 {}
L 4 702.5 22.5 717.5 27.5 {}
L 4 702.5 22.5 717.5 17.5 {}
L 4 702.5 12.5 717.5 17.5 {}
L 4 702.5 12.5 717.5 7.5 {}
L 4 702.5 2.5 717.5 7.5 {}
L 4 702.5 2.5 717.5 -2.5 {}
L 4 702.5 -7.5 717.5 -2.5 {}
L 4 702.5 -7.5 710 -10 {}
L 4 710 -20 710 -10 {}
L 4 712.5 -12.5 717.5 -12.5 {}
L 4 715 -15 715 -10 {}
L 4 820 30 820 40 {}
L 4 820 30 827.5 27.5 {}
L 4 812.5 22.5 827.5 27.5 {}
L 4 812.5 22.5 827.5 17.5 {}
L 4 812.5 12.5 827.5 17.5 {}
L 4 812.5 12.5 827.5 7.5 {}
L 4 812.5 2.5 827.5 7.5 {}
L 4 812.5 2.5 827.5 -2.5 {}
L 4 812.5 -7.5 827.5 -2.5 {}
L 4 812.5 -7.5 820 -10 {}
L 4 820 -20 820 -10 {}
L 4 822.5 -12.5 827.5 -12.5 {}
L 4 825 -15 825 -10 {}
L 4 930 30 930 40 {}
L 4 930 30 937.5 27.5 {}
L 4 922.5 22.5 937.5 27.5 {}
L 4 922.5 22.5 937.5 17.5 {}
L 4 922.5 12.5 937.5 17.5 {}
L 4 922.5 12.5 937.5 7.5 {}
L 4 922.5 2.5 937.5 7.5 {}
L 4 922.5 2.5 937.5 -2.5 {}
L 4 922.5 -7.5 937.5 -2.5 {}
L 4 922.5 -7.5 930 -10 {}
L 4 930 -20 930 -10 {}
L 4 932.5 -12.5 937.5 -12.5 {}
L 4 935 -15 935 -10 {}
L 4 1250 30 1250 40 {}
L 4 1250 30 1257.5 27.5 {}
L 4 1242.5 22.5 1257.5 27.5 {}
L 4 1242.5 22.5 1257.5 17.5 {}
L 4 1242.5 12.5 1257.5 17.5 {}
L 4 1242.5 12.5 1257.5 7.5 {}
L 4 1242.5 2.5 1257.5 7.5 {}
L 4 1242.5 2.5 1257.5 -2.5 {}
L 4 1242.5 -7.5 1257.5 -2.5 {}
L 4 1242.5 -7.5 1250 -10 {}
L 4 1250 -20 1250 -10 {}
L 4 1252.5 -12.5 1257.5 -12.5 {}
L 4 1255 -15 1255 -10 {}
L 4 1360 30 1360 40 {}
L 4 1360 30 1367.5 27.5 {}
L 4 1352.5 22.5 1367.5 27.5 {}
L 4 1352.5 22.5 1367.5 17.5 {}
L 4 1352.5 12.5 1367.5 17.5 {}
L 4 1352.5 12.5 1367.5 7.5 {}
L 4 1352.5 2.5 1367.5 7.5 {}
L 4 1352.5 2.5 1367.5 -2.5 {}
L 4 1352.5 -7.5 1367.5 -2.5 {}
L 4 1352.5 -7.5 1360 -10 {}
L 4 1360 -20 1360 -10 {}
L 4 1362.5 -12.5 1367.5 -12.5 {}
L 4 1365 -15 1365 -10 {}
L 4 1470 30 1470 40 {}
L 4 1470 30 1477.5 27.5 {}
L 4 1462.5 22.5 1477.5 27.5 {}
L 4 1462.5 22.5 1477.5 17.5 {}
L 4 1462.5 12.5 1477.5 17.5 {}
L 4 1462.5 12.5 1477.5 7.5 {}
L 4 1462.5 2.5 1477.5 7.5 {}
L 4 1462.5 2.5 1477.5 -2.5 {}
L 4 1462.5 -7.5 1477.5 -2.5 {}
L 4 1462.5 -7.5 1470 -10 {}
L 4 1470 -20 1470 -10 {}
L 4 1472.5 -12.5 1477.5 -12.5 {}
L 4 1475 -15 1475 -10 {}
L 4 1790 60 1790 70 {}
L 4 1790 60 1797.5 57.5 {}
L 4 1782.5 52.5 1797.5 57.5 {}
L 4 1782.5 52.5 1797.5 47.5 {}
L 4 1782.5 42.5 1797.5 47.5 {}
L 4 1782.5 42.5 1797.5 37.5 {}
L 4 1782.5 32.5 1797.5 37.5 {}
L 4 1782.5 32.5 1797.5 27.5 {}
L 4 1782.5 22.5 1797.5 27.5 {}
L 4 1782.5 22.5 1790 20 {}
L 4 1790 10 1790 20 {}
L 4 1792.5 17.5 1797.5 17.5 {}
L 4 1795 15 1795 20 {}
L 4 1900 60 1900 70 {}
L 4 1900 60 1907.5 57.5 {}
L 4 1892.5 52.5 1907.5 57.5 {}
L 4 1892.5 52.5 1907.5 47.5 {}
L 4 1892.5 42.5 1907.5 47.5 {}
L 4 1892.5 42.5 1907.5 37.5 {}
L 4 1892.5 32.5 1907.5 37.5 {}
L 4 1892.5 32.5 1907.5 27.5 {}
L 4 1892.5 22.5 1907.5 27.5 {}
L 4 1892.5 22.5 1900 20 {}
L 4 1900 10 1900 20 {}
L 4 1902.5 17.5 1907.5 17.5 {}
L 4 1905 15 1905 20 {}
L 4 2010 60 2010 70 {}
L 4 2010 60 2017.5 57.5 {}
L 4 2002.5 52.5 2017.5 57.5 {}
L 4 2002.5 52.5 2017.5 47.5 {}
L 4 2002.5 42.5 2017.5 47.5 {}
L 4 2002.5 42.5 2017.5 37.5 {}
L 4 2002.5 32.5 2017.5 37.5 {}
L 4 2002.5 32.5 2017.5 27.5 {}
L 4 2002.5 22.5 2017.5 27.5 {}
L 4 2002.5 22.5 2010 20 {}
L 4 2010 10 2010 20 {}
L 4 2012.5 17.5 2017.5 17.5 {}
L 4 2015 15 2015 20 {}
L 4 1760 -720 1760 -710 {}
L 4 1760 -720 1767.5 -722.5 {}
L 4 1752.5 -727.5 1767.5 -722.5 {}
L 4 1752.5 -727.5 1767.5 -732.5 {}
L 4 1752.5 -737.5 1767.5 -732.5 {}
L 4 1752.5 -737.5 1767.5 -742.5 {}
L 4 1752.5 -747.5 1767.5 -742.5 {}
L 4 1752.5 -747.5 1767.5 -752.5 {}
L 4 1752.5 -757.5 1767.5 -752.5 {}
L 4 1752.5 -757.5 1760 -760 {}
L 4 1760 -770 1760 -760 {}
L 4 1762.5 -762.5 1767.5 -762.5 {}
L 4 1765 -765 1765 -760 {}
L 4 1880 -720 1880 -710 {}
L 4 1880 -720 1887.5 -722.5 {}
L 4 1872.5 -727.5 1887.5 -722.5 {}
L 4 1872.5 -727.5 1887.5 -732.5 {}
L 4 1872.5 -737.5 1887.5 -732.5 {}
L 4 1872.5 -737.5 1887.5 -742.5 {}
L 4 1872.5 -747.5 1887.5 -742.5 {}
L 4 1872.5 -747.5 1887.5 -752.5 {}
L 4 1872.5 -757.5 1887.5 -752.5 {}
L 4 1872.5 -757.5 1880 -760 {}
L 4 1880 -770 1880 -760 {}
L 4 1882.5 -762.5 1887.5 -762.5 {}
L 4 1885 -765 1885 -760 {}
L 4 805 380 805 440 {}
L 4 805 390 820 390 {}
L 4 820 380 820 390 {}
L 4 805 430 820 430 {}
L 4 820 430 820 440 {}
L 4 795 395 795 425 {}
L 4 795 410 795 415 {}
L 4 780 410 787.5 410 {}
L 4 780 410 795 410 {}
L 4 810 410 820 410 {}
L 4 805 405 810 410 {}
L 4 805 415 810 410 {}
L 4 820 340 820 350 {}
L 4 820 340 827.5 337.5 {}
L 4 812.5 332.5 827.5 337.5 {}
L 4 812.5 332.5 827.5 327.5 {}
L 4 812.5 322.5 827.5 327.5 {}
L 4 812.5 322.5 827.5 317.5 {}
L 4 812.5 312.5 827.5 317.5 {}
L 4 812.5 312.5 827.5 307.5 {}
L 4 812.5 302.5 827.5 307.5 {}
L 4 812.5 302.5 820 300 {}
L 4 820 290 820 300 {}
L 4 822.5 297.5 827.5 297.5 {}
L 4 825 295 825 300 {}
L 4 910 415 910 440 {}
L 4 910 380 910 405 {}
L 4 900 405 920 405 {}
L 4 900 415 920 415 {}
L 4 912.5 387.5 917.5 387.5 {}
L 4 915 385 915 390 {}
L 4 582.5 447.5 587.5 447.5 {}
L 4 585 445 585 450 {}
L 4 580 440 580 500 {}
L 4 690 520 690 532.5 {}
L 4 685 532.5 695 532.5 {}
L 4 690 537.5 695 532.5 {}
L 4 685 532.5 690 537.5 {}
L 4 690 240 690 260 {}
L 4 680 240 700 240 {}
L 4 1455 380 1455 440 {}
L 4 1455 390 1470 390 {}
L 4 1470 380 1470 390 {}
L 4 1455 430 1470 430 {}
L 4 1470 430 1470 440 {}
L 4 1445 395 1445 425 {}
L 4 1445 410 1445 415 {}
L 4 1430 410 1437.5 410 {}
L 4 1430 410 1445 410 {}
L 4 1460 410 1470 410 {}
L 4 1455 405 1460 410 {}
L 4 1455 415 1460 410 {}
L 4 1470 340 1470 350 {}
L 4 1470 340 1477.5 337.5 {}
L 4 1462.5 332.5 1477.5 337.5 {}
L 4 1462.5 332.5 1477.5 327.5 {}
L 4 1462.5 322.5 1477.5 327.5 {}
L 4 1462.5 322.5 1477.5 317.5 {}
L 4 1462.5 312.5 1477.5 317.5 {}
L 4 1462.5 312.5 1477.5 307.5 {}
L 4 1462.5 302.5 1477.5 307.5 {}
L 4 1462.5 302.5 1470 300 {}
L 4 1470 290 1470 300 {}
L 4 1472.5 297.5 1477.5 297.5 {}
L 4 1475 295 1475 300 {}
L 4 1232.5 447.5 1237.5 447.5 {}
L 4 1235 445 1235 450 {}
L 4 1230 440 1230 500 {}
L 4 1340 520 1340 532.5 {}
L 4 1335 532.5 1345 532.5 {}
L 4 1340 537.5 1345 532.5 {}
L 4 1335 532.5 1340 537.5 {}
L 4 1340 240 1340 260 {}
L 4 1330 240 1350 240 {}
L 4 1285 -4370 1285 -4310 {}
L 4 1285 -4360 1300 -4360 {}
L 4 1300 -4370 1300 -4360 {}
L 4 1285 -4320 1300 -4320 {}
L 4 1300 -4320 1300 -4310 {}
L 4 1275 -4355 1275 -4325 {}
L 4 1275 -4340 1275 -4335 {}
L 4 1260 -4340 1267.5 -4340 {}
L 4 1260 -4340 1275 -4340 {}
L 4 1290 -4340 1300 -4340 {}
L 4 1285 -4345 1290 -4340 {}
L 4 1285 -4335 1290 -4340 {}
L 4 1300 -4410 1300 -4400 {}
L 4 1300 -4410 1307.5 -4412.5 {}
L 4 1292.5 -4417.5 1307.5 -4412.5 {}
L 4 1292.5 -4417.5 1307.5 -4422.5 {}
L 4 1292.5 -4427.5 1307.5 -4422.5 {}
L 4 1292.5 -4427.5 1307.5 -4432.5 {}
L 4 1292.5 -4437.5 1307.5 -4432.5 {}
L 4 1292.5 -4437.5 1307.5 -4442.5 {}
L 4 1292.5 -4447.5 1307.5 -4442.5 {}
L 4 1292.5 -4447.5 1300 -4450 {}
L 4 1300 -4460 1300 -4450 {}
L 4 1302.5 -4452.5 1307.5 -4452.5 {}
L 4 1305 -4455 1305 -4450 {}
L 4 1390 -4335 1390 -4310 {}
L 4 1390 -4370 1390 -4345 {}
L 4 1380 -4345 1400 -4345 {}
L 4 1380 -4335 1400 -4335 {}
L 4 1392.5 -4362.5 1397.5 -4362.5 {}
L 4 1395 -4365 1395 -4360 {}
L 4 1062.5 -4302.5 1067.5 -4302.5 {}
L 4 1065 -4305 1065 -4300 {}
L 4 1060 -4310 1060 -4250 {}
L 4 1170 -4230 1170 -4217.5 {}
L 4 1165 -4217.5 1175 -4217.5 {}
L 4 1170 -4212.5 1175 -4217.5 {}
L 4 1165 -4217.5 1170 -4212.5 {}
L 4 1170 -4510 1170 -4490 {}
L 4 1160 -4510 1180 -4510 {}
L 4 1845 -4370 1845 -4310 {}
L 4 1845 -4360 1860 -4360 {}
L 4 1860 -4370 1860 -4360 {}
L 4 1845 -4320 1860 -4320 {}
L 4 1860 -4320 1860 -4310 {}
L 4 1835 -4355 1835 -4325 {}
L 4 1835 -4340 1835 -4335 {}
L 4 1820 -4340 1827.5 -4340 {}
L 4 1820 -4340 1835 -4340 {}
L 4 1850 -4340 1860 -4340 {}
L 4 1845 -4345 1850 -4340 {}
L 4 1845 -4335 1850 -4340 {}
L 4 1860 -4410 1860 -4400 {}
L 4 1860 -4410 1867.5 -4412.5 {}
L 4 1852.5 -4417.5 1867.5 -4412.5 {}
L 4 1852.5 -4417.5 1867.5 -4422.5 {}
L 4 1852.5 -4427.5 1867.5 -4422.5 {}
L 4 1852.5 -4427.5 1867.5 -4432.5 {}
L 4 1852.5 -4437.5 1867.5 -4432.5 {}
L 4 1852.5 -4437.5 1867.5 -4442.5 {}
L 4 1852.5 -4447.5 1867.5 -4442.5 {}
L 4 1852.5 -4447.5 1860 -4450 {}
L 4 1860 -4460 1860 -4450 {}
L 4 1862.5 -4452.5 1867.5 -4452.5 {}
L 4 1865 -4455 1865 -4450 {}
L 4 1950 -4335 1950 -4310 {}
L 4 1950 -4370 1950 -4345 {}
L 4 1940 -4345 1960 -4345 {}
L 4 1940 -4335 1960 -4335 {}
L 4 1952.5 -4362.5 1957.5 -4362.5 {}
L 4 1955 -4365 1955 -4360 {}
L 4 1622.5 -4302.5 1627.5 -4302.5 {}
L 4 1625 -4305 1625 -4300 {}
L 4 1620 -4310 1620 -4250 {}
L 4 1730 -4230 1730 -4217.5 {}
L 4 1725 -4217.5 1735 -4217.5 {}
L 4 1730 -4212.5 1735 -4217.5 {}
L 4 1725 -4217.5 1730 -4212.5 {}
L 4 1730 -4510 1730 -4490 {}
L 4 1720 -4510 1740 -4510 {}
L 4 2415 -4370 2415 -4310 {}
L 4 2415 -4360 2430 -4360 {}
L 4 2430 -4370 2430 -4360 {}
L 4 2415 -4320 2430 -4320 {}
L 4 2430 -4320 2430 -4310 {}
L 4 2405 -4355 2405 -4325 {}
L 4 2405 -4340 2405 -4335 {}
L 4 2390 -4340 2397.5 -4340 {}
L 4 2390 -4340 2405 -4340 {}
L 4 2420 -4340 2430 -4340 {}
L 4 2415 -4345 2420 -4340 {}
L 4 2415 -4335 2420 -4340 {}
L 4 2430 -4410 2430 -4400 {}
L 4 2430 -4410 2437.5 -4412.5 {}
L 4 2422.5 -4417.5 2437.5 -4412.5 {}
L 4 2422.5 -4417.5 2437.5 -4422.5 {}
L 4 2422.5 -4427.5 2437.5 -4422.5 {}
L 4 2422.5 -4427.5 2437.5 -4432.5 {}
L 4 2422.5 -4437.5 2437.5 -4432.5 {}
L 4 2422.5 -4437.5 2437.5 -4442.5 {}
L 4 2422.5 -4447.5 2437.5 -4442.5 {}
L 4 2422.5 -4447.5 2430 -4450 {}
L 4 2430 -4460 2430 -4450 {}
L 4 2432.5 -4452.5 2437.5 -4452.5 {}
L 4 2435 -4455 2435 -4450 {}
L 4 2520 -4335 2520 -4310 {}
L 4 2520 -4370 2520 -4345 {}
L 4 2510 -4345 2530 -4345 {}
L 4 2510 -4335 2530 -4335 {}
L 4 2522.5 -4362.5 2527.5 -4362.5 {}
L 4 2525 -4365 2525 -4360 {}
L 4 2192.5 -4302.5 2197.5 -4302.5 {}
L 4 2195 -4305 2195 -4300 {}
L 4 2190 -4310 2190 -4250 {}
L 4 2300 -4230 2300 -4217.5 {}
L 4 2295 -4217.5 2305 -4217.5 {}
L 4 2300 -4212.5 2305 -4217.5 {}
L 4 2295 -4217.5 2300 -4212.5 {}
L 4 2300 -4510 2300 -4490 {}
L 4 2290 -4510 2310 -4510 {}
L 4 2015 380 2015 440 {}
L 4 2015 390 2030 390 {}
L 4 2030 380 2030 390 {}
L 4 2015 430 2030 430 {}
L 4 2030 430 2030 440 {}
L 4 2005 395 2005 425 {}
L 4 2005 410 2005 415 {}
L 4 1990 410 1997.5 410 {}
L 4 1990 410 2005 410 {}
L 4 2020 410 2030 410 {}
L 4 2015 405 2020 410 {}
L 4 2015 415 2020 410 {}
L 4 2030 340 2030 350 {}
L 4 2030 340 2037.5 337.5 {}
L 4 2022.5 332.5 2037.5 337.5 {}
L 4 2022.5 332.5 2037.5 327.5 {}
L 4 2022.5 322.5 2037.5 327.5 {}
L 4 2022.5 322.5 2037.5 317.5 {}
L 4 2022.5 312.5 2037.5 317.5 {}
L 4 2022.5 312.5 2037.5 307.5 {}
L 4 2022.5 302.5 2037.5 307.5 {}
L 4 2022.5 302.5 2030 300 {}
L 4 2030 290 2030 300 {}
L 4 2032.5 297.5 2037.5 297.5 {}
L 4 2035 295 2035 300 {}
L 4 1792.5 447.5 1797.5 447.5 {}
L 4 1795 445 1795 450 {}
L 4 1790 440 1790 500 {}
L 4 1900 520 1900 532.5 {}
L 4 1895 532.5 1905 532.5 {}
L 4 1900 537.5 1905 532.5 {}
L 4 1895 532.5 1900 537.5 {}
L 4 1900 240 1900 260 {}
L 4 1890 240 1910 240 {}
L 4 745 -3990 745 -3930 {}
L 4 745 -3980 760 -3980 {}
L 4 760 -3990 760 -3980 {}
L 4 745 -3940 760 -3940 {}
L 4 760 -3940 760 -3930 {}
L 4 735 -3975 735 -3945 {}
L 4 735 -3960 735 -3955 {}
L 4 720 -3960 727.5 -3960 {}
L 4 720 -3960 735 -3960 {}
L 4 750 -3960 760 -3960 {}
L 4 745 -3965 750 -3960 {}
L 4 745 -3955 750 -3960 {}
L 4 850 -3955 850 -3930 {}
L 4 850 -3990 850 -3965 {}
L 4 840 -3965 860 -3965 {}
L 4 840 -3955 860 -3955 {}
L 4 852.5 -3982.5 857.5 -3982.5 {}
L 4 855 -3985 855 -3980 {}
L 4 522.5 -3922.5 527.5 -3922.5 {}
L 4 525 -3925 525 -3920 {}
L 4 520 -3930 520 -3870 {}
L 4 630 -3850 630 -3837.5 {}
L 4 625 -3837.5 635 -3837.5 {}
L 4 630 -3832.5 635 -3837.5 {}
L 4 625 -3837.5 630 -3832.5 {}
L 4 420 -6940 420 -6930 {}
L 4 420 -6940 427.5 -6942.5 {}
L 4 412.5 -6947.5 427.5 -6942.5 {}
L 4 412.5 -6947.5 427.5 -6952.5 {}
L 4 412.5 -6957.5 427.5 -6952.5 {}
L 4 412.5 -6957.5 427.5 -6962.5 {}
L 4 412.5 -6967.5 427.5 -6962.5 {}
L 4 412.5 -6967.5 427.5 -6972.5 {}
L 4 412.5 -6977.5 427.5 -6972.5 {}
L 4 412.5 -6977.5 420 -6980 {}
L 4 420 -6990 420 -6980 {}
L 4 422.5 -6982.5 427.5 -6982.5 {}
L 4 425 -6985 425 -6980 {}
L 4 610 -6940 610 -6930 {}
L 4 610 -6940 617.5 -6942.5 {}
L 4 602.5 -6947.5 617.5 -6942.5 {}
L 4 602.5 -6947.5 617.5 -6952.5 {}
L 4 602.5 -6957.5 617.5 -6952.5 {}
L 4 602.5 -6957.5 617.5 -6962.5 {}
L 4 602.5 -6967.5 617.5 -6962.5 {}
L 4 602.5 -6967.5 617.5 -6972.5 {}
L 4 602.5 -6977.5 617.5 -6972.5 {}
L 4 602.5 -6977.5 610 -6980 {}
L 4 610 -6990 610 -6980 {}
L 4 612.5 -6982.5 617.5 -6982.5 {}
L 4 615 -6985 615 -6980 {}
L 4 800 -6940 800 -6930 {}
L 4 800 -6940 807.5 -6942.5 {}
L 4 792.5 -6947.5 807.5 -6942.5 {}
L 4 792.5 -6947.5 807.5 -6952.5 {}
L 4 792.5 -6957.5 807.5 -6952.5 {}
L 4 792.5 -6957.5 807.5 -6962.5 {}
L 4 792.5 -6967.5 807.5 -6962.5 {}
L 4 792.5 -6967.5 807.5 -6972.5 {}
L 4 792.5 -6977.5 807.5 -6972.5 {}
L 4 792.5 -6977.5 800 -6980 {}
L 4 800 -6990 800 -6980 {}
L 4 802.5 -6982.5 807.5 -6982.5 {}
L 4 805 -6985 805 -6980 {}
L 4 1050 -6940 1050 -6930 {}
L 4 1050 -6940 1057.5 -6942.5 {}
L 4 1042.5 -6947.5 1057.5 -6942.5 {}
L 4 1042.5 -6947.5 1057.5 -6952.5 {}
L 4 1042.5 -6957.5 1057.5 -6952.5 {}
L 4 1042.5 -6957.5 1057.5 -6962.5 {}
L 4 1042.5 -6967.5 1057.5 -6962.5 {}
L 4 1042.5 -6967.5 1057.5 -6972.5 {}
L 4 1042.5 -6977.5 1057.5 -6972.5 {}
L 4 1042.5 -6977.5 1050 -6980 {}
L 4 1050 -6990 1050 -6980 {}
L 4 1052.5 -6982.5 1057.5 -6982.5 {}
L 4 1055 -6985 1055 -6980 {}
L 4 1240 -6940 1240 -6930 {}
L 4 1240 -6940 1247.5 -6942.5 {}
L 4 1232.5 -6947.5 1247.5 -6942.5 {}
L 4 1232.5 -6947.5 1247.5 -6952.5 {}
L 4 1232.5 -6957.5 1247.5 -6952.5 {}
L 4 1232.5 -6957.5 1247.5 -6962.5 {}
L 4 1232.5 -6967.5 1247.5 -6962.5 {}
L 4 1232.5 -6967.5 1247.5 -6972.5 {}
L 4 1232.5 -6977.5 1247.5 -6972.5 {}
L 4 1232.5 -6977.5 1240 -6980 {}
L 4 1240 -6990 1240 -6980 {}
L 4 1242.5 -6982.5 1247.5 -6982.5 {}
L 4 1245 -6985 1245 -6980 {}
L 4 1530 -6940 1530 -6930 {}
L 4 1530 -6940 1537.5 -6942.5 {}
L 4 1522.5 -6947.5 1537.5 -6942.5 {}
L 4 1522.5 -6947.5 1537.5 -6952.5 {}
L 4 1522.5 -6957.5 1537.5 -6952.5 {}
L 4 1522.5 -6957.5 1537.5 -6962.5 {}
L 4 1522.5 -6967.5 1537.5 -6962.5 {}
L 4 1522.5 -6967.5 1537.5 -6972.5 {}
L 4 1522.5 -6977.5 1537.5 -6972.5 {}
L 4 1522.5 -6977.5 1530 -6980 {}
L 4 1530 -6990 1530 -6980 {}
L 4 1532.5 -6982.5 1537.5 -6982.5 {}
L 4 1535 -6985 1535 -6980 {}
L 4 1660 -6955 1660 -6930 {}
L 4 1660 -6990 1660 -6965 {}
L 4 1650 -6965 1670 -6965 {}
L 4 1650 -6955 1670 -6955 {}
L 4 1662.5 -6982.5 1667.5 -6982.5 {}
L 4 1665 -6985 1665 -6980 {}
L 4 1860 -6940 1860 -6930 {}
L 4 1860 -6940 1867.5 -6942.5 {}
L 4 1852.5 -6947.5 1867.5 -6942.5 {}
L 4 1852.5 -6947.5 1867.5 -6952.5 {}
L 4 1852.5 -6957.5 1867.5 -6952.5 {}
L 4 1852.5 -6957.5 1867.5 -6962.5 {}
L 4 1852.5 -6967.5 1867.5 -6962.5 {}
L 4 1852.5 -6967.5 1867.5 -6972.5 {}
L 4 1852.5 -6977.5 1867.5 -6972.5 {}
L 4 1852.5 -6977.5 1860 -6980 {}
L 4 1860 -6990 1860 -6980 {}
L 4 1862.5 -6982.5 1867.5 -6982.5 {}
L 4 1865 -6985 1865 -6980 {}
L 4 1990 -6955 1990 -6930 {}
L 4 1990 -6990 1990 -6965 {}
L 4 1980 -6965 2000 -6965 {}
L 4 1980 -6955 2000 -6955 {}
L 4 1992.5 -6982.5 1997.5 -6982.5 {}
L 4 1995 -6985 1995 -6980 {}
L 4 2400 -6940 2400 -6930 {}
L 4 2400 -6940 2407.5 -6942.5 {}
L 4 2392.5 -6947.5 2407.5 -6942.5 {}
L 4 2392.5 -6947.5 2407.5 -6952.5 {}
L 4 2392.5 -6957.5 2407.5 -6952.5 {}
L 4 2392.5 -6957.5 2407.5 -6962.5 {}
L 4 2392.5 -6967.5 2407.5 -6962.5 {}
L 4 2392.5 -6967.5 2407.5 -6972.5 {}
L 4 2392.5 -6977.5 2407.5 -6972.5 {}
L 4 2392.5 -6977.5 2400 -6980 {}
L 4 2400 -6990 2400 -6980 {}
L 4 2402.5 -6982.5 2407.5 -6982.5 {}
L 4 2405 -6985 2405 -6980 {}
L 4 2530 -6955 2530 -6930 {}
L 4 2530 -6990 2530 -6965 {}
L 4 2520 -6965 2540 -6965 {}
L 4 2520 -6955 2540 -6955 {}
L 4 2532.5 -6982.5 2537.5 -6982.5 {}
L 4 2535 -6985 2535 -6980 {}
L 4 2110 -6940 2110 -6930 {}
L 4 2110 -6940 2117.5 -6942.5 {}
L 4 2102.5 -6947.5 2117.5 -6942.5 {}
L 4 2102.5 -6947.5 2117.5 -6952.5 {}
L 4 2102.5 -6957.5 2117.5 -6952.5 {}
L 4 2102.5 -6957.5 2117.5 -6962.5 {}
L 4 2102.5 -6967.5 2117.5 -6962.5 {}
L 4 2102.5 -6967.5 2117.5 -6972.5 {}
L 4 2102.5 -6977.5 2117.5 -6972.5 {}
L 4 2102.5 -6977.5 2110 -6980 {}
L 4 2110 -6990 2110 -6980 {}
L 4 2112.5 -6982.5 2117.5 -6982.5 {}
L 4 2115 -6985 2115 -6980 {}
L 4 2240 -6955 2240 -6930 {}
L 4 2240 -6990 2240 -6965 {}
L 4 2230 -6965 2250 -6965 {}
L 4 2230 -6955 2250 -6955 {}
L 4 2242.5 -6982.5 2247.5 -6982.5 {}
L 4 2245 -6985 2245 -6980 {}
L 4 2380 -3550 2380 -3540 {}
L 4 2380 -3550 2387.5 -3552.5 {}
L 4 2372.5 -3557.5 2387.5 -3552.5 {}
L 4 2372.5 -3557.5 2387.5 -3562.5 {}
L 4 2372.5 -3567.5 2387.5 -3562.5 {}
L 4 2372.5 -3567.5 2387.5 -3572.5 {}
L 4 2372.5 -3577.5 2387.5 -3572.5 {}
L 4 2372.5 -3577.5 2387.5 -3582.5 {}
L 4 2372.5 -3587.5 2387.5 -3582.5 {}
L 4 2372.5 -3587.5 2380 -3590 {}
L 4 2380 -3600 2380 -3590 {}
L 4 2382.5 -3592.5 2387.5 -3592.5 {}
L 4 2385 -3595 2385 -3590 {}
L 5 1105 -8220 1110 -8220 {}
L 5 1410 -8250 1418.75 -8250 {}
L 5 1645 -8220 1650 -8220 {}
L 5 1950 -8250 1958.75 -8250 {}
L 5 575 -8220 580 -8220 {}
L 5 880 -8250 888.75 -8250 {}
L 5 575 -7760 580 -7760 {}
L 5 880 -7790 888.75 -7790 {}
L 5 1115 -7760 1120 -7760 {}
L 5 1420 -7790 1428.75 -7790 {}
L 5 575 -6140 580 -6140 {}
L 5 880 -6170 888.75 -6170 {}
L 5 1115 -6140 1120 -6140 {}
L 5 1420 -6170 1428.75 -6170 {}
L 5 575 -5650 580 -5650 {}
L 5 880 -5680 888.75 -5680 {}
L 5 1115 -5650 1120 -5650 {}
L 5 1420 -5680 1428.75 -5680 {}
L 5 575 -5160 580 -5160 {}
L 5 1765 -5160 1770 -5160 {}
L 5 1115 -5160 1120 -5160 {}
L 5 1105 -7390 1110 -7390 {}
L 5 1410 -7420 1418.75 -7420 {}
L 5 575 -7390 580 -7390 {}
L 5 880 -7420 888.75 -7420 {}
L 5 1605 -7390 1610 -7390 {}
L 5 1910 -7420 1918.75 -7420 {}
L 5 1645 -8690 1650 -8690 {}
L 5 1950 -8720 1958.75 -8720 {}
L 5 575 -8690 580 -8690 {}
L 5 880 -8720 888.75 -8720 {}
L 5 2105 -8690 2110 -8690 {}
L 5 2410 -8720 2418.75 -8720 {}
L 5 595 -4720 600 -4720 {}
L 5 900 -4750 908.75 -4750 {}
L 5 1135 -4720 1140 -4720 {}
L 5 1440 -4750 1448.75 -4750 {}
L 5 1695 -4720 1700 -4720 {}
L 5 2000 -4750 2008.75 -4750 {}
L 5 2265 -4720 2270 -4720 {}
L 5 2570 -4750 2578.75 -4750 {}
L 5 595 -6550 600 -6550 {}
L 5 900 -6580 908.75 -6580 {}
L 5 1135 -6550 1140 -6550 {}
L 5 1440 -6580 1448.75 -6580 {}
L 5 2265 -6550 2270 -6550 {}
L 5 2570 -6580 2578.75 -6580 {}
L 5 595 -4340 600 -4340 {}
L 5 900 -4370 908.75 -4370 {}
L 5 1135 -3960 1140 -3960 {}
L 5 1440 -3990 1448.75 -3990 {}
L 5 2235 -3960 2240 -3960 {}
L 5 2540 -3990 2548.75 -3990 {}
L 5 1675 -3960 1680 -3960 {}
L 5 1980 -3990 1988.75 -3990 {}
L 5 1105 -8690 1110 -8690 {}
L 5 1410 -8720 1418.75 -8720 {}
L 5 655 410 660 410 {}
L 5 960 380 968.75 380 {}
L 5 1305 410 1310 410 {}
L 5 1610 380 1618.75 380 {}
L 5 1135 -4340 1140 -4340 {}
L 5 1440 -4370 1448.75 -4370 {}
L 5 1695 -4340 1700 -4340 {}
L 5 2000 -4370 2008.75 -4370 {}
L 5 2265 -4340 2270 -4340 {}
L 5 2570 -4370 2578.75 -4370 {}
L 5 1865 410 1870 410 {}
L 5 2170 380 2178.75 380 {}
L 5 595 -3960 600 -3960 {}
L 5 900 -3990 908.75 -3990 {}
L 6 1110 -8220 1230 -8220 {}
L 6 1030 -8370 1270 -8370 {}
L 6 1270 -8250 1410 -8250 {}
L 6 1030 -8130 1030 -8110 {}
L 6 1030 -8370 1030 -8190 {}
L 6 1030 -8110 1270 -8110 {}
L 6 1650 -8220 1770 -8220 {}
L 6 1570 -8370 1810 -8370 {}
L 6 1810 -8250 1950 -8250 {}
L 6 1570 -8130 1570 -8110 {}
L 6 1570 -8370 1570 -8190 {}
L 6 1570 -8110 1810 -8110 {}
L 6 580 -8220 700 -8220 {}
L 6 500 -8370 740 -8370 {}
L 6 740 -8250 880 -8250 {}
L 6 500 -8130 500 -8110 {}
L 6 500 -8370 500 -8190 {}
L 6 500 -8110 740 -8110 {}
L 6 580 -7760 700 -7760 {}
L 6 740 -7820 740 -7790 {}
L 6 740 -7910 740 -7880 {}
L 6 500 -7910 740 -7910 {}
L 6 740 -7790 880 -7790 {}
L 6 830 -7730 830 -7650 {}
L 6 500 -7670 500 -7650 {}
L 6 500 -7910 500 -7730 {}
L 6 740 -7760 740 -7650 {}
L 6 740 -7650 830 -7650 {}
L 6 500 -7650 740 -7650 {}
L 6 1120 -7760 1240 -7760 {}
L 6 1280 -7820 1280 -7790 {}
L 6 1280 -7910 1280 -7880 {}
L 6 1040 -7910 1280 -7910 {}
L 6 1280 -7790 1420 -7790 {}
L 6 1370 -7730 1370 -7650 {}
L 6 1040 -7670 1040 -7650 {}
L 6 1040 -7910 1040 -7730 {}
L 6 1280 -7760 1280 -7650 {}
L 6 1280 -7650 1370 -7650 {}
L 6 1040 -7650 1280 -7650 {}
L 6 580 -6140 700 -6140 {}
L 6 740 -6200 740 -6170 {}
L 6 740 -6290 740 -6260 {}
L 6 500 -6290 740 -6290 {}
L 6 740 -6170 880 -6170 {}
L 6 830 -6110 830 -6030 {}
L 6 500 -6050 500 -6030 {}
L 6 500 -6290 500 -6110 {}
L 6 740 -6140 740 -6030 {}
L 6 740 -6030 830 -6030 {}
L 6 500 -6030 740 -6030 {}
L 6 1120 -6140 1240 -6140 {}
L 6 1280 -6200 1280 -6170 {}
L 6 1280 -6290 1280 -6260 {}
L 6 1040 -6290 1280 -6290 {}
L 6 1280 -6170 1420 -6170 {}
L 6 1370 -6110 1370 -6030 {}
L 6 1040 -6050 1040 -6030 {}
L 6 1040 -6290 1040 -6110 {}
L 6 1280 -6140 1280 -6030 {}
L 6 1280 -6030 1370 -6030 {}
L 6 1040 -6030 1280 -6030 {}
L 6 580 -5650 700 -5650 {}
L 6 740 -5710 740 -5680 {}
L 6 740 -5800 740 -5770 {}
L 6 500 -5800 740 -5800 {}
L 6 740 -5680 880 -5680 {}
L 6 830 -5620 830 -5540 {}
L 6 500 -5560 500 -5540 {}
L 6 500 -5800 500 -5620 {}
L 6 740 -5650 740 -5540 {}
L 6 740 -5540 830 -5540 {}
L 6 500 -5540 740 -5540 {}
L 6 1120 -5650 1240 -5650 {}
L 6 1040 -5800 1280 -5800 {}
L 6 1280 -5680 1420 -5680 {}
L 6 1370 -5620 1370 -5540 {}
L 6 1040 -5560 1040 -5540 {}
L 6 1040 -5800 1040 -5620 {}
L 6 1280 -5650 1280 -5540 {}
L 6 1280 -5540 1370 -5540 {}
L 6 1040 -5540 1280 -5540 {}
L 6 580 -5160 700 -5160 {}
L 6 500 -5310 740 -5310 {}
L 6 500 -5070 500 -5050 {}
L 6 500 -5310 500 -5130 {}
L 6 500 -5050 740 -5050 {}
L 6 1690 -5070 1690 -5050 {}
L 6 1690 -5310 1690 -5130 {}
L 6 1120 -5160 1240 -5160 {}
L 6 1040 -5070 1040 -5050 {}
L 6 1040 -5310 1040 -5130 {}
L 6 1110 -7390 1230 -7390 {}
L 6 1030 -7540 1270 -7540 {}
L 6 1270 -7420 1410 -7420 {}
L 6 1030 -7300 1030 -7280 {}
L 6 1030 -7540 1030 -7360 {}
L 6 1030 -7280 1270 -7280 {}
L 6 580 -7390 700 -7390 {}
L 6 500 -7540 740 -7540 {}
L 6 740 -7420 880 -7420 {}
L 6 500 -7300 500 -7280 {}
L 6 500 -7540 500 -7360 {}
L 6 500 -7280 740 -7280 {}
L 6 1610 -7390 1730 -7390 {}
L 6 1770 -7450 1770 -7420 {}
L 6 1770 -7540 1770 -7510 {}
L 6 1530 -7540 1770 -7540 {}
L 6 1770 -7420 1910 -7420 {}
L 6 1860 -7360 1860 -7280 {}
L 6 1530 -7300 1530 -7280 {}
L 6 1530 -7540 1530 -7360 {}
L 6 1770 -7390 1770 -7280 {}
L 6 1770 -7280 1860 -7280 {}
L 6 1530 -7280 1770 -7280 {}
L 6 1650 -8690 1770 -8690 {}
L 6 1570 -8840 1810 -8840 {}
L 6 1810 -8720 1950 -8720 {}
L 6 1570 -8580 1810 -8580 {}
L 6 580 -8690 700 -8690 {}
L 6 500 -8840 740 -8840 {}
L 6 740 -8720 880 -8720 {}
L 6 500 -8600 500 -8580 {}
L 6 500 -8840 500 -8660 {}
L 6 500 -8580 740 -8580 {}
L 6 2110 -8690 2230 -8690 {}
L 6 2030 -8840 2270 -8840 {}
L 6 2270 -8720 2410 -8720 {}
L 6 2030 -8580 2270 -8580 {}
L 6 2360 -8660 2360 -8580 {}
L 6 600 -4720 720 -4720 {}
L 6 760 -4780 760 -4750 {}
L 6 760 -4870 760 -4840 {}
L 6 520 -4870 760 -4870 {}
L 6 760 -4750 900 -4750 {}
L 6 850 -4690 850 -4610 {}
L 6 520 -4630 520 -4610 {}
L 6 520 -4870 520 -4690 {}
L 6 760 -4720 760 -4610 {}
L 6 760 -4610 850 -4610 {}
L 6 520 -4610 760 -4610 {}
L 6 1140 -4720 1260 -4720 {}
L 6 1300 -4780 1300 -4750 {}
L 6 1300 -4870 1300 -4840 {}
L 6 1060 -4870 1300 -4870 {}
L 6 1300 -4750 1440 -4750 {}
L 6 1390 -4690 1390 -4610 {}
L 6 1060 -4630 1060 -4610 {}
L 6 1060 -4870 1060 -4690 {}
L 6 1300 -4720 1300 -4610 {}
L 6 1300 -4610 1390 -4610 {}
L 6 1060 -4610 1300 -4610 {}
L 6 1700 -4720 1820 -4720 {}
L 6 1860 -4780 1860 -4750 {}
L 6 1860 -4870 1860 -4840 {}
L 6 1620 -4870 1860 -4870 {}
L 6 1860 -4750 2000 -4750 {}
L 6 1950 -4690 1950 -4610 {}
L 6 1620 -4630 1620 -4610 {}
L 6 1620 -4870 1620 -4690 {}
L 6 1860 -4720 1860 -4610 {}
L 6 1860 -4610 1950 -4610 {}
L 6 1620 -4610 1860 -4610 {}
L 6 2270 -4720 2390 -4720 {}
L 6 2430 -4780 2430 -4750 {}
L 6 2430 -4870 2430 -4840 {}
L 6 2190 -4870 2430 -4870 {}
L 6 2430 -4750 2570 -4750 {}
L 6 2520 -4690 2520 -4610 {}
L 6 2190 -4630 2190 -4610 {}
L 6 2190 -4870 2190 -4690 {}
L 6 2430 -4720 2430 -4610 {}
L 6 2430 -4610 2520 -4610 {}
L 6 2190 -4610 2430 -4610 {}
L 6 600 -6550 720 -6550 {}
L 6 760 -6610 760 -6580 {}
L 6 760 -6700 760 -6670 {}
L 6 760 -6580 900 -6580 {}
L 6 850 -6520 850 -6440 {}
L 6 520 -6460 520 -6440 {}
L 6 520 -6700 520 -6520 {}
L 6 760 -6550 760 -6440 {}
L 6 760 -6440 850 -6440 {}
L 6 520 -6440 760 -6440 {}
L 6 1140 -6550 1260 -6550 {}
L 6 1300 -6610 1300 -6580 {}
L 6 1300 -6700 1300 -6670 {}
L 6 1300 -6580 1440 -6580 {}
L 6 1390 -6520 1390 -6440 {}
L 6 1060 -6460 1060 -6440 {}
L 6 1060 -6700 1060 -6520 {}
L 6 1300 -6550 1300 -6440 {}
L 6 1300 -6440 1390 -6440 {}
L 6 1060 -6440 1300 -6440 {}
L 6 2270 -6550 2390 -6550 {}
L 6 2430 -6610 2430 -6580 {}
L 6 2430 -6700 2430 -6670 {}
L 6 2430 -6580 2570 -6580 {}
L 6 2520 -6520 2520 -6440 {}
L 6 2190 -6460 2190 -6440 {}
L 6 2190 -6700 2190 -6520 {}
L 6 2430 -6550 2430 -6440 {}
L 6 2430 -6440 2520 -6440 {}
L 6 2190 -6440 2430 -6440 {}
L 6 600 -4340 720 -4340 {}
L 6 760 -4400 760 -4370 {}
L 6 760 -4490 760 -4460 {}
L 6 760 -4370 900 -4370 {}
L 6 520 -4250 520 -4230 {}
L 6 760 -4340 760 -4230 {}
L 6 760 -4230 850 -4230 {}
L 6 520 -4230 760 -4230 {}
L 6 1140 -3960 1260 -3960 {}
L 6 1300 -3990 1440 -3990 {}
L 6 1390 -3930 1390 -3850 {}
L 6 1060 -3870 1060 -3850 {}
L 6 1300 -3960 1300 -3850 {}
L 6 1300 -3850 1390 -3850 {}
L 6 1060 -3850 1300 -3850 {}
L 6 2240 -3960 2360 -3960 {}
L 6 2400 -3990 2540 -3990 {}
L 6 2490 -3930 2490 -3850 {}
L 6 2160 -3870 2160 -3850 {}
L 6 2400 -3960 2400 -3850 {}
L 6 2400 -3850 2490 -3850 {}
L 6 2160 -3850 2400 -3850 {}
L 6 1680 -3960 1800 -3960 {}
L 6 1840 -3990 1980 -3990 {}
L 6 1930 -3930 1930 -3850 {}
L 6 1600 -3870 1600 -3850 {}
L 6 1840 -3960 1840 -3850 {}
L 6 1840 -3850 1930 -3850 {}
L 6 1600 -3850 1840 -3850 {}
L 6 690 -2190 690 -2010 {}
L 6 1230 -2190 1230 -2010 {}
L 6 1880 -2190 1880 -2130 {}
L 6 1880 -2070 1880 -2010 {}
L 6 1110 -8690 1230 -8690 {}
L 6 1030 -8840 1270 -8840 {}
L 6 1270 -8720 1410 -8720 {}
L 6 1030 -8580 1270 -8580 {}
L 6 1030 -8600 1030 -8580 {}
L 6 1030 -8840 1030 -8660 {}
L 6 660 410 780 410 {}
L 6 820 350 820 380 {}
L 6 820 260 820 290 {}
L 6 580 260 820 260 {}
L 6 820 380 960 380 {}
L 6 910 440 910 520 {}
L 6 580 500 580 520 {}
L 6 580 260 580 440 {}
L 6 820 410 820 520 {}
L 6 820 520 910 520 {}
L 6 580 520 820 520 {}
L 6 1310 410 1430 410 {}
L 6 1470 350 1470 380 {}
L 6 1470 260 1470 290 {}
L 6 1230 260 1470 260 {}
L 6 1230 260 1230 440 {}
L 6 1140 -4340 1260 -4340 {}
L 6 1300 -4400 1300 -4370 {}
L 6 1300 -4490 1300 -4460 {}
L 6 1300 -4370 1440 -4370 {}
L 6 1060 -4250 1060 -4230 {}
L 6 1300 -4340 1300 -4230 {}
L 6 1300 -4230 1390 -4230 {}
L 6 1060 -4230 1300 -4230 {}
L 6 1700 -4340 1820 -4340 {}
L 6 1860 -4400 1860 -4370 {}
L 6 1860 -4490 1860 -4460 {}
L 6 1860 -4370 2000 -4370 {}
L 6 1620 -4250 1620 -4230 {}
L 6 1860 -4340 1860 -4230 {}
L 6 1860 -4230 1950 -4230 {}
L 6 1620 -4230 1860 -4230 {}
L 6 2270 -4340 2390 -4340 {}
L 6 2430 -4400 2430 -4370 {}
L 6 2430 -4490 2430 -4460 {}
L 6 2430 -4370 2570 -4370 {}
L 6 2190 -4250 2190 -4230 {}
L 6 2430 -4340 2430 -4230 {}
L 6 2430 -4230 2520 -4230 {}
L 6 2190 -4230 2430 -4230 {}
L 6 1870 410 1990 410 {}
L 6 2030 350 2030 380 {}
L 6 2030 260 2030 290 {}
L 6 1790 260 2030 260 {}
L 6 1790 260 1790 440 {}
L 6 600 -3960 720 -3960 {}
L 6 760 -3990 900 -3990 {}
L 6 850 -3930 850 -3850 {}
L 6 520 -3870 520 -3850 {}
L 6 760 -3960 760 -3850 {}
L 6 760 -3850 850 -3850 {}
L 6 520 -3850 760 -3850 {}
L 9 0 -4970 2670 -4970 {dash=4}
L 9 0 -5500 2670 -5500 {dash=4}
L 9 0 -5980 2670 -5980 {dash=4}
L 9 0 -7170 2670 -7170 {dash=4}
L 9 0 -8000 2670 -8000 {dash=4}
L 9 0 -7610 2670 -7610 {dash=4}
L 9 0 -8450 2670 -8450 {dash=4}
L 9 0 -3060 2670 -3060 {dash=4}
L 9 0 -3440 2670 -3440 {dash=4}
L 9 0 -3790 2670 -3790 {dash=4}
L 9 0 -4200 2670 -4200 {dash=4}
L 9 0 -4570 2670 -4570 {dash=4}
L 9 0 -2640 2670 -2640 {dash=4}
L 9 0 -2260 2670 -2260 {dash=4}
L 9 0 -230 2670 -230 {dash=4}
L 9 0 -1940 2670 -1940 {dash=4}
L 9 0 -1000 2670 -1000 {dash=4}
L 9 0 -630 2670 -630 {dash=4}
L 9 0 170 2670 170 {dash=4}
L 9 0 600 2670 600 {dash=4}
L 9 0 -1710 2670 -1710 {dash=4}
L 9 0 -1340 2670 -1340 {dash=4}
L 9 0 -6390 2670 -6390 {dash=4}
L 9 0 -6820 2670 -6820 {dash=4}
B 1 1790 -6610 1820 -6460 {}
B 2 660 -8390 860 -8070 {}
B 2 1267.5 -8252.5 1272.5 -8247.5 {name=d dir=inout}
B 2 1227.5 -8222.5 1232.5 -8217.5 {name=g dir=in}
B 2 1267.5 -8192.5 1272.5 -8187.5 {name=s dir=inout}
B 2 1267.5 -8222.5 1272.5 -8217.5 {name=b dir=in}
B 2 1267.5 -8342.5 1272.5 -8337.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -8282.5 1272.5 -8277.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -8252.5 1362.5 -8247.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -8192.5 1362.5 -8187.5 {name=m dir=inout pinnumber=2}
B 2 2047.5 -8262.5 2052.5 -8257.5 {name=d dir=inout}
B 2 2007.5 -8232.5 2012.5 -8227.5 {name=g dir=in}
B 2 2047.5 -8202.5 2052.5 -8197.5 {name=s dir=inout}
B 2 2047.5 -8232.5 2052.5 -8227.5 {name=b dir=in}
B 2 2047.5 -8352.5 2052.5 -8347.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2047.5 -8292.5 2052.5 -8287.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2137.5 -8262.5 2142.5 -8257.5 {name=p dir=inout pinnumber=1}
B 2 2137.5 -8202.5 2142.5 -8197.5 {name=m dir=inout pinnumber=2}
B 2 1357.5 -7882.5 1362.5 -7877.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -7822.5 1362.5 -7817.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -6262.5 1362.5 -6257.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -6202.5 1362.5 -6197.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -5772.5 1362.5 -5767.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -5712.5 1362.5 -5707.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 660 -5340 900 -5020 {}
B 2 737.5 -8252.5 742.5 -8247.5 {name=d dir=inout}
B 2 737.5 -8192.5 742.5 -8187.5 {name=s dir=inout}
B 2 737.5 -8222.5 742.5 -8217.5 {name=b dir=in}
B 2 737.5 -8342.5 742.5 -8337.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -8282.5 742.5 -8277.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -8252.5 832.5 -8247.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -8192.5 832.5 -8187.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -5192.5 742.5 -5187.5 {name=d dir=inout}
B 2 737.5 -5132.5 742.5 -5127.5 {name=s dir=inout}
B 2 737.5 -5162.5 742.5 -5157.5 {name=b dir=in}
B 2 737.5 -5282.5 742.5 -5277.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -5222.5 742.5 -5217.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -5192.5 832.5 -5187.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -5132.5 832.5 -5127.5 {name=m dir=inout pinnumber=2}
B 2 878.75 -5191.25 881.25 -5188.75 {name=p dir=in}
B 2 1277.5 -5192.5 1282.5 -5187.5 {name=d dir=inout}
B 2 1237.5 -5162.5 1242.5 -5157.5 {name=g dir=in}
B 2 1277.5 -5132.5 1282.5 -5127.5 {name=s dir=inout}
B 2 1277.5 -5162.5 1282.5 -5157.5 {name=b dir=in}
B 2 1277.5 -5282.5 1282.5 -5277.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1277.5 -5222.5 1282.5 -5217.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1367.5 -5192.5 1372.5 -5187.5 {name=p dir=inout pinnumber=1}
B 2 1367.5 -5132.5 1372.5 -5127.5 {name=m dir=inout pinnumber=2}
B 2 1418.75 -5191.25 1421.25 -5188.75 {name=p dir=in}
B 2 2117.5 -5192.5 2122.5 -5187.5 {name=d dir=inout}
B 2 2077.5 -5162.5 2082.5 -5157.5 {name=g dir=in}
B 2 2117.5 -5132.5 2122.5 -5127.5 {name=s dir=inout}
B 2 2117.5 -5162.5 2122.5 -5157.5 {name=b dir=in}
B 2 2117.5 -5282.5 2122.5 -5277.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2117.5 -5222.5 2122.5 -5217.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2207.5 -5192.5 2212.5 -5187.5 {name=p dir=inout pinnumber=1}
B 2 2207.5 -5132.5 2212.5 -5127.5 {name=m dir=inout pinnumber=2}
B 2 2258.75 -5191.25 2261.25 -5188.75 {name=p dir=in}
B 2 660 -7560 860 -7240 {}
B 2 1267.5 -7422.5 1272.5 -7417.5 {name=d dir=inout}
B 2 1227.5 -7392.5 1232.5 -7387.5 {name=g dir=in}
B 2 1267.5 -7362.5 1272.5 -7357.5 {name=s dir=inout}
B 2 1267.5 -7392.5 1272.5 -7387.5 {name=b dir=in}
B 2 1267.5 -7512.5 1272.5 -7507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -7452.5 1272.5 -7447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -7422.5 1362.5 -7417.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -7362.5 1362.5 -7357.5 {name=m dir=inout pinnumber=2}
B 2 2047.5 -7432.5 2052.5 -7427.5 {name=d dir=inout}
B 2 2007.5 -7402.5 2012.5 -7397.5 {name=g dir=in}
B 2 2047.5 -7372.5 2052.5 -7367.5 {name=s dir=inout}
B 2 2047.5 -7402.5 2052.5 -7397.5 {name=b dir=in}
B 2 2047.5 -7522.5 2052.5 -7517.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2047.5 -7462.5 2052.5 -7457.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2137.5 -7432.5 2142.5 -7427.5 {name=p dir=inout pinnumber=1}
B 2 2137.5 -7372.5 2142.5 -7367.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -7422.5 742.5 -7417.5 {name=d dir=inout}
B 2 737.5 -7362.5 742.5 -7357.5 {name=s dir=inout}
B 2 737.5 -7392.5 742.5 -7387.5 {name=b dir=in}
B 2 737.5 -7512.5 742.5 -7507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -7452.5 742.5 -7447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -7422.5 832.5 -7417.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -7362.5 832.5 -7357.5 {name=m dir=inout pinnumber=2}
B 2 660 -8860 860 -8540 {}
B 2 1807.5 -8722.5 1812.5 -8717.5 {name=d dir=inout}
B 2 1767.5 -8692.5 1772.5 -8687.5 {name=g dir=in}
B 2 1807.5 -8662.5 1812.5 -8657.5 {name=s dir=inout}
B 2 1807.5 -8692.5 1812.5 -8687.5 {name=b dir=in}
B 2 1807.5 -8812.5 1812.5 -8807.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1807.5 -8752.5 1812.5 -8747.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -8722.5 1902.5 -8717.5 {name=p dir=inout pinnumber=1}
B 2 1897.5 -8662.5 1902.5 -8657.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -8722.5 742.5 -8717.5 {name=d dir=inout}
B 2 737.5 -8662.5 742.5 -8657.5 {name=s dir=inout}
B 2 737.5 -8692.5 742.5 -8687.5 {name=b dir=in}
B 2 737.5 -8812.5 742.5 -8807.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -8752.5 742.5 -8747.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -8722.5 832.5 -8717.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -8662.5 832.5 -8657.5 {name=m dir=inout pinnumber=2}
B 2 1530 -8850 1610 -8570 {}
B 2 1567.5 -8662.5 1572.5 -8657.5 {name=p dir=inout}
B 2 1567.5 -8602.5 1572.5 -8597.5 {name=m dir=inout}
B 2 2267.5 -8722.5 2272.5 -8717.5 {name=d dir=inout}
B 2 2227.5 -8692.5 2232.5 -8687.5 {name=g dir=in}
B 2 2267.5 -8662.5 2272.5 -8657.5 {name=s dir=inout}
B 2 2267.5 -8692.5 2272.5 -8687.5 {name=b dir=in}
B 2 2267.5 -8812.5 2272.5 -8807.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2267.5 -8752.5 2272.5 -8747.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2027.5 -8662.5 2032.5 -8657.5 {name=p dir=inout}
B 2 2027.5 -8602.5 2032.5 -8597.5 {name=m dir=inout}
B 2 2320 -8740 2390 -8560 {}
B 2 1670 -6640 1820 -6610 {}
B 2 1000 -4150 1340 -4000 {}
B 2 1297.5 -4082.5 1302.5 -4077.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1297.5 -4022.5 1302.5 -4017.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1167.5 -4112.5 1172.5 -4107.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 2397.5 -4112.5 2402.5 -4107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2397.5 -4052.5 2402.5 -4047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2267.5 -4142.5 2272.5 -4137.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1837.5 -4082.5 1842.5 -4077.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1837.5 -4022.5 1842.5 -4017.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1707.5 -4112.5 1712.5 -4107.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1357.5 -3222.5 1362.5 -3217.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -3162.5 1362.5 -3157.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -3542.5 1362.5 -3537.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -3602.5 1362.5 -3597.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -3542.5 1362.5 -3537.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -3602.5 1362.5 -3597.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1777.5 -3542.5 1782.5 -3537.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1777.5 -3602.5 1782.5 -3597.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1210 -2550 1500 -2480 {}
B 2 1210 -470 1500 -390 {}
B 2 1247.5 -462.5 1252.5 -457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1247.5 -402.5 1252.5 -397.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -462.5 1362.5 -457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -402.5 1362.5 -397.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1467.5 -462.5 1472.5 -457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1467.5 -402.5 1472.5 -397.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1787.5 -512.5 1792.5 -507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1787.5 -452.5 1792.5 -447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -512.5 1902.5 -507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1897.5 -452.5 1902.5 -447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2007.5 -512.5 2012.5 -507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2007.5 -452.5 2012.5 -447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 647.5 -2132.5 652.5 -2127.5 {name=d dir=inout}
B 2 607.5 -2102.5 612.5 -2097.5 {name=g dir=in}
B 2 647.5 -2072.5 652.5 -2067.5 {name=s dir=inout}
B 2 647.5 -2102.5 652.5 -2097.5 {name=b dir=in}
B 2 1227.5 -2132.5 1232.5 -2127.5 {name=d dir=inout}
B 2 1187.5 -2102.5 1192.5 -2097.5 {name=g dir=in}
B 2 1227.5 -2072.5 1232.5 -2067.5 {name=s dir=inout}
B 2 1227.5 -2102.5 1232.5 -2097.5 {name=b dir=in}
B 2 1267.5 -8722.5 1272.5 -8717.5 {name=d dir=inout}
B 2 1227.5 -8692.5 1232.5 -8687.5 {name=g dir=in}
B 2 1267.5 -8662.5 1272.5 -8657.5 {name=s dir=inout}
B 2 1267.5 -8692.5 1272.5 -8687.5 {name=b dir=in}
B 2 1267.5 -8812.5 1272.5 -8807.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -8752.5 1272.5 -8747.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -8722.5 1362.5 -8717.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -8662.5 1362.5 -8657.5 {name=m dir=inout pinnumber=2}
B 2 1210 -90 1500 -10 {}
B 2 1247.5 -82.5 1252.5 -77.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1247.5 -22.5 1252.5 -17.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -82.5 1362.5 -77.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -22.5 1362.5 -17.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1467.5 -82.5 1472.5 -77.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1467.5 -22.5 1472.5 -17.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1787.5 -132.5 1792.5 -127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1787.5 -72.5 1792.5 -67.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -132.5 1902.5 -127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1897.5 -72.5 1902.5 -67.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2007.5 -132.5 2012.5 -127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2007.5 -72.5 2012.5 -67.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 677.5 -902.5 682.5 -897.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 677.5 -842.5 682.5 -837.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 797.5 -902.5 802.5 -897.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1217.5 -902.5 1222.5 -897.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1217.5 -842.5 1222.5 -837.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1337.5 -902.5 1342.5 -897.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1337.5 -842.5 1342.5 -837.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1557.5 377.5 1562.5 382.5 {name=p dir=inout pinnumber=1}
B 2 1557.5 437.5 1562.5 442.5 {name=m dir=inout pinnumber=2}
B 2 2427.5 197.5 2432.5 202.5 {name=p dir=inout pinnumber=1}
B 2 2427.5 257.5 2432.5 262.5 {name=m dir=inout pinnumber=2}
B 2 757.5 -4082.5 762.5 -4077.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 757.5 -4022.5 762.5 -4017.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 627.5 -4112.5 632.5 -4107.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1027.5 -8192.5 1032.5 -8187.5 {name=p dir=inout}
B 5 1027.5 -8132.5 1032.5 -8127.5 {name=m dir=inout}
B 5 1108.75 -8221.25 1111.25 -8218.75 {name=p dir=out}
B 5 1137.5 -8112.5 1142.5 -8107.5 {name=p dir=inout goto=0}
B 5 1137.5 -8372.5 1142.5 -8367.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -8251.25 1411.25 -8248.75 {name=p dir=in}
B 5 1567.5 -8192.5 1572.5 -8187.5 {name=p dir=inout}
B 5 1567.5 -8132.5 1572.5 -8127.5 {name=m dir=inout}
B 5 1648.75 -8221.25 1651.25 -8218.75 {name=p dir=out}
B 5 1677.5 -8112.5 1682.5 -8107.5 {name=p dir=inout goto=0}
B 5 1677.5 -8372.5 1682.5 -8367.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1948.75 -8251.25 1951.25 -8248.75 {name=p dir=in}
B 5 697.5 -8222.5 702.5 -8217.5 {name=g dir=in}
B 5 497.5 -8192.5 502.5 -8187.5 {name=p dir=inout}
B 5 497.5 -8132.5 502.5 -8127.5 {name=m dir=inout}
B 5 578.75 -8221.25 581.25 -8218.75 {name=p dir=out}
B 5 607.5 -8112.5 612.5 -8107.5 {name=p dir=inout goto=0}
B 5 607.5 -8372.5 612.5 -8367.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -8251.25 881.25 -8248.75 {name=p dir=in}
B 5 737.5 -7792.5 742.5 -7787.5 {name=d dir=inout}
B 5 697.5 -7762.5 702.5 -7757.5 {name=g dir=in}
B 5 737.5 -7732.5 742.5 -7727.5 {name=s dir=inout}
B 5 737.5 -7762.5 742.5 -7757.5 {name=b dir=in}
B 5 737.5 -7882.5 742.5 -7877.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -7822.5 742.5 -7817.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -7792.5 832.5 -7787.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -7732.5 832.5 -7727.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -7732.5 502.5 -7727.5 {name=p dir=inout}
B 5 497.5 -7672.5 502.5 -7667.5 {name=m dir=inout}
B 5 578.75 -7761.25 581.25 -7758.75 {name=p dir=out}
B 5 607.5 -7652.5 612.5 -7647.5 {name=p dir=inout goto=0}
B 5 607.5 -7912.5 612.5 -7907.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -7791.25 881.25 -7788.75 {name=p dir=in}
B 5 1277.5 -7792.5 1282.5 -7787.5 {name=d dir=inout}
B 5 1237.5 -7762.5 1242.5 -7757.5 {name=g dir=in}
B 5 1277.5 -7732.5 1282.5 -7727.5 {name=s dir=inout}
B 5 1277.5 -7762.5 1282.5 -7757.5 {name=b dir=in}
B 5 1367.5 -7792.5 1372.5 -7787.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -7732.5 1372.5 -7727.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -7732.5 1042.5 -7727.5 {name=p dir=inout}
B 5 1037.5 -7672.5 1042.5 -7667.5 {name=m dir=inout}
B 5 1118.75 -7761.25 1121.25 -7758.75 {name=p dir=out}
B 5 1147.5 -7652.5 1152.5 -7647.5 {name=p dir=inout goto=0}
B 5 1147.5 -7912.5 1152.5 -7907.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -7791.25 1421.25 -7788.75 {name=p dir=in}
B 5 737.5 -6172.5 742.5 -6167.5 {name=d dir=inout}
B 5 697.5 -6142.5 702.5 -6137.5 {name=g dir=in}
B 5 737.5 -6112.5 742.5 -6107.5 {name=s dir=inout}
B 5 737.5 -6142.5 742.5 -6137.5 {name=b dir=in}
B 5 737.5 -6262.5 742.5 -6257.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -6202.5 742.5 -6197.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -6172.5 832.5 -6167.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -6112.5 832.5 -6107.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -6112.5 502.5 -6107.5 {name=p dir=inout}
B 5 497.5 -6052.5 502.5 -6047.5 {name=m dir=inout}
B 5 578.75 -6141.25 581.25 -6138.75 {name=p dir=out}
B 5 607.5 -6032.5 612.5 -6027.5 {name=p dir=inout goto=0}
B 5 607.5 -6292.5 612.5 -6287.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -6171.25 881.25 -6168.75 {name=p dir=in}
B 5 1277.5 -6172.5 1282.5 -6167.5 {name=d dir=inout}
B 5 1237.5 -6142.5 1242.5 -6137.5 {name=g dir=in}
B 5 1277.5 -6112.5 1282.5 -6107.5 {name=s dir=inout}
B 5 1277.5 -6142.5 1282.5 -6137.5 {name=b dir=in}
B 5 1367.5 -6172.5 1372.5 -6167.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -6112.5 1372.5 -6107.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -6112.5 1042.5 -6107.5 {name=p dir=inout}
B 5 1037.5 -6052.5 1042.5 -6047.5 {name=m dir=inout}
B 5 1118.75 -6141.25 1121.25 -6138.75 {name=p dir=out}
B 5 1147.5 -6032.5 1152.5 -6027.5 {name=p dir=inout goto=0}
B 5 1147.5 -6292.5 1152.5 -6287.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -6171.25 1421.25 -6168.75 {name=p dir=in}
B 5 737.5 -5682.5 742.5 -5677.5 {name=d dir=inout}
B 5 697.5 -5652.5 702.5 -5647.5 {name=g dir=in}
B 5 737.5 -5622.5 742.5 -5617.5 {name=s dir=inout}
B 5 737.5 -5652.5 742.5 -5647.5 {name=b dir=in}
B 5 737.5 -5772.5 742.5 -5767.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -5712.5 742.5 -5707.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -5682.5 832.5 -5677.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -5622.5 832.5 -5617.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -5622.5 502.5 -5617.5 {name=p dir=inout}
B 5 497.5 -5562.5 502.5 -5557.5 {name=m dir=inout}
B 5 578.75 -5651.25 581.25 -5648.75 {name=p dir=out}
B 5 607.5 -5542.5 612.5 -5537.5 {name=p dir=inout goto=0}
B 5 607.5 -5802.5 612.5 -5797.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -5681.25 881.25 -5678.75 {name=p dir=in}
B 5 1277.5 -5682.5 1282.5 -5677.5 {name=d dir=inout}
B 5 1237.5 -5652.5 1242.5 -5647.5 {name=g dir=in}
B 5 1277.5 -5622.5 1282.5 -5617.5 {name=s dir=inout}
B 5 1277.5 -5652.5 1282.5 -5647.5 {name=b dir=in}
B 5 1367.5 -5682.5 1372.5 -5677.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -5622.5 1372.5 -5617.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -5622.5 1042.5 -5617.5 {name=p dir=inout}
B 5 1037.5 -5562.5 1042.5 -5557.5 {name=m dir=inout}
B 5 1118.75 -5651.25 1121.25 -5648.75 {name=p dir=out}
B 5 1147.5 -5542.5 1152.5 -5537.5 {name=p dir=inout goto=0}
B 5 1147.5 -5802.5 1152.5 -5797.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -5681.25 1421.25 -5678.75 {name=p dir=in}
B 5 697.5 -5162.5 702.5 -5157.5 {name=g dir=in}
B 5 497.5 -5132.5 502.5 -5127.5 {name=p dir=inout}
B 5 497.5 -5072.5 502.5 -5067.5 {name=m dir=inout}
B 5 578.75 -5161.25 581.25 -5158.75 {name=p dir=out}
B 5 607.5 -5052.5 612.5 -5047.5 {name=p dir=inout goto=0}
B 5 607.5 -5312.5 612.5 -5307.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1687.5 -5132.5 1692.5 -5127.5 {name=p dir=inout}
B 5 1687.5 -5072.5 1692.5 -5067.5 {name=m dir=inout}
B 5 1768.75 -5161.25 1771.25 -5158.75 {name=p dir=out}
B 5 1797.5 -5052.5 1802.5 -5047.5 {name=p dir=inout goto=0}
B 5 1797.5 -5312.5 1802.5 -5307.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1037.5 -5132.5 1042.5 -5127.5 {name=p dir=inout}
B 5 1037.5 -5072.5 1042.5 -5067.5 {name=m dir=inout}
B 5 1118.75 -5161.25 1121.25 -5158.75 {name=p dir=out}
B 5 1147.5 -5052.5 1152.5 -5047.5 {name=p dir=inout goto=0}
B 5 1147.5 -5312.5 1152.5 -5307.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1027.5 -7362.5 1032.5 -7357.5 {name=p dir=inout}
B 5 1027.5 -7302.5 1032.5 -7297.5 {name=m dir=inout}
B 5 1108.75 -7391.25 1111.25 -7388.75 {name=p dir=out}
B 5 1137.5 -7282.5 1142.5 -7277.5 {name=p dir=inout goto=0}
B 5 1137.5 -7542.5 1142.5 -7537.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -7421.25 1411.25 -7418.75 {name=p dir=in}
B 5 697.5 -7392.5 702.5 -7387.5 {name=g dir=in}
B 5 497.5 -7362.5 502.5 -7357.5 {name=p dir=inout}
B 5 497.5 -7302.5 502.5 -7297.5 {name=m dir=inout}
B 5 578.75 -7391.25 581.25 -7388.75 {name=p dir=out}
B 5 607.5 -7282.5 612.5 -7277.5 {name=p dir=inout goto=0}
B 5 607.5 -7542.5 612.5 -7537.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -7421.25 881.25 -7418.75 {name=p dir=in}
B 5 1767.5 -7422.5 1772.5 -7417.5 {name=d dir=inout}
B 5 1727.5 -7392.5 1732.5 -7387.5 {name=g dir=in}
B 5 1767.5 -7362.5 1772.5 -7357.5 {name=s dir=inout}
B 5 1767.5 -7392.5 1772.5 -7387.5 {name=b dir=in}
B 5 1767.5 -7512.5 1772.5 -7507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1767.5 -7452.5 1772.5 -7447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1857.5 -7422.5 1862.5 -7417.5 {name=p dir=inout pinnumber=1}
B 5 1857.5 -7362.5 1862.5 -7357.5 {name=m dir=inout pinnumber=2}
B 5 1527.5 -7362.5 1532.5 -7357.5 {name=p dir=inout}
B 5 1527.5 -7302.5 1532.5 -7297.5 {name=m dir=inout}
B 5 1608.75 -7391.25 1611.25 -7388.75 {name=p dir=out}
B 5 1637.5 -7282.5 1642.5 -7277.5 {name=p dir=inout goto=0}
B 5 1637.5 -7542.5 1642.5 -7537.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1908.75 -7421.25 1911.25 -7418.75 {name=p dir=in}
B 5 1648.75 -8691.25 1651.25 -8688.75 {name=p dir=out}
B 5 1677.5 -8582.5 1682.5 -8577.5 {name=p dir=inout goto=0}
B 5 1677.5 -8842.5 1682.5 -8837.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1948.75 -8721.25 1951.25 -8718.75 {name=p dir=in}
B 5 697.5 -8692.5 702.5 -8687.5 {name=g dir=in}
B 5 497.5 -8662.5 502.5 -8657.5 {name=p dir=inout}
B 5 497.5 -8602.5 502.5 -8597.5 {name=m dir=inout}
B 5 578.75 -8691.25 581.25 -8688.75 {name=p dir=out}
B 5 607.5 -8582.5 612.5 -8577.5 {name=p dir=inout goto=0}
B 5 607.5 -8842.5 612.5 -8837.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -8721.25 881.25 -8718.75 {name=p dir=in}
B 5 2108.75 -8691.25 2111.25 -8688.75 {name=p dir=out}
B 5 2137.5 -8582.5 2142.5 -8577.5 {name=p dir=inout goto=0}
B 5 2137.5 -8842.5 2142.5 -8837.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2408.75 -8721.25 2411.25 -8718.75 {name=p dir=in}
B 5 2357.5 -8722.5 2362.5 -8717.5 {name=p dir=inout pinnumber=1}
B 5 2357.5 -8662.5 2362.5 -8657.5 {name=m dir=inout pinnumber=2}
B 5 757.5 -4752.5 762.5 -4747.5 {name=d dir=inout}
B 5 717.5 -4722.5 722.5 -4717.5 {name=g dir=in}
B 5 757.5 -4692.5 762.5 -4687.5 {name=s dir=inout}
B 5 757.5 -4722.5 762.5 -4717.5 {name=b dir=in}
B 5 757.5 -4842.5 762.5 -4837.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -4782.5 762.5 -4777.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 847.5 -4752.5 852.5 -4747.5 {name=p dir=inout pinnumber=1}
B 5 847.5 -4692.5 852.5 -4687.5 {name=m dir=inout pinnumber=2}
B 5 517.5 -4692.5 522.5 -4687.5 {name=p dir=inout}
B 5 517.5 -4632.5 522.5 -4627.5 {name=m dir=inout}
B 5 598.75 -4721.25 601.25 -4718.75 {name=p dir=out}
B 5 627.5 -4612.5 632.5 -4607.5 {name=p dir=inout goto=0}
B 5 627.5 -4872.5 632.5 -4867.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 898.75 -4751.25 901.25 -4748.75 {name=p dir=in}
B 5 1297.5 -4752.5 1302.5 -4747.5 {name=d dir=inout}
B 5 1257.5 -4722.5 1262.5 -4717.5 {name=g dir=in}
B 5 1297.5 -4692.5 1302.5 -4687.5 {name=s dir=inout}
B 5 1297.5 -4722.5 1302.5 -4717.5 {name=b dir=in}
B 5 1297.5 -4842.5 1302.5 -4837.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1297.5 -4782.5 1302.5 -4777.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1387.5 -4752.5 1392.5 -4747.5 {name=p dir=inout pinnumber=1}
B 5 1387.5 -4692.5 1392.5 -4687.5 {name=m dir=inout pinnumber=2}
B 5 1057.5 -4692.5 1062.5 -4687.5 {name=p dir=inout}
B 5 1057.5 -4632.5 1062.5 -4627.5 {name=m dir=inout}
B 5 1138.75 -4721.25 1141.25 -4718.75 {name=p dir=out}
B 5 1167.5 -4612.5 1172.5 -4607.5 {name=p dir=inout goto=0}
B 5 1167.5 -4872.5 1172.5 -4867.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1438.75 -4751.25 1441.25 -4748.75 {name=p dir=in}
B 5 1857.5 -4752.5 1862.5 -4747.5 {name=d dir=inout}
B 5 1817.5 -4722.5 1822.5 -4717.5 {name=g dir=in}
B 5 1857.5 -4692.5 1862.5 -4687.5 {name=s dir=inout}
B 5 1857.5 -4722.5 1862.5 -4717.5 {name=b dir=in}
B 5 1857.5 -4842.5 1862.5 -4837.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1857.5 -4782.5 1862.5 -4777.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1947.5 -4752.5 1952.5 -4747.5 {name=p dir=inout pinnumber=1}
B 5 1947.5 -4692.5 1952.5 -4687.5 {name=m dir=inout pinnumber=2}
B 5 1617.5 -4692.5 1622.5 -4687.5 {name=p dir=inout}
B 5 1617.5 -4632.5 1622.5 -4627.5 {name=m dir=inout}
B 5 1698.75 -4721.25 1701.25 -4718.75 {name=p dir=out}
B 5 1727.5 -4612.5 1732.5 -4607.5 {name=p dir=inout goto=0}
B 5 1727.5 -4872.5 1732.5 -4867.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1998.75 -4751.25 2001.25 -4748.75 {name=p dir=in}
B 5 2427.5 -4752.5 2432.5 -4747.5 {name=d dir=inout}
B 5 2387.5 -4722.5 2392.5 -4717.5 {name=g dir=in}
B 5 2427.5 -4692.5 2432.5 -4687.5 {name=s dir=inout}
B 5 2427.5 -4722.5 2432.5 -4717.5 {name=b dir=in}
B 5 2427.5 -4842.5 2432.5 -4837.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -4782.5 2432.5 -4777.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2517.5 -4752.5 2522.5 -4747.5 {name=p dir=inout pinnumber=1}
B 5 2517.5 -4692.5 2522.5 -4687.5 {name=m dir=inout pinnumber=2}
B 5 2187.5 -4692.5 2192.5 -4687.5 {name=p dir=inout}
B 5 2187.5 -4632.5 2192.5 -4627.5 {name=m dir=inout}
B 5 2268.75 -4721.25 2271.25 -4718.75 {name=p dir=out}
B 5 2297.5 -4612.5 2302.5 -4607.5 {name=p dir=inout goto=0}
B 5 2297.5 -4872.5 2302.5 -4867.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2568.75 -4751.25 2571.25 -4748.75 {name=p dir=in}
B 5 757.5 -6582.5 762.5 -6577.5 {name=d dir=inout}
B 5 717.5 -6552.5 722.5 -6547.5 {name=g dir=in}
B 5 757.5 -6522.5 762.5 -6517.5 {name=s dir=inout}
B 5 757.5 -6552.5 762.5 -6547.5 {name=b dir=in}
B 5 757.5 -6672.5 762.5 -6667.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -6612.5 762.5 -6607.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 847.5 -6582.5 852.5 -6577.5 {name=p dir=inout pinnumber=1}
B 5 847.5 -6522.5 852.5 -6517.5 {name=m dir=inout pinnumber=2}
B 5 517.5 -6522.5 522.5 -6517.5 {name=p dir=inout}
B 5 517.5 -6462.5 522.5 -6457.5 {name=m dir=inout}
B 5 598.75 -6551.25 601.25 -6548.75 {name=p dir=out}
B 5 627.5 -6442.5 632.5 -6437.5 {name=p dir=inout goto=0}
B 5 627.5 -6702.5 632.5 -6697.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 898.75 -6581.25 901.25 -6578.75 {name=p dir=in}
B 5 1297.5 -6582.5 1302.5 -6577.5 {name=d dir=inout}
B 5 1257.5 -6552.5 1262.5 -6547.5 {name=g dir=in}
B 5 1297.5 -6522.5 1302.5 -6517.5 {name=s dir=inout}
B 5 1297.5 -6552.5 1302.5 -6547.5 {name=b dir=in}
B 5 1297.5 -6672.5 1302.5 -6667.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1297.5 -6612.5 1302.5 -6607.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1387.5 -6582.5 1392.5 -6577.5 {name=p dir=inout pinnumber=1}
B 5 1387.5 -6522.5 1392.5 -6517.5 {name=m dir=inout pinnumber=2}
B 5 1057.5 -6522.5 1062.5 -6517.5 {name=p dir=inout}
B 5 1057.5 -6462.5 1062.5 -6457.5 {name=m dir=inout}
B 5 1138.75 -6551.25 1141.25 -6548.75 {name=p dir=out}
B 5 1167.5 -6442.5 1172.5 -6437.5 {name=p dir=inout goto=0}
B 5 1167.5 -6702.5 1172.5 -6697.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1438.75 -6581.25 1441.25 -6578.75 {name=p dir=in}
B 5 2427.5 -6582.5 2432.5 -6577.5 {name=d dir=inout}
B 5 2387.5 -6552.5 2392.5 -6547.5 {name=g dir=in}
B 5 2427.5 -6522.5 2432.5 -6517.5 {name=s dir=inout}
B 5 2427.5 -6552.5 2432.5 -6547.5 {name=b dir=in}
B 5 2427.5 -6672.5 2432.5 -6667.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -6612.5 2432.5 -6607.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2517.5 -6582.5 2522.5 -6577.5 {name=p dir=inout pinnumber=1}
B 5 2517.5 -6522.5 2522.5 -6517.5 {name=m dir=inout pinnumber=2}
B 5 2187.5 -6522.5 2192.5 -6517.5 {name=p dir=inout}
B 5 2187.5 -6462.5 2192.5 -6457.5 {name=m dir=inout}
B 5 2268.75 -6551.25 2271.25 -6548.75 {name=p dir=out}
B 5 2297.5 -6442.5 2302.5 -6437.5 {name=p dir=inout goto=0}
B 5 2297.5 -6702.5 2302.5 -6697.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2568.75 -6581.25 2571.25 -6578.75 {name=p dir=in}
B 5 757.5 -4372.5 762.5 -4367.5 {name=d dir=inout}
B 5 717.5 -4342.5 722.5 -4337.5 {name=g dir=in}
B 5 757.5 -4312.5 762.5 -4307.5 {name=s dir=inout}
B 5 757.5 -4342.5 762.5 -4337.5 {name=b dir=in}
B 5 757.5 -4462.5 762.5 -4457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -4402.5 762.5 -4397.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 847.5 -4372.5 852.5 -4367.5 {name=p dir=inout pinnumber=1}
B 5 847.5 -4312.5 852.5 -4307.5 {name=m dir=inout pinnumber=2}
B 5 517.5 -4312.5 522.5 -4307.5 {name=p dir=inout}
B 5 517.5 -4252.5 522.5 -4247.5 {name=m dir=inout}
B 5 598.75 -4341.25 601.25 -4338.75 {name=p dir=out}
B 5 627.5 -4232.5 632.5 -4227.5 {name=p dir=inout goto=0}
B 5 627.5 -4492.5 632.5 -4487.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 898.75 -4371.25 901.25 -4368.75 {name=p dir=in}
B 5 1297.5 -3992.5 1302.5 -3987.5 {name=d dir=inout}
B 5 1257.5 -3962.5 1262.5 -3957.5 {name=g dir=in}
B 5 1297.5 -3932.5 1302.5 -3927.5 {name=s dir=inout}
B 5 1297.5 -3962.5 1302.5 -3957.5 {name=b dir=in}
B 5 1387.5 -3992.5 1392.5 -3987.5 {name=p dir=inout pinnumber=1}
B 5 1387.5 -3932.5 1392.5 -3927.5 {name=m dir=inout pinnumber=2}
B 5 1057.5 -3932.5 1062.5 -3927.5 {name=p dir=inout}
B 5 1057.5 -3872.5 1062.5 -3867.5 {name=m dir=inout}
B 5 1138.75 -3961.25 1141.25 -3958.75 {name=p dir=out}
B 5 1167.5 -3852.5 1172.5 -3847.5 {name=p dir=inout goto=0}
B 5 1438.75 -3991.25 1441.25 -3988.75 {name=p dir=in}
B 5 2397.5 -3992.5 2402.5 -3987.5 {name=d dir=inout}
B 5 2357.5 -3962.5 2362.5 -3957.5 {name=g dir=in}
B 5 2397.5 -3932.5 2402.5 -3927.5 {name=s dir=inout}
B 5 2397.5 -3962.5 2402.5 -3957.5 {name=b dir=in}
B 5 2487.5 -3992.5 2492.5 -3987.5 {name=p dir=inout pinnumber=1}
B 5 2487.5 -3932.5 2492.5 -3927.5 {name=m dir=inout pinnumber=2}
B 5 2157.5 -3932.5 2162.5 -3927.5 {name=p dir=inout}
B 5 2157.5 -3872.5 2162.5 -3867.5 {name=m dir=inout}
B 5 2238.75 -3961.25 2241.25 -3958.75 {name=p dir=out}
B 5 2267.5 -3852.5 2272.5 -3847.5 {name=p dir=inout goto=0}
B 5 2538.75 -3991.25 2541.25 -3988.75 {name=p dir=in}
B 5 1837.5 -3992.5 1842.5 -3987.5 {name=d dir=inout}
B 5 1797.5 -3962.5 1802.5 -3957.5 {name=g dir=in}
B 5 1837.5 -3932.5 1842.5 -3927.5 {name=s dir=inout}
B 5 1837.5 -3962.5 1842.5 -3957.5 {name=b dir=in}
B 5 1927.5 -3992.5 1932.5 -3987.5 {name=p dir=inout pinnumber=1}
B 5 1927.5 -3932.5 1932.5 -3927.5 {name=m dir=inout pinnumber=2}
B 5 1597.5 -3932.5 1602.5 -3927.5 {name=p dir=inout}
B 5 1597.5 -3872.5 1602.5 -3867.5 {name=m dir=inout}
B 5 1678.75 -3961.25 1681.25 -3958.75 {name=p dir=out}
B 5 1707.5 -3852.5 1712.5 -3847.5 {name=p dir=inout goto=0}
B 5 1978.75 -3991.25 1981.25 -3988.75 {name=p dir=in}
B 5 817.5 -3222.5 822.5 -3217.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -3162.5 822.5 -3157.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -3162.5 822.5 -3157.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -3102.5 822.5 -3097.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -3102.5 1362.5 -3097.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -3262.5 1902.5 -3257.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -3202.5 1902.5 -3197.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -3162.5 1902.5 -3157.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -3102.5 1902.5 -3097.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -3542.5 822.5 -3537.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -3482.5 822.5 -3477.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -3602.5 822.5 -3597.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -3542.5 822.5 -3537.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -3662.5 822.5 -3657.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -3602.5 822.5 -3597.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -3482.5 1362.5 -3477.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -3662.5 1362.5 -3657.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -3482.5 1902.5 -3477.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -3542.5 1902.5 -3537.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -3662.5 1902.5 -3657.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -3602.5 1902.5 -3597.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -2392.5 712.5 -2387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -2332.5 712.5 -2327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -2392.5 822.5 -2387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -2332.5 822.5 -2327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -2392.5 932.5 -2387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -2332.5 932.5 -2327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -2392.5 1252.5 -2387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -2332.5 1252.5 -2327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -2392.5 1362.5 -2387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -2332.5 1362.5 -2327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -2392.5 1472.5 -2387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -2332.5 1472.5 -2327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -2392.5 1792.5 -2387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -2332.5 1792.5 -2327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -2392.5 1902.5 -2387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -2332.5 1902.5 -2327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -2392.5 2012.5 -2387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -2332.5 2012.5 -2327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2317.5 -2392.5 2322.5 -2387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2317.5 -2332.5 2322.5 -2327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2427.5 -2392.5 2432.5 -2387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -2332.5 2432.5 -2327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2537.5 -2392.5 2542.5 -2387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2537.5 -2332.5 2542.5 -2327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2497.5 -3482.5 2502.5 -3477.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2497.5 -3542.5 2502.5 -3537.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2497.5 -3662.5 2502.5 -3657.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2497.5 -3602.5 2502.5 -3597.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -462.5 712.5 -457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -402.5 712.5 -397.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -462.5 822.5 -457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -402.5 822.5 -397.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -462.5 932.5 -457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -402.5 932.5 -397.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -372.5 712.5 -367.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -312.5 712.5 -307.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -372.5 822.5 -367.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -312.5 822.5 -307.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -372.5 932.5 -367.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -312.5 932.5 -307.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -372.5 1252.5 -367.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -312.5 1252.5 -307.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -372.5 1362.5 -367.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -312.5 1362.5 -307.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -372.5 1472.5 -367.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -312.5 1472.5 -307.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -372.5 1792.5 -367.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -312.5 1792.5 -307.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -372.5 1902.5 -367.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -312.5 1902.5 -307.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -372.5 2012.5 -367.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -312.5 2012.5 -307.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1877.5 -2132.5 1882.5 -2127.5 {name=d dir=inout}
B 5 1837.5 -2102.5 1842.5 -2097.5 {name=g dir=in}
B 5 1877.5 -2072.5 1882.5 -2067.5 {name=s dir=inout}
B 5 1877.5 -2102.5 1882.5 -2097.5 {name=b dir=in}
B 5 1108.75 -8691.25 1111.25 -8688.75 {name=p dir=out}
B 5 1137.5 -8582.5 1142.5 -8577.5 {name=p dir=inout goto=0}
B 5 1137.5 -8842.5 1142.5 -8837.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -8721.25 1411.25 -8718.75 {name=p dir=in}
B 5 1027.5 -8662.5 1032.5 -8657.5 {name=p dir=inout}
B 5 1027.5 -8602.5 1032.5 -8597.5 {name=m dir=inout}
B 5 707.5 -82.5 712.5 -77.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -22.5 712.5 -17.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -82.5 822.5 -77.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -22.5 822.5 -17.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -82.5 932.5 -77.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -22.5 932.5 -17.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -22.5 712.5 -17.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 37.5 712.5 42.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -22.5 822.5 -17.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 37.5 822.5 42.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -22.5 932.5 -17.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 37.5 932.5 42.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -22.5 1252.5 -17.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 37.5 1252.5 42.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -22.5 1362.5 -17.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 37.5 1362.5 42.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -22.5 1472.5 -17.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 37.5 1472.5 42.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 7.5 1792.5 12.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 67.5 1792.5 72.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 7.5 1902.5 12.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 67.5 1902.5 72.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 7.5 2012.5 12.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 67.5 2012.5 72.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1757.5 -772.5 1762.5 -767.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1757.5 -712.5 1762.5 -707.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1877.5 -772.5 1882.5 -767.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1877.5 -712.5 1882.5 -707.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 797.5 -842.5 802.5 -837.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 377.5 822.5 382.5 {name=d dir=inout}
B 5 777.5 407.5 782.5 412.5 {name=g dir=in}
B 5 817.5 437.5 822.5 442.5 {name=s dir=inout}
B 5 817.5 407.5 822.5 412.5 {name=b dir=in}
B 5 817.5 287.5 822.5 292.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 347.5 822.5 352.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 907.5 377.5 912.5 382.5 {name=p dir=inout pinnumber=1}
B 5 907.5 437.5 912.5 442.5 {name=m dir=inout pinnumber=2}
B 5 577.5 437.5 582.5 442.5 {name=p dir=inout}
B 5 577.5 497.5 582.5 502.5 {name=m dir=inout}
B 5 658.75 408.75 661.25 411.25 {name=p dir=out}
B 5 687.5 517.5 692.5 522.5 {name=p dir=inout goto=0}
B 5 687.5 257.5 692.5 262.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 958.75 378.75 961.25 381.25 {name=p dir=in}
B 5 1467.5 377.5 1472.5 382.5 {name=d dir=inout}
B 5 1427.5 407.5 1432.5 412.5 {name=g dir=in}
B 5 1467.5 437.5 1472.5 442.5 {name=s dir=inout}
B 5 1467.5 407.5 1472.5 412.5 {name=b dir=in}
B 5 1467.5 287.5 1472.5 292.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 347.5 1472.5 352.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1227.5 437.5 1232.5 442.5 {name=p dir=inout}
B 5 1227.5 497.5 1232.5 502.5 {name=m dir=inout}
B 5 1308.75 408.75 1311.25 411.25 {name=p dir=out}
B 5 1337.5 517.5 1342.5 522.5 {name=p dir=inout goto=0}
B 5 1337.5 257.5 1342.5 262.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1608.75 378.75 1611.25 381.25 {name=p dir=in}
B 5 1297.5 -4372.5 1302.5 -4367.5 {name=d dir=inout}
B 5 1257.5 -4342.5 1262.5 -4337.5 {name=g dir=in}
B 5 1297.5 -4312.5 1302.5 -4307.5 {name=s dir=inout}
B 5 1297.5 -4342.5 1302.5 -4337.5 {name=b dir=in}
B 5 1297.5 -4462.5 1302.5 -4457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1297.5 -4402.5 1302.5 -4397.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1387.5 -4372.5 1392.5 -4367.5 {name=p dir=inout pinnumber=1}
B 5 1387.5 -4312.5 1392.5 -4307.5 {name=m dir=inout pinnumber=2}
B 5 1057.5 -4312.5 1062.5 -4307.5 {name=p dir=inout}
B 5 1057.5 -4252.5 1062.5 -4247.5 {name=m dir=inout}
B 5 1138.75 -4341.25 1141.25 -4338.75 {name=p dir=out}
B 5 1167.5 -4232.5 1172.5 -4227.5 {name=p dir=inout goto=0}
B 5 1167.5 -4492.5 1172.5 -4487.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1438.75 -4371.25 1441.25 -4368.75 {name=p dir=in}
B 5 1857.5 -4372.5 1862.5 -4367.5 {name=d dir=inout}
B 5 1817.5 -4342.5 1822.5 -4337.5 {name=g dir=in}
B 5 1857.5 -4312.5 1862.5 -4307.5 {name=s dir=inout}
B 5 1857.5 -4342.5 1862.5 -4337.5 {name=b dir=in}
B 5 1857.5 -4462.5 1862.5 -4457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1857.5 -4402.5 1862.5 -4397.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1947.5 -4372.5 1952.5 -4367.5 {name=p dir=inout pinnumber=1}
B 5 1947.5 -4312.5 1952.5 -4307.5 {name=m dir=inout pinnumber=2}
B 5 1617.5 -4312.5 1622.5 -4307.5 {name=p dir=inout}
B 5 1617.5 -4252.5 1622.5 -4247.5 {name=m dir=inout}
B 5 1698.75 -4341.25 1701.25 -4338.75 {name=p dir=out}
B 5 1727.5 -4232.5 1732.5 -4227.5 {name=p dir=inout goto=0}
B 5 1727.5 -4492.5 1732.5 -4487.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1998.75 -4371.25 2001.25 -4368.75 {name=p dir=in}
B 5 2427.5 -4372.5 2432.5 -4367.5 {name=d dir=inout}
B 5 2387.5 -4342.5 2392.5 -4337.5 {name=g dir=in}
B 5 2427.5 -4312.5 2432.5 -4307.5 {name=s dir=inout}
B 5 2427.5 -4342.5 2432.5 -4337.5 {name=b dir=in}
B 5 2427.5 -4462.5 2432.5 -4457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -4402.5 2432.5 -4397.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2517.5 -4372.5 2522.5 -4367.5 {name=p dir=inout pinnumber=1}
B 5 2517.5 -4312.5 2522.5 -4307.5 {name=m dir=inout pinnumber=2}
B 5 2187.5 -4312.5 2192.5 -4307.5 {name=p dir=inout}
B 5 2187.5 -4252.5 2192.5 -4247.5 {name=m dir=inout}
B 5 2268.75 -4341.25 2271.25 -4338.75 {name=p dir=out}
B 5 2297.5 -4232.5 2302.5 -4227.5 {name=p dir=inout goto=0}
B 5 2297.5 -4492.5 2302.5 -4487.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2568.75 -4371.25 2571.25 -4368.75 {name=p dir=in}
B 5 2027.5 377.5 2032.5 382.5 {name=d dir=inout}
B 5 1987.5 407.5 1992.5 412.5 {name=g dir=in}
B 5 2027.5 437.5 2032.5 442.5 {name=s dir=inout}
B 5 2027.5 407.5 2032.5 412.5 {name=b dir=in}
B 5 2027.5 287.5 2032.5 292.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2027.5 347.5 2032.5 352.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 437.5 1792.5 442.5 {name=p dir=inout}
B 5 1787.5 497.5 1792.5 502.5 {name=m dir=inout}
B 5 1868.75 408.75 1871.25 411.25 {name=p dir=out}
B 5 1897.5 517.5 1902.5 522.5 {name=p dir=inout goto=0}
B 5 1897.5 257.5 1902.5 262.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2168.75 378.75 2171.25 381.25 {name=p dir=in}
B 5 757.5 -3992.5 762.5 -3987.5 {name=d dir=inout}
B 5 717.5 -3962.5 722.5 -3957.5 {name=g dir=in}
B 5 757.5 -3932.5 762.5 -3927.5 {name=s dir=inout}
B 5 757.5 -3962.5 762.5 -3957.5 {name=b dir=in}
B 5 847.5 -3992.5 852.5 -3987.5 {name=p dir=inout pinnumber=1}
B 5 847.5 -3932.5 852.5 -3927.5 {name=m dir=inout pinnumber=2}
B 5 517.5 -3932.5 522.5 -3927.5 {name=p dir=inout}
B 5 517.5 -3872.5 522.5 -3867.5 {name=m dir=inout}
B 5 598.75 -3961.25 601.25 -3958.75 {name=p dir=out}
B 5 627.5 -3852.5 632.5 -3847.5 {name=p dir=inout goto=0}
B 5 898.75 -3991.25 901.25 -3988.75 {name=p dir=in}
B 5 417.5 -6992.5 422.5 -6987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 607.5 -6992.5 612.5 -6987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 797.5 -6992.5 802.5 -6987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1047.5 -6992.5 1052.5 -6987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1237.5 -6992.5 1242.5 -6987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 417.5 -6932.5 422.5 -6927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 607.5 -6932.5 612.5 -6927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 797.5 -6932.5 802.5 -6927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1047.5 -6932.5 1052.5 -6927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1237.5 -6932.5 1242.5 -6927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1527.5 -6992.5 1532.5 -6987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1527.5 -6932.5 1532.5 -6927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1657.5 -6992.5 1662.5 -6987.5 {name=p dir=inout pinnumber=1}
B 5 1657.5 -6932.5 1662.5 -6927.5 {name=m dir=inout pinnumber=2}
B 5 1857.5 -6992.5 1862.5 -6987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1857.5 -6932.5 1862.5 -6927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1987.5 -6992.5 1992.5 -6987.5 {name=p dir=inout pinnumber=1}
B 5 1987.5 -6932.5 1992.5 -6927.5 {name=m dir=inout pinnumber=2}
B 5 2397.5 -6992.5 2402.5 -6987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2397.5 -6932.5 2402.5 -6927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2527.5 -6992.5 2532.5 -6987.5 {name=p dir=inout pinnumber=1}
B 5 2527.5 -6932.5 2532.5 -6927.5 {name=m dir=inout pinnumber=2}
B 5 2107.5 -6992.5 2112.5 -6987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2107.5 -6932.5 2112.5 -6927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2237.5 -6992.5 2242.5 -6987.5 {name=p dir=inout pinnumber=1}
B 5 2237.5 -6932.5 2242.5 -6927.5 {name=m dir=inout pinnumber=2}
B 5 2377.5 -3602.5 2382.5 -3597.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2377.5 -3542.5 2382.5 -3537.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
A 1 1220 -1760 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1340 -1760 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1850 -1760 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1970 -1760 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1280 -1480 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1910 -1480 5.590169943749475 333.434948822922 360 {fill=1}
A 1 740 -1080 5.590169943749475 333.434948822922 360 {fill=1}
A 2 1570 -8630 15 270 360 {}
A 2 2030 -8630 15 270 360 {}
A 4 1030 -8160 15 270 360 {}
A 4 1570 -8160 15 270 360 {}
A 4 500 -8160 15 270 360 {}
A 4 500 -7700 15 270 360 {}
A 4 1040 -7700 15 270 360 {}
A 4 500 -6080 15 270 360 {}
A 4 1040 -6080 15 270 360 {}
A 4 500 -5590 15 270 360 {}
A 4 1040 -5590 15 270 360 {}
A 4 500 -5100 15 270 360 {}
A 4 1690 -5100 15 270 360 {}
A 4 1040 -5100 15 270 360 {}
A 4 1030 -7330 15 270 360 {}
A 4 500 -7330 15 270 360 {}
A 4 1530 -7330 15 270 360 {}
A 4 500 -8630 15 270 360 {}
A 4 520 -4660 15 270 360 {}
A 4 1060 -4660 15 270 360 {}
A 4 1620 -4660 15 270 360 {}
A 4 2190 -4660 15 270 360 {}
A 4 520 -6490 15 270 360 {}
A 4 1060 -6490 15 270 360 {}
A 4 2190 -6490 15 270 360 {}
A 4 520 -4280 15 270 360 {}
A 4 1060 -3900 15 270 360 {}
A 4 2160 -3900 15 270 360 {}
A 4 1600 -3900 15 270 360 {}
A 4 1030 -8630 15 270 360 {}
A 4 580 470 15 270 360 {}
A 4 1230 470 15 270 360 {}
A 4 1060 -4280 15 270 360 {}
A 4 1620 -4280 15 270 360 {}
A 4 2190 -4280 15 270 360 {}
A 4 1790 470 15 270 360 {}
A 4 520 -3900 15 270 360 {}
A 5 1360 -2840 5.590169943749475 333.434948822922 360 {fill=1}
P 1 14 920 -8080 942.5 -8080 947.5 -8080 947.5 -8075 947.5 -8032.5 940 -8007.5 935 -8007.5 905 -8007.5 900 -8007.5 892.5 -8032.5 892.5 -8075 892.5 -8080 897.5 -8080 920 -8080 {bezier=1}
P 1 14 935 -8077.5 940 -8077.5 945 -8077.5 945 -8072.5 945 -8052.5 945 -8047.5 940 -8047.5 930 -8047.5 925 -8047.5 925 -8052.5 925 -8072.5 925 -8077.5 930 -8077.5 935 -8077.5 {bezier=1}
P 1 5 917.5 -8075 922.5 -8075 922.5 -8050 917.5 -8050 917.5 -8075 {}
P 1 14 1350 -8080 1372.5 -8080 1377.5 -8080 1377.5 -8075 1377.5 -8032.5 1370 -8007.5 1365 -8007.5 1335 -8007.5 1330 -8007.5 1322.5 -8032.5 1322.5 -8075 1322.5 -8080 1327.5 -8080 1350 -8080 {bezier=1}
P 1 14 1365 -8077.5 1370 -8077.5 1375 -8077.5 1375 -8072.5 1375 -8052.5 1375 -8047.5 1370 -8047.5 1360 -8047.5 1355 -8047.5 1355 -8052.5 1355 -8072.5 1355 -8077.5 1360 -8077.5 1365 -8077.5 {bezier=1}
P 1 5 1347.5 -8075 1352.5 -8075 1352.5 -8050 1347.5 -8050 1347.5 -8075 {}
P 1 14 2120 -8080 2142.5 -8080 2147.5 -8080 2147.5 -8075 2147.5 -8032.5 2140 -8007.5 2135 -8007.5 2105 -8007.5 2100 -8007.5 2092.5 -8032.5 2092.5 -8075 2092.5 -8080 2097.5 -8080 2120 -8080 {bezier=1}
P 1 14 2135 -8077.5 2140 -8077.5 2145 -8077.5 2145 -8072.5 2145 -8052.5 2145 -8047.5 2140 -8047.5 2130 -8047.5 2125 -8047.5 2125 -8052.5 2125 -8072.5 2125 -8077.5 2130 -8077.5 2135 -8077.5 {bezier=1}
P 1 5 2117.5 -8075 2122.5 -8075 2122.5 -8050 2117.5 -8050 2117.5 -8075 {}
P 1 14 1420 -7890 1442.5 -7890 1447.5 -7890 1447.5 -7885 1447.5 -7842.5 1440 -7817.5 1435 -7817.5 1405 -7817.5 1400 -7817.5 1392.5 -7842.5 1392.5 -7885 1392.5 -7890 1397.5 -7890 1420 -7890 {bezier=1}
P 1 14 1435 -7887.5 1440 -7887.5 1445 -7887.5 1445 -7882.5 1445 -7862.5 1445 -7857.5 1440 -7857.5 1430 -7857.5 1425 -7857.5 1425 -7862.5 1425 -7882.5 1425 -7887.5 1430 -7887.5 1435 -7887.5 {bezier=1}
P 1 5 1417.5 -7885 1422.5 -7885 1422.5 -7860 1417.5 -7860 1417.5 -7885 {}
P 1 14 1440 -6280 1462.5 -6280 1467.5 -6280 1467.5 -6275 1467.5 -6232.5 1460 -6207.5 1455 -6207.5 1425 -6207.5 1420 -6207.5 1412.5 -6232.5 1412.5 -6275 1412.5 -6280 1417.5 -6280 1440 -6280 {bezier=1}
P 1 14 1455 -6277.5 1460 -6277.5 1465 -6277.5 1465 -6272.5 1465 -6252.5 1465 -6247.5 1460 -6247.5 1450 -6247.5 1445 -6247.5 1445 -6252.5 1445 -6272.5 1445 -6277.5 1450 -6277.5 1455 -6277.5 {bezier=1}
P 1 5 1437.5 -6275 1442.5 -6275 1442.5 -6250 1437.5 -6250 1437.5 -6275 {}
P 1 10 1530 -6265 1555 -6265 1565 -6255 1565 -6225 1555 -6215 1505 -6215 1495 -6225 1495 -6255 1505 -6265 1530 -6265 {bezier=1}
P 1 10 1530 -6270 1560 -6270 1570 -6260 1570 -6220 1560 -6210 1500 -6210 1490 -6220 1490 -6260 1500 -6270 1530 -6270 {bezier=1}
P 1 14 1440 -5790 1462.5 -5790 1467.5 -5790 1467.5 -5785 1467.5 -5742.5 1460 -5717.5 1455 -5717.5 1425 -5717.5 1420 -5717.5 1412.5 -5742.5 1412.5 -5785 1412.5 -5790 1417.5 -5790 1440 -5790 {bezier=1}
P 1 14 1455 -5787.5 1460 -5787.5 1465 -5787.5 1465 -5782.5 1465 -5762.5 1465 -5757.5 1460 -5757.5 1450 -5757.5 1445 -5757.5 1445 -5762.5 1445 -5782.5 1445 -5787.5 1450 -5787.5 1455 -5787.5 {bezier=1}
P 1 5 1437.5 -5785 1442.5 -5785 1442.5 -5760 1437.5 -5760 1437.5 -5785 {}
P 1 10 1530 -5775 1555 -5775 1565 -5765 1565 -5735 1555 -5725 1505 -5725 1495 -5735 1495 -5765 1505 -5775 1530 -5775 {bezier=1}
P 1 10 1530 -5780 1560 -5780 1570 -5770 1570 -5730 1560 -5720 1500 -5720 1490 -5730 1490 -5770 1500 -5780 1530 -5780 {bezier=1}
P 1 14 950 -5060 972.5 -5060 977.5 -5060 977.5 -5055 977.5 -5012.5 970 -4987.5 965 -4987.5 935 -4987.5 930 -4987.5 922.5 -5012.5 922.5 -5055 922.5 -5060 927.5 -5060 950 -5060 {bezier=1}
P 1 14 965 -5057.5 970 -5057.5 975 -5057.5 975 -5052.5 975 -5032.5 975 -5027.5 970 -5027.5 960 -5027.5 955 -5027.5 955 -5032.5 955 -5052.5 955 -5057.5 960 -5057.5 965 -5057.5 {bezier=1}
P 1 5 947.5 -5055 952.5 -5055 952.5 -5030 947.5 -5030 947.5 -5055 {}
P 1 14 1430 -5070 1452.5 -5070 1457.5 -5070 1457.5 -5065 1457.5 -5022.5 1450 -4997.5 1445 -4997.5 1415 -4997.5 1410 -4997.5 1402.5 -5022.5 1402.5 -5065 1402.5 -5070 1407.5 -5070 1430 -5070 {bezier=1}
P 1 14 1445 -5067.5 1450 -5067.5 1455 -5067.5 1455 -5062.5 1455 -5042.5 1455 -5037.5 1450 -5037.5 1440 -5037.5 1435 -5037.5 1435 -5042.5 1435 -5062.5 1435 -5067.5 1440 -5067.5 1445 -5067.5 {bezier=1}
P 1 5 1427.5 -5065 1432.5 -5065 1432.5 -5040 1427.5 -5040 1427.5 -5065 {}
P 1 10 1520 -5055 1545 -5055 1555 -5045 1555 -5015 1545 -5005 1495 -5005 1485 -5015 1485 -5045 1495 -5055 1520 -5055 {bezier=1}
P 1 10 1520 -5060 1550 -5060 1560 -5050 1560 -5010 1550 -5000 1490 -5000 1480 -5010 1480 -5050 1490 -5060 1520 -5060 {bezier=1}
P 1 14 920 -7250 942.5 -7250 947.5 -7250 947.5 -7245 947.5 -7202.5 940 -7177.5 935 -7177.5 905 -7177.5 900 -7177.5 892.5 -7202.5 892.5 -7245 892.5 -7250 897.5 -7250 920 -7250 {bezier=1}
P 1 14 935 -7247.5 940 -7247.5 945 -7247.5 945 -7242.5 945 -7222.5 945 -7217.5 940 -7217.5 930 -7217.5 925 -7217.5 925 -7222.5 925 -7242.5 925 -7247.5 930 -7247.5 935 -7247.5 {bezier=1}
P 1 5 917.5 -7245 922.5 -7245 922.5 -7220 917.5 -7220 917.5 -7245 {}
P 1 14 1350 -7250 1372.5 -7250 1377.5 -7250 1377.5 -7245 1377.5 -7202.5 1370 -7177.5 1365 -7177.5 1335 -7177.5 1330 -7177.5 1322.5 -7202.5 1322.5 -7245 1322.5 -7250 1327.5 -7250 1350 -7250 {bezier=1}
P 1 14 1365 -7247.5 1370 -7247.5 1375 -7247.5 1375 -7242.5 1375 -7222.5 1375 -7217.5 1370 -7217.5 1360 -7217.5 1355 -7217.5 1355 -7222.5 1355 -7242.5 1355 -7247.5 1360 -7247.5 1365 -7247.5 {bezier=1}
P 1 5 1347.5 -7245 1352.5 -7245 1352.5 -7220 1347.5 -7220 1347.5 -7245 {}
P 1 14 2120 -7250 2142.5 -7250 2147.5 -7250 2147.5 -7245 2147.5 -7202.5 2140 -7177.5 2135 -7177.5 2105 -7177.5 2100 -7177.5 2092.5 -7202.5 2092.5 -7245 2092.5 -7250 2097.5 -7250 2120 -7250 {bezier=1}
P 1 14 2135 -7247.5 2140 -7247.5 2145 -7247.5 2145 -7242.5 2145 -7222.5 2145 -7217.5 2140 -7217.5 2130 -7217.5 2125 -7217.5 2125 -7222.5 2125 -7242.5 2125 -7247.5 2130 -7247.5 2135 -7247.5 {bezier=1}
P 1 5 2117.5 -7245 2122.5 -7245 2122.5 -7220 2117.5 -7220 2117.5 -7245 {}
P 1 10 1270 -7245 1295 -7245 1305 -7235 1305 -7205 1295 -7195 1245 -7195 1235 -7205 1235 -7235 1245 -7245 1270 -7245 {bezier=1}
P 1 10 1270 -7250 1300 -7250 1310 -7240 1310 -7200 1300 -7190 1240 -7190 1230 -7200 1230 -7240 1240 -7250 1270 -7250 {bezier=1}
P 1 14 920 -8550 942.5 -8550 947.5 -8550 947.5 -8545 947.5 -8502.5 940 -8477.5 935 -8477.5 905 -8477.5 900 -8477.5 892.5 -8502.5 892.5 -8545 892.5 -8550 897.5 -8550 920 -8550 {bezier=1}
P 1 14 935 -8547.5 940 -8547.5 945 -8547.5 945 -8542.5 945 -8522.5 945 -8517.5 940 -8517.5 930 -8517.5 925 -8517.5 925 -8522.5 925 -8542.5 925 -8547.5 930 -8547.5 935 -8547.5 {bezier=1}
P 1 5 917.5 -8545 922.5 -8545 922.5 -8520 917.5 -8520 917.5 -8545 {}
P 1 14 1630 -8540 1652.5 -8540 1657.5 -8540 1657.5 -8535 1657.5 -8492.5 1650 -8467.5 1645 -8467.5 1615 -8467.5 1610 -8467.5 1602.5 -8492.5 1602.5 -8535 1602.5 -8540 1607.5 -8540 1630 -8540 {bezier=1}
P 1 14 1645 -8537.5 1650 -8537.5 1655 -8537.5 1655 -8532.5 1655 -8512.5 1655 -8507.5 1650 -8507.5 1640 -8507.5 1635 -8507.5 1635 -8512.5 1635 -8532.5 1635 -8537.5 1640 -8537.5 1645 -8537.5 {bezier=1}
P 1 5 1627.5 -8535 1632.5 -8535 1632.5 -8510 1627.5 -8510 1627.5 -8535 {}
P 1 10 1710 -8525 1735 -8525 1745 -8515 1745 -8485 1735 -8475 1685 -8475 1675 -8485 1675 -8515 1685 -8525 1710 -8525 {bezier=1}
P 1 10 1710 -8530 1740 -8530 1750 -8520 1750 -8480 1740 -8470 1680 -8470 1670 -8480 1670 -8520 1680 -8530 1710 -8530 {bezier=1}
P 1 14 2410 -8530 2432.5 -8530 2437.5 -8530 2437.5 -8525 2437.5 -8482.5 2430 -8457.5 2425 -8457.5 2395 -8457.5 2390 -8457.5 2382.5 -8482.5 2382.5 -8525 2382.5 -8530 2387.5 -8530 2410 -8530 {bezier=1}
P 1 14 2425 -8527.5 2430 -8527.5 2435 -8527.5 2435 -8522.5 2435 -8502.5 2435 -8497.5 2430 -8497.5 2420 -8497.5 2415 -8497.5 2415 -8502.5 2415 -8522.5 2415 -8527.5 2420 -8527.5 2425 -8527.5 {bezier=1}
P 1 5 2407.5 -8525 2412.5 -8525 2412.5 -8500 2407.5 -8500 2407.5 -8525 {}
P 1 10 2490 -8515 2515 -8515 2525 -8505 2525 -8475 2515 -8465 2465 -8465 2455 -8475 2455 -8505 2465 -8515 2490 -8515 {bezier=1}
P 1 10 2490 -8520 2520 -8520 2530 -8510 2530 -8470 2520 -8460 2460 -8460 2450 -8470 2450 -8510 2460 -8520 2490 -8520 {bezier=1}
P 1 14 1490 -4870 1512.5 -4870 1517.5 -4870 1517.5 -4865 1517.5 -4822.5 1510 -4797.5 1505 -4797.5 1475 -4797.5 1470 -4797.5 1462.5 -4822.5 1462.5 -4865 1462.5 -4870 1467.5 -4870 1490 -4870 {bezier=1}
P 1 14 1505 -4867.5 1510 -4867.5 1515 -4867.5 1515 -4862.5 1515 -4842.5 1515 -4837.5 1510 -4837.5 1500 -4837.5 1495 -4837.5 1495 -4842.5 1495 -4862.5 1495 -4867.5 1500 -4867.5 1505 -4867.5 {bezier=1}
P 1 5 1487.5 -4865 1492.5 -4865 1492.5 -4840 1487.5 -4840 1487.5 -4865 {}
P 1 14 1940 -4940 1962.5 -4940 1967.5 -4940 1967.5 -4935 1967.5 -4892.5 1960 -4867.5 1955 -4867.5 1925 -4867.5 1920 -4867.5 1912.5 -4892.5 1912.5 -4935 1912.5 -4940 1917.5 -4940 1940 -4940 {bezier=1}
P 1 14 1955 -4937.5 1960 -4937.5 1965 -4937.5 1965 -4932.5 1965 -4912.5 1965 -4907.5 1960 -4907.5 1950 -4907.5 1945 -4907.5 1945 -4912.5 1945 -4932.5 1945 -4937.5 1950 -4937.5 1955 -4937.5 {bezier=1}
P 1 5 1937.5 -4935 1942.5 -4935 1942.5 -4910 1937.5 -4910 1937.5 -4935 {}
P 1 14 2560 -4850 2582.5 -4850 2587.5 -4850 2587.5 -4845 2587.5 -4802.5 2580 -4777.5 2575 -4777.5 2545 -4777.5 2540 -4777.5 2532.5 -4802.5 2532.5 -4845 2532.5 -4850 2537.5 -4850 2560 -4850 {bezier=1}
P 1 14 2575 -4847.5 2580 -4847.5 2585 -4847.5 2585 -4842.5 2585 -4822.5 2585 -4817.5 2580 -4817.5 2570 -4817.5 2565 -4817.5 2565 -4822.5 2565 -4842.5 2565 -4847.5 2570 -4847.5 2575 -4847.5 {bezier=1}
P 1 5 2557.5 -4845 2562.5 -4845 2562.5 -4820 2557.5 -4820 2557.5 -4845 {}
P 1 14 690 -6670 712.5 -6670 717.5 -6670 717.5 -6665 717.5 -6622.5 710 -6597.5 705 -6597.5 675 -6597.5 670 -6597.5 662.5 -6622.5 662.5 -6665 662.5 -6670 667.5 -6670 690 -6670 {bezier=1}
P 1 14 705 -6667.5 710 -6667.5 715 -6667.5 715 -6662.5 715 -6642.5 715 -6637.5 710 -6637.5 700 -6637.5 695 -6637.5 695 -6642.5 695 -6662.5 695 -6667.5 700 -6667.5 705 -6667.5 {bezier=1}
P 1 5 687.5 -6665 692.5 -6665 692.5 -6640 687.5 -6640 687.5 -6665 {}
P 1 14 1350 -6690 1372.5 -6690 1377.5 -6690 1377.5 -6685 1377.5 -6642.5 1370 -6617.5 1365 -6617.5 1335 -6617.5 1330 -6617.5 1322.5 -6642.5 1322.5 -6685 1322.5 -6690 1327.5 -6690 1350 -6690 {bezier=1}
P 1 14 1365 -6687.5 1370 -6687.5 1375 -6687.5 1375 -6682.5 1375 -6662.5 1375 -6657.5 1370 -6657.5 1360 -6657.5 1355 -6657.5 1355 -6662.5 1355 -6682.5 1355 -6687.5 1360 -6687.5 1365 -6687.5 {bezier=1}
P 1 5 1347.5 -6685 1352.5 -6685 1352.5 -6660 1347.5 -6660 1347.5 -6685 {}
P 1 14 2540 -6740 2562.5 -6740 2567.5 -6740 2567.5 -6735 2567.5 -6692.5 2560 -6667.5 2555 -6667.5 2525 -6667.5 2520 -6667.5 2512.5 -6692.5 2512.5 -6735 2512.5 -6740 2517.5 -6740 2540 -6740 {bezier=1}
P 1 14 2555 -6737.5 2560 -6737.5 2565 -6737.5 2565 -6732.5 2565 -6712.5 2565 -6707.5 2560 -6707.5 2550 -6707.5 2545 -6707.5 2545 -6712.5 2545 -6732.5 2545 -6737.5 2550 -6737.5 2555 -6737.5 {bezier=1}
P 1 5 2537.5 -6735 2542.5 -6735 2542.5 -6710 2537.5 -6710 2537.5 -6735 {}
P 1 14 1390 -4130 1412.5 -4130 1417.5 -4130 1417.5 -4125 1417.5 -4082.5 1410 -4057.5 1405 -4057.5 1375 -4057.5 1370 -4057.5 1362.5 -4082.5 1362.5 -4125 1362.5 -4130 1367.5 -4130 1390 -4130 {bezier=1}
P 1 14 1405 -4127.5 1410 -4127.5 1415 -4127.5 1415 -4122.5 1415 -4102.5 1415 -4097.5 1410 -4097.5 1400 -4097.5 1395 -4097.5 1395 -4102.5 1395 -4122.5 1395 -4127.5 1400 -4127.5 1405 -4127.5 {bezier=1}
P 1 5 1387.5 -4125 1392.5 -4125 1392.5 -4100 1387.5 -4100 1387.5 -4125 {}
P 1 14 1790 -4080 1812.5 -4080 1817.5 -4080 1817.5 -4075 1817.5 -4032.5 1810 -4007.5 1805 -4007.5 1775 -4007.5 1770 -4007.5 1762.5 -4032.5 1762.5 -4075 1762.5 -4080 1767.5 -4080 1790 -4080 {bezier=1}
P 1 14 1805 -4077.5 1810 -4077.5 1815 -4077.5 1815 -4072.5 1815 -4052.5 1815 -4047.5 1810 -4047.5 1800 -4047.5 1795 -4047.5 1795 -4052.5 1795 -4072.5 1795 -4077.5 1800 -4077.5 1805 -4077.5 {bezier=1}
P 1 5 1787.5 -4075 1792.5 -4075 1792.5 -4050 1787.5 -4050 1787.5 -4075 {}
P 1 10 1710 -4065 1735 -4065 1745 -4055 1745 -4025 1735 -4015 1685 -4015 1675 -4025 1675 -4055 1685 -4065 1710 -4065 {bezier=1}
P 1 10 1710 -4070 1740 -4070 1750 -4060 1750 -4020 1740 -4010 1680 -4010 1670 -4020 1670 -4060 1680 -4070 1710 -4070 {bezier=1}
P 1 14 2350 -4110 2372.5 -4110 2377.5 -4110 2377.5 -4105 2377.5 -4062.5 2370 -4037.5 2365 -4037.5 2335 -4037.5 2330 -4037.5 2322.5 -4062.5 2322.5 -4105 2322.5 -4110 2327.5 -4110 2350 -4110 {bezier=1}
P 1 14 2365 -4107.5 2370 -4107.5 2375 -4107.5 2375 -4102.5 2375 -4082.5 2375 -4077.5 2370 -4077.5 2360 -4077.5 2355 -4077.5 2355 -4082.5 2355 -4102.5 2355 -4107.5 2360 -4107.5 2365 -4107.5 {bezier=1}
P 1 5 2347.5 -4105 2352.5 -4105 2352.5 -4080 2347.5 -4080 2347.5 -4105 {}
P 1 14 1430 -3560 1452.5 -3560 1457.5 -3560 1457.5 -3555 1457.5 -3512.5 1450 -3487.5 1445 -3487.5 1415 -3487.5 1410 -3487.5 1402.5 -3512.5 1402.5 -3555 1402.5 -3560 1407.5 -3560 1430 -3560 {bezier=1}
P 1 14 1445 -3557.5 1450 -3557.5 1455 -3557.5 1455 -3552.5 1455 -3532.5 1455 -3527.5 1450 -3527.5 1440 -3527.5 1435 -3527.5 1435 -3532.5 1435 -3552.5 1435 -3557.5 1440 -3557.5 1445 -3557.5 {bezier=1}
P 1 5 1427.5 -3555 1432.5 -3555 1432.5 -3530 1427.5 -3530 1427.5 -3555 {}
P 1 10 1430 -3715 1455 -3715 1465 -3705 1465 -3675 1455 -3665 1405 -3665 1395 -3675 1395 -3705 1405 -3715 1430 -3715 {bezier=1}
P 1 10 1430 -3720 1460 -3720 1470 -3710 1470 -3670 1460 -3660 1400 -3660 1390 -3670 1390 -3710 1400 -3720 1430 -3720 {bezier=1}
P 1 10 1430 -3635 1455 -3635 1465 -3625 1465 -3595 1455 -3585 1405 -3585 1395 -3595 1395 -3625 1405 -3635 1430 -3635 {bezier=1}
P 1 10 1430 -3640 1460 -3640 1470 -3630 1470 -3590 1460 -3580 1400 -3580 1390 -3590 1390 -3630 1400 -3640 1430 -3640 {bezier=1}
P 1 14 1700 -3560 1722.5 -3560 1727.5 -3560 1727.5 -3555 1727.5 -3512.5 1720 -3487.5 1715 -3487.5 1685 -3487.5 1680 -3487.5 1672.5 -3512.5 1672.5 -3555 1672.5 -3560 1677.5 -3560 1700 -3560 {bezier=1}
P 1 14 1715 -3557.5 1720 -3557.5 1725 -3557.5 1725 -3552.5 1725 -3532.5 1725 -3527.5 1720 -3527.5 1710 -3527.5 1705 -3527.5 1705 -3532.5 1705 -3552.5 1705 -3557.5 1710 -3557.5 1715 -3557.5 {bezier=1}
P 1 5 1697.5 -3555 1702.5 -3555 1702.5 -3530 1697.5 -3530 1697.5 -3555 {}
P 1 10 1700 -3715 1725 -3715 1735 -3705 1735 -3675 1725 -3665 1675 -3665 1665 -3675 1665 -3705 1675 -3715 1700 -3715 {bezier=1}
P 1 10 1700 -3720 1730 -3720 1740 -3710 1740 -3670 1730 -3660 1670 -3660 1660 -3670 1660 -3710 1670 -3720 1700 -3720 {bezier=1}
P 1 10 1700 -3635 1725 -3635 1735 -3625 1735 -3595 1725 -3585 1675 -3585 1665 -3595 1665 -3625 1675 -3635 1700 -3635 {bezier=1}
P 1 10 1700 -3640 1730 -3640 1740 -3630 1740 -3590 1730 -3580 1670 -3580 1660 -3590 1660 -3630 1670 -3640 1700 -3640 {bezier=1}
P 1 14 2300 -3560 2322.5 -3560 2327.5 -3560 2327.5 -3555 2327.5 -3512.5 2320 -3487.5 2315 -3487.5 2285 -3487.5 2280 -3487.5 2272.5 -3512.5 2272.5 -3555 2272.5 -3560 2277.5 -3560 2300 -3560 {bezier=1}
P 1 14 2315 -3557.5 2320 -3557.5 2325 -3557.5 2325 -3552.5 2325 -3532.5 2325 -3527.5 2320 -3527.5 2310 -3527.5 2305 -3527.5 2305 -3532.5 2305 -3552.5 2305 -3557.5 2310 -3557.5 2315 -3557.5 {bezier=1}
P 1 5 2297.5 -3555 2302.5 -3555 2302.5 -3530 2297.5 -3530 2297.5 -3555 {}
P 1 14 1430 -3180 1452.5 -3180 1457.5 -3180 1457.5 -3175 1457.5 -3132.5 1450 -3107.5 1445 -3107.5 1415 -3107.5 1410 -3107.5 1402.5 -3132.5 1402.5 -3175 1402.5 -3180 1407.5 -3180 1430 -3180 {bezier=1}
P 1 14 1445 -3177.5 1450 -3177.5 1455 -3177.5 1455 -3172.5 1455 -3152.5 1455 -3147.5 1450 -3147.5 1440 -3147.5 1435 -3147.5 1435 -3152.5 1435 -3172.5 1435 -3177.5 1440 -3177.5 1445 -3177.5 {bezier=1}
P 1 5 1427.5 -3175 1432.5 -3175 1432.5 -3150 1427.5 -3150 1427.5 -3175 {}
P 1 10 1430 -3335 1455 -3335 1465 -3325 1465 -3295 1455 -3285 1405 -3285 1395 -3295 1395 -3325 1405 -3335 1430 -3335 {bezier=1}
P 1 10 1430 -3340 1460 -3340 1470 -3330 1470 -3290 1460 -3280 1400 -3280 1390 -3290 1390 -3330 1400 -3340 1430 -3340 {bezier=1}
P 1 10 1430 -3255 1455 -3255 1465 -3245 1465 -3215 1455 -3205 1405 -3205 1395 -3215 1395 -3245 1405 -3255 1430 -3255 {bezier=1}
P 1 10 1430 -3260 1460 -3260 1470 -3250 1470 -3210 1460 -3200 1400 -3200 1390 -3210 1390 -3250 1400 -3260 1430 -3260 {bezier=1}
P 1 14 2080 -450 2102.5 -450 2107.5 -450 2107.5 -445 2107.5 -402.5 2100 -377.5 2095 -377.5 2065 -377.5 2060 -377.5 2052.5 -402.5 2052.5 -445 2052.5 -450 2057.5 -450 2080 -450 {bezier=1}
P 1 14 2095 -447.5 2100 -447.5 2105 -447.5 2105 -442.5 2105 -422.5 2105 -417.5 2100 -417.5 2090 -417.5 2085 -417.5 2085 -422.5 2085 -442.5 2085 -447.5 2090 -447.5 2095 -447.5 {bezier=1}
P 1 5 2077.5 -445 2082.5 -445 2082.5 -420 2077.5 -420 2077.5 -445 {}
P 1 10 2080 -515 2105 -515 2115 -505 2115 -475 2105 -465 2055 -465 2045 -475 2045 -505 2055 -515 2080 -515 {bezier=1}
P 1 10 2080 -520 2110 -520 2120 -510 2120 -470 2110 -460 2050 -460 2040 -470 2040 -510 2050 -520 2080 -520 {bezier=1}
P 1 14 1570 -420 1592.5 -420 1597.5 -420 1597.5 -415 1597.5 -372.5 1590 -347.5 1585 -347.5 1555 -347.5 1550 -347.5 1542.5 -372.5 1542.5 -415 1542.5 -420 1547.5 -420 1570 -420 {bezier=1}
P 1 14 1585 -417.5 1590 -417.5 1595 -417.5 1595 -412.5 1595 -392.5 1595 -387.5 1590 -387.5 1580 -387.5 1575 -387.5 1575 -392.5 1575 -412.5 1575 -417.5 1580 -417.5 1585 -417.5 {bezier=1}
P 1 5 1567.5 -415 1572.5 -415 1572.5 -390 1567.5 -390 1567.5 -415 {}
P 1 14 1430 -2820 1452.5 -2820 1457.5 -2820 1457.5 -2815 1457.5 -2772.5 1450 -2747.5 1445 -2747.5 1415 -2747.5 1410 -2747.5 1402.5 -2772.5 1402.5 -2815 1402.5 -2820 1407.5 -2820 1430 -2820 {bezier=1}
P 1 14 1415 -2817.5 1410 -2817.5 1405 -2817.5 1405 -2812.5 1405 -2792.5 1405 -2787.5 1410 -2787.5 1420 -2787.5 1425 -2787.5 1425 -2792.5 1425 -2812.5 1425 -2817.5 1420 -2817.5 1415 -2817.5 {bezier=1}
P 1 5 1427.5 -2815 1432.5 -2815 1432.5 -2790 1427.5 -2790 1427.5 -2815 {}
P 1 10 1430 -2885 1455 -2885 1465 -2875 1465 -2845 1455 -2835 1405 -2835 1395 -2845 1395 -2875 1405 -2885 1430 -2885 {bezier=1}
P 1 10 1430 -2890 1460 -2890 1470 -2880 1470 -2840 1460 -2830 1400 -2830 1390 -2840 1390 -2880 1400 -2890 1430 -2890 {bezier=1}
P 1 14 1960 -2930 1982.5 -2930 1987.5 -2930 1987.5 -2925 1987.5 -2882.5 1980 -2857.5 1975 -2857.5 1945 -2857.5 1940 -2857.5 1932.5 -2882.5 1932.5 -2925 1932.5 -2930 1937.5 -2930 1960 -2930 {bezier=1}
P 1 14 1975 -2927.5 1980 -2927.5 1985 -2927.5 1985 -2922.5 1985 -2902.5 1985 -2897.5 1980 -2897.5 1970 -2897.5 1965 -2897.5 1965 -2902.5 1965 -2922.5 1965 -2927.5 1970 -2927.5 1975 -2927.5 {bezier=1}
P 1 5 1957.5 -2925 1962.5 -2925 1962.5 -2900 1957.5 -2900 1957.5 -2925 {}
P 1 14 1580 -2410 1602.5 -2410 1607.5 -2410 1607.5 -2405 1607.5 -2362.5 1600 -2337.5 1595 -2337.5 1565 -2337.5 1560 -2337.5 1552.5 -2362.5 1552.5 -2405 1552.5 -2410 1557.5 -2410 1580 -2410 {bezier=1}
P 1 14 1595 -2407.5 1600 -2407.5 1605 -2407.5 1605 -2402.5 1605 -2382.5 1605 -2377.5 1600 -2377.5 1590 -2377.5 1585 -2377.5 1585 -2382.5 1585 -2402.5 1585 -2407.5 1590 -2407.5 1595 -2407.5 {bezier=1}
P 1 5 1577.5 -2405 1582.5 -2405 1582.5 -2380 1577.5 -2380 1577.5 -2405 {}
P 1 10 1580 -2475 1605 -2475 1615 -2465 1615 -2435 1605 -2425 1555 -2425 1545 -2435 1545 -2465 1555 -2475 1580 -2475 {bezier=1}
P 1 10 1580 -2480 1610 -2480 1620 -2470 1620 -2430 1610 -2420 1550 -2420 1540 -2430 1540 -2470 1550 -2480 1580 -2480 {bezier=1}
P 1 14 2070 -2470 2092.5 -2470 2097.5 -2470 2097.5 -2465 2097.5 -2422.5 2090 -2397.5 2085 -2397.5 2055 -2397.5 2050 -2397.5 2042.5 -2422.5 2042.5 -2465 2042.5 -2470 2047.5 -2470 2070 -2470 {bezier=1}
P 1 14 2085 -2467.5 2090 -2467.5 2095 -2467.5 2095 -2462.5 2095 -2442.5 2095 -2437.5 2090 -2437.5 2080 -2437.5 2075 -2437.5 2075 -2442.5 2075 -2462.5 2075 -2467.5 2080 -2467.5 2085 -2467.5 {bezier=1}
P 1 5 2067.5 -2465 2072.5 -2465 2072.5 -2440 2067.5 -2440 2067.5 -2465 {}
P 1 14 2600 -2600 2622.5 -2600 2627.5 -2600 2627.5 -2595 2627.5 -2552.5 2620 -2527.5 2615 -2527.5 2585 -2527.5 2580 -2527.5 2572.5 -2552.5 2572.5 -2595 2572.5 -2600 2577.5 -2600 2600 -2600 {bezier=1}
P 1 14 2615 -2597.5 2620 -2597.5 2625 -2597.5 2625 -2592.5 2625 -2572.5 2625 -2567.5 2620 -2567.5 2610 -2567.5 2605 -2567.5 2605 -2572.5 2605 -2592.5 2605 -2597.5 2610 -2597.5 2615 -2597.5 {bezier=1}
P 1 5 2597.5 -2595 2602.5 -2595 2602.5 -2570 2597.5 -2570 2597.5 -2595 {}
P 1 14 2585 -2597.5 2590 -2597.5 2595 -2597.5 2595 -2592.5 2595 -2572.5 2595 -2567.5 2590 -2567.5 2580 -2567.5 2575 -2567.5 2575 -2572.5 2575 -2592.5 2575 -2597.5 2580 -2597.5 2585 -2597.5 {}
P 1 10 1960 -2175 1985 -2175 1995 -2165 1995 -2135 1985 -2125 1935 -2125 1925 -2135 1925 -2165 1935 -2175 1960 -2175 {bezier=1}
P 1 10 1960 -2180 1990 -2180 2000 -2170 2000 -2130 1990 -2120 1930 -2120 1920 -2130 1920 -2170 1930 -2180 1960 -2180 {bezier=1}
P 1 10 1960 -2095 1985 -2095 1995 -2085 1995 -2055 1985 -2045 1935 -2045 1925 -2055 1925 -2085 1935 -2095 1960 -2095 {bezier=1}
P 1 10 1960 -2100 1990 -2100 2000 -2090 2000 -2050 1990 -2040 1930 -2040 1920 -2050 1920 -2090 1930 -2100 1960 -2100 {bezier=1}
P 1 14 990 -8820 1012.5 -8820 1017.5 -8820 1017.5 -8815 1017.5 -8772.5 1010 -8747.5 1005 -8747.5 975 -8747.5 970 -8747.5 962.5 -8772.5 962.5 -8815 962.5 -8820 967.5 -8820 990 -8820 {bezier=1}
P 1 14 1005 -8817.5 1010 -8817.5 1015 -8817.5 1015 -8812.5 1015 -8792.5 1015 -8787.5 1010 -8787.5 1000 -8787.5 995 -8787.5 995 -8792.5 995 -8812.5 995 -8817.5 1000 -8817.5 1005 -8817.5 {bezier=1}
P 1 5 987.5 -8815 992.5 -8815 992.5 -8790 987.5 -8790 987.5 -8815 {}
P 1 10 1080 -8805 1105 -8805 1115 -8795 1115 -8765 1105 -8755 1055 -8755 1045 -8765 1045 -8795 1055 -8805 1080 -8805 {bezier=1}
P 1 10 1080 -8810 1110 -8810 1120 -8800 1120 -8760 1110 -8750 1050 -8750 1040 -8760 1040 -8800 1050 -8810 1080 -8810 {bezier=1}
P 1 14 1570 -40 1592.5 -40 1597.5 -40 1597.5 -35 1597.5 7.5 1590 32.5 1585 32.5 1555 32.5 1550 32.5 1542.5 7.5 1542.5 -35 1542.5 -40 1547.5 -40 1570 -40 {bezier=1}
P 1 14 1585 -37.5 1590 -37.5 1595 -37.5 1595 -32.5 1595 -12.5 1595 -7.5 1590 -7.5 1580 -7.5 1575 -7.5 1575 -12.5 1575 -32.5 1575 -37.5 1580 -37.5 1585 -37.5 {bezier=1}
P 1 5 1567.5 -35 1572.5 -35 1572.5 -10 1567.5 -10 1567.5 -35 {}
P 1 14 2080 10 2102.5 10 2107.5 10 2107.5 15 2107.5 57.5 2100 82.5 2095 82.5 2065 82.5 2060 82.5 2052.5 57.5 2052.5 15 2052.5 10 2057.5 10 2080 10 {bezier=1}
P 1 14 2095 12.5 2100 12.5 2105 12.5 2105 17.5 2105 37.5 2105 42.5 2100 42.5 2090 42.5 2085 42.5 2085 37.5 2085 17.5 2085 12.5 2090 12.5 2095 12.5 {bezier=1}
P 1 5 2077.5 15 2082.5 15 2082.5 40 2077.5 40 2077.5 15 {}
P 1 10 2080 -135 2105 -135 2115 -125 2115 -95 2105 -85 2055 -85 2045 -95 2045 -125 2055 -135 2080 -135 {bezier=1}
P 1 10 2080 -140 2110 -140 2120 -130 2120 -90 2110 -80 2050 -80 2040 -90 2040 -130 2050 -140 2080 -140 {bezier=1}
P 1 10 2080 -65 2105 -65 2115 -55 2115 -25 2105 -15 2055 -15 2045 -25 2045 -55 2055 -65 2080 -65 {bezier=1}
P 1 10 2080 -70 2110 -70 2120 -60 2120 -20 2110 -10 2050 -10 2040 -20 2040 -60 2050 -70 2080 -70 {bezier=1}
P 1 10 1920 -1875 1945 -1875 1955 -1865 1955 -1835 1945 -1825 1895 -1825 1885 -1835 1885 -1865 1895 -1875 1920 -1875 {bezier=1}
P 1 10 1920 -1880 1950 -1880 1960 -1870 1960 -1830 1950 -1820 1890 -1820 1880 -1830 1880 -1870 1890 -1880 1920 -1880 {bezier=1}
P 1 10 1830 -1445 1855 -1445 1865 -1435 1865 -1405 1855 -1395 1805 -1395 1795 -1405 1795 -1435 1805 -1445 1830 -1445 {bezier=1}
P 1 10 1830 -1450 1860 -1450 1870 -1440 1870 -1400 1860 -1390 1800 -1390 1790 -1400 1790 -1440 1800 -1450 1830 -1450 {bezier=1}
P 1 14 2500 -2850 2522.5 -2850 2527.5 -2850 2527.5 -2845 2527.5 -2802.5 2520 -2777.5 2515 -2777.5 2485 -2777.5 2480 -2777.5 2472.5 -2802.5 2472.5 -2845 2472.5 -2850 2477.5 -2850 2500 -2850 {bezier=1}
P 1 14 2515 -2847.5 2520 -2847.5 2525 -2847.5 2525 -2842.5 2525 -2822.5 2525 -2817.5 2520 -2817.5 2510 -2817.5 2505 -2817.5 2505 -2822.5 2505 -2842.5 2505 -2847.5 2510 -2847.5 2515 -2847.5 {bezier=1}
P 1 5 2497.5 -2845 2502.5 -2845 2502.5 -2820 2497.5 -2820 2497.5 -2845 {}
P 1 10 1290 -795 1315 -795 1325 -785 1325 -755 1315 -745 1265 -745 1255 -755 1255 -785 1265 -795 1290 -795 {bezier=1}
P 1 10 1290 -800 1320 -800 1330 -790 1330 -750 1320 -740 1260 -740 1250 -750 1250 -790 1260 -800 1290 -800 {bezier=1}
P 1 14 1820 -890 1842.5 -890 1847.5 -890 1847.5 -885 1847.5 -842.5 1840 -817.5 1835 -817.5 1805 -817.5 1800 -817.5 1792.5 -842.5 1792.5 -885 1792.5 -890 1797.5 -890 1820 -890 {bezier=1}
P 1 14 1835 -887.5 1840 -887.5 1845 -887.5 1845 -882.5 1845 -862.5 1845 -857.5 1840 -857.5 1830 -857.5 1825 -857.5 1825 -862.5 1825 -882.5 1825 -887.5 1830 -887.5 1835 -887.5 {bezier=1}
P 1 5 1817.5 -885 1822.5 -885 1822.5 -860 1817.5 -860 1817.5 -885 {}
P 1 14 670 -820 692.5 -820 697.5 -820 697.5 -815 697.5 -772.5 690 -747.5 685 -747.5 655 -747.5 650 -747.5 642.5 -772.5 642.5 -815 642.5 -820 647.5 -820 670 -820 {bezier=1}
P 1 14 685 -817.5 690 -817.5 695 -817.5 695 -812.5 695 -792.5 695 -787.5 690 -787.5 680 -787.5 675 -787.5 675 -792.5 675 -812.5 675 -817.5 680 -817.5 685 -817.5 {bezier=1}
P 1 5 667.5 -815 672.5 -815 672.5 -790 667.5 -790 667.5 -815 {}
P 1 14 790 -820 812.5 -820 817.5 -820 817.5 -815 817.5 -772.5 810 -747.5 805 -747.5 775 -747.5 770 -747.5 762.5 -772.5 762.5 -815 762.5 -820 767.5 -820 790 -820 {bezier=1}
P 1 14 805 -817.5 810 -817.5 815 -817.5 815 -812.5 815 -792.5 815 -787.5 810 -787.5 800 -787.5 795 -787.5 795 -792.5 795 -812.5 795 -817.5 800 -817.5 805 -817.5 {bezier=1}
P 1 5 787.5 -815 792.5 -815 792.5 -790 787.5 -790 787.5 -815 {}
P 1 10 790 -725 815 -725 825 -715 825 -685 815 -675 765 -675 755 -685 755 -715 765 -725 790 -725 {bezier=1}
P 1 10 790 -730 820 -730 830 -720 830 -680 820 -670 760 -670 750 -680 750 -720 760 -730 790 -730 {bezier=1}
P 1 14 1650 510 1672.5 510 1677.5 510 1677.5 515 1677.5 557.5 1670 582.5 1665 582.5 1635 582.5 1630 582.5 1622.5 557.5 1622.5 515 1622.5 510 1627.5 510 1650 510 {bezier=1}
P 1 14 1635 512.5 1630 512.5 1625 512.5 1625 517.5 1625 537.5 1625 542.5 1630 542.5 1640 542.5 1645 542.5 1645 537.5 1645 517.5 1645 512.5 1640 512.5 1635 512.5 {bezier=1}
P 1 5 1647.5 515 1652.5 515 1652.5 540 1647.5 540 1647.5 515 {}
P 1 10 1650 435 1675 435 1685 445 1685 475 1675 485 1625 485 1615 475 1615 445 1625 435 1650 435 {bezier=1}
P 1 10 1650 430 1680 430 1690 440 1690 480 1680 490 1620 490 1610 480 1610 440 1620 430 1650 430 {bezier=1}
P 1 10 1920 -1305 1945 -1305 1955 -1295 1955 -1265 1945 -1255 1895 -1255 1885 -1265 1885 -1295 1895 -1305 1920 -1305 {bezier=1}
P 1 10 1920 -1310 1950 -1310 1960 -1300 1960 -1260 1950 -1250 1890 -1250 1880 -1260 1880 -1300 1890 -1310 1920 -1310 {bezier=1}
P 1 14 460 -4310 482.5 -4310 487.5 -4310 487.5 -4305 487.5 -4262.5 480 -4237.5 475 -4237.5 445 -4237.5 440 -4237.5 432.5 -4262.5 432.5 -4305 432.5 -4310 437.5 -4310 460 -4310 {bezier=1}
P 1 14 475 -4307.5 480 -4307.5 485 -4307.5 485 -4302.5 485 -4282.5 485 -4277.5 480 -4277.5 470 -4277.5 465 -4277.5 465 -4282.5 465 -4302.5 465 -4307.5 470 -4307.5 475 -4307.5 {bezier=1}
P 1 5 457.5 -4305 462.5 -4305 462.5 -4280 457.5 -4280 457.5 -4305 {}
P 1 14 1000 -4490 1022.5 -4490 1027.5 -4490 1027.5 -4485 1027.5 -4442.5 1020 -4417.5 1015 -4417.5 985 -4417.5 980 -4417.5 972.5 -4442.5 972.5 -4485 972.5 -4490 977.5 -4490 1000 -4490 {bezier=1}
P 1 14 1015 -4487.5 1020 -4487.5 1025 -4487.5 1025 -4482.5 1025 -4462.5 1025 -4457.5 1020 -4457.5 1010 -4457.5 1005 -4457.5 1005 -4462.5 1005 -4482.5 1005 -4487.5 1010 -4487.5 1015 -4487.5 {bezier=1}
P 1 5 997.5 -4485 1002.5 -4485 1002.5 -4460 997.5 -4460 997.5 -4485 {}
P 1 14 2010 -4280 2032.5 -4280 2037.5 -4280 2037.5 -4275 2037.5 -4232.5 2030 -4207.5 2025 -4207.5 1995 -4207.5 1990 -4207.5 1982.5 -4232.5 1982.5 -4275 1982.5 -4280 1987.5 -4280 2010 -4280 {bezier=1}
P 1 14 2025 -4277.5 2030 -4277.5 2035 -4277.5 2035 -4272.5 2035 -4252.5 2035 -4247.5 2030 -4247.5 2020 -4247.5 2015 -4247.5 2015 -4252.5 2015 -4272.5 2015 -4277.5 2020 -4277.5 2025 -4277.5 {bezier=1}
P 1 5 2007.5 -4275 2012.5 -4275 2012.5 -4250 2007.5 -4250 2007.5 -4275 {}
P 1 14 2580 -4280 2602.5 -4280 2607.5 -4280 2607.5 -4275 2607.5 -4232.5 2600 -4207.5 2595 -4207.5 2565 -4207.5 2560 -4207.5 2552.5 -4232.5 2552.5 -4275 2552.5 -4280 2557.5 -4280 2580 -4280 {bezier=1}
P 1 14 2595 -4277.5 2600 -4277.5 2605 -4277.5 2605 -4272.5 2605 -4252.5 2605 -4247.5 2600 -4247.5 2590 -4247.5 2585 -4247.5 2585 -4252.5 2585 -4272.5 2585 -4277.5 2590 -4277.5 2595 -4277.5 {bezier=1}
P 1 5 2577.5 -4275 2582.5 -4275 2582.5 -4250 2577.5 -4250 2577.5 -4275 {}
P 1 14 2280 -5070 2302.5 -5070 2307.5 -5070 2307.5 -5065 2307.5 -5022.5 2300 -4997.5 2295 -4997.5 2265 -4997.5 2260 -4997.5 2252.5 -5022.5 2252.5 -5065 2252.5 -5070 2257.5 -5070 2280 -5070 {bezier=1}
P 1 14 2295 -5067.5 2300 -5067.5 2305 -5067.5 2305 -5062.5 2305 -5042.5 2305 -5037.5 2300 -5037.5 2290 -5037.5 2285 -5037.5 2285 -5042.5 2285 -5062.5 2285 -5067.5 2290 -5067.5 2295 -5067.5 {bezier=1}
P 1 5 2277.5 -5065 2282.5 -5065 2282.5 -5040 2277.5 -5040 2277.5 -5065 {}
P 1 10 2370 -5055 2395 -5055 2405 -5045 2405 -5015 2395 -5005 2345 -5005 2335 -5015 2335 -5045 2345 -5055 2370 -5055 {bezier=1}
P 1 10 2370 -5060 2400 -5060 2410 -5050 2410 -5010 2400 -5000 2340 -5000 2330 -5010 2330 -5050 2340 -5060 2370 -5060 {bezier=1}
P 1 14 1980 -3180 2002.5 -3180 2007.5 -3180 2007.5 -3175 2007.5 -3132.5 2000 -3107.5 1995 -3107.5 1965 -3107.5 1960 -3107.5 1952.5 -3132.5 1952.5 -3175 1952.5 -3180 1957.5 -3180 1980 -3180 {bezier=1}
P 1 14 1995 -3177.5 2000 -3177.5 2005 -3177.5 2005 -3172.5 2005 -3152.5 2005 -3147.5 2000 -3147.5 1990 -3147.5 1985 -3147.5 1985 -3152.5 1985 -3172.5 1985 -3177.5 1990 -3177.5 1995 -3177.5 {bezier=1}
P 1 5 1977.5 -3175 1982.5 -3175 1982.5 -3150 1977.5 -3150 1977.5 -3175 {}
P 1 10 1980 -3335 2005 -3335 2015 -3325 2015 -3295 2005 -3285 1955 -3285 1945 -3295 1945 -3325 1955 -3335 1980 -3335 {bezier=1}
P 1 10 1980 -3340 2010 -3340 2020 -3330 2020 -3290 2010 -3280 1950 -3280 1940 -3290 1940 -3330 1950 -3340 1980 -3340 {bezier=1}
P 1 10 1980 -3255 2005 -3255 2015 -3245 2015 -3215 2005 -3205 1955 -3205 1945 -3215 1945 -3245 1955 -3255 1980 -3255 {bezier=1}
P 1 10 1980 -3260 2010 -3260 2020 -3250 2020 -3210 2010 -3200 1950 -3200 1940 -3210 1940 -3250 1950 -3260 1980 -3260 {bezier=1}
P 1 14 2340 -1480 2362.5 -1480 2367.5 -1480 2367.5 -1475 2367.5 -1432.5 2360 -1407.5 2355 -1407.5 2325 -1407.5 2320 -1407.5 2312.5 -1432.5 2312.5 -1475 2312.5 -1480 2317.5 -1480 2340 -1480 {bezier=1}
P 1 14 2355 -1477.5 2360 -1477.5 2365 -1477.5 2365 -1472.5 2365 -1452.5 2365 -1447.5 2360 -1447.5 2350 -1447.5 2345 -1447.5 2345 -1452.5 2345 -1472.5 2345 -1477.5 2350 -1477.5 2355 -1477.5 {bezier=1}
P 1 5 2337.5 -1475 2342.5 -1475 2342.5 -1450 2337.5 -1450 2337.5 -1475 {}
P 1 14 810 -1600 832.5 -1600 837.5 -1600 837.5 -1595 837.5 -1552.5 830 -1527.5 825 -1527.5 795 -1527.5 790 -1527.5 782.5 -1552.5 782.5 -1595 782.5 -1600 787.5 -1600 810 -1600 {bezier=1}
P 1 14 825 -1597.5 830 -1597.5 835 -1597.5 835 -1592.5 835 -1572.5 835 -1567.5 830 -1567.5 820 -1567.5 815 -1567.5 815 -1572.5 815 -1592.5 815 -1597.5 820 -1597.5 825 -1597.5 {bezier=1}
P 1 5 807.5 -1595 812.5 -1595 812.5 -1570 807.5 -1570 807.5 -1595 {}
P 1 14 1350 -1580 1372.5 -1580 1377.5 -1580 1377.5 -1575 1377.5 -1532.5 1370 -1507.5 1365 -1507.5 1335 -1507.5 1330 -1507.5 1322.5 -1532.5 1322.5 -1575 1322.5 -1580 1327.5 -1580 1350 -1580 {bezier=1}
P 1 14 1365 -1577.5 1370 -1577.5 1375 -1577.5 1375 -1572.5 1375 -1552.5 1375 -1547.5 1370 -1547.5 1360 -1547.5 1355 -1547.5 1355 -1552.5 1355 -1572.5 1355 -1577.5 1360 -1577.5 1365 -1577.5 {bezier=1}
P 1 5 1347.5 -1575 1352.5 -1575 1352.5 -1550 1347.5 -1550 1347.5 -1575 {}
P 1 14 1260 -1200 1282.5 -1200 1287.5 -1200 1287.5 -1195 1287.5 -1152.5 1280 -1127.5 1275 -1127.5 1245 -1127.5 1240 -1127.5 1232.5 -1152.5 1232.5 -1195 1232.5 -1200 1237.5 -1200 1260 -1200 {bezier=1}
P 1 14 1275 -1197.5 1280 -1197.5 1285 -1197.5 1285 -1192.5 1285 -1172.5 1285 -1167.5 1280 -1167.5 1270 -1167.5 1265 -1167.5 1265 -1172.5 1265 -1192.5 1265 -1197.5 1270 -1197.5 1275 -1197.5 {bezier=1}
P 1 5 1257.5 -1195 1262.5 -1195 1262.5 -1170 1257.5 -1170 1257.5 -1195 {}
P 1 14 2520 -1150 2542.5 -1150 2547.5 -1150 2547.5 -1145 2547.5 -1102.5 2540 -1077.5 2535 -1077.5 2505 -1077.5 2500 -1077.5 2492.5 -1102.5 2492.5 -1145 2492.5 -1150 2497.5 -1150 2520 -1150 {bezier=1}
P 1 14 2535 -1147.5 2540 -1147.5 2545 -1147.5 2545 -1142.5 2545 -1122.5 2545 -1117.5 2540 -1117.5 2530 -1117.5 2525 -1117.5 2525 -1122.5 2525 -1142.5 2525 -1147.5 2530 -1147.5 2535 -1147.5 {bezier=1}
P 1 5 2517.5 -1145 2522.5 -1145 2522.5 -1120 2517.5 -1120 2517.5 -1145 {}
P 1 14 2480 260 2502.5 260 2507.5 260 2507.5 265 2507.5 307.5 2500 332.5 2495 332.5 2465 332.5 2460 332.5 2452.5 307.5 2452.5 265 2452.5 260 2457.5 260 2480 260 {bezier=1}
P 1 14 2465 262.5 2460 262.5 2455 262.5 2455 267.5 2455 287.5 2455 292.5 2460 292.5 2470 292.5 2475 292.5 2475 287.5 2475 267.5 2475 262.5 2470 262.5 2465 262.5 {bezier=1}
P 1 5 2477.5 265 2482.5 265 2482.5 290 2477.5 290 2477.5 265 {}
P 1 14 460 -3970 482.5 -3970 487.5 -3970 487.5 -3965 487.5 -3922.5 480 -3897.5 475 -3897.5 445 -3897.5 440 -3897.5 432.5 -3922.5 432.5 -3965 432.5 -3970 437.5 -3970 460 -3970 {bezier=1}
P 1 14 475 -3967.5 480 -3967.5 485 -3967.5 485 -3962.5 485 -3942.5 485 -3937.5 480 -3937.5 470 -3937.5 465 -3937.5 465 -3942.5 465 -3962.5 465 -3967.5 470 -3967.5 475 -3967.5 {bezier=1}
P 1 5 457.5 -3965 462.5 -3965 462.5 -3940 457.5 -3940 457.5 -3965 {}
P 1 10 2270 -4095 2295 -4095 2305 -4085 2305 -4055 2295 -4045 2245 -4045 2235 -4055 2235 -4085 2245 -4095 2270 -4095 {bezier=1}
P 1 10 2270 -4100 2300 -4100 2310 -4090 2310 -4050 2300 -4040 2240 -4040 2230 -4050 2230 -4090 2240 -4100 2270 -4100 {bezier=1}
P 1 14 820 -4840 842.5 -4840 847.5 -4840 847.5 -4835 847.5 -4792.5 840 -4767.5 835 -4767.5 805 -4767.5 800 -4767.5 792.5 -4792.5 792.5 -4835 792.5 -4840 797.5 -4840 820 -4840 {bezier=1}
P 1 14 835 -4837.5 840 -4837.5 845 -4837.5 845 -4832.5 845 -4812.5 845 -4807.5 840 -4807.5 830 -4807.5 825 -4807.5 825 -4812.5 825 -4832.5 825 -4837.5 830 -4837.5 835 -4837.5 {bezier=1}
P 1 5 817.5 -4835 822.5 -4835 822.5 -4810 817.5 -4810 817.5 -4835 {}
P 1 14 480 -7000 502.5 -7000 507.5 -7000 507.5 -6995 507.5 -6952.5 500 -6927.5 495 -6927.5 465 -6927.5 460 -6927.5 452.5 -6952.5 452.5 -6995 452.5 -7000 457.5 -7000 480 -7000 {bezier=1}
P 1 14 495 -6997.5 500 -6997.5 505 -6997.5 505 -6992.5 505 -6972.5 505 -6967.5 500 -6967.5 490 -6967.5 485 -6967.5 485 -6972.5 485 -6992.5 485 -6997.5 490 -6997.5 495 -6997.5 {bezier=1}
P 1 5 477.5 -6995 482.5 -6995 482.5 -6970 477.5 -6970 477.5 -6995 {}
P 1 14 670 -7110 692.5 -7110 697.5 -7110 697.5 -7105 697.5 -7062.5 690 -7037.5 685 -7037.5 655 -7037.5 650 -7037.5 642.5 -7062.5 642.5 -7105 642.5 -7110 647.5 -7110 670 -7110 {bezier=1}
P 1 14 685 -7107.5 690 -7107.5 695 -7107.5 695 -7102.5 695 -7082.5 695 -7077.5 690 -7077.5 680 -7077.5 675 -7077.5 675 -7082.5 675 -7102.5 675 -7107.5 680 -7107.5 685 -7107.5 {bezier=1}
P 1 5 667.5 -7105 672.5 -7105 672.5 -7080 667.5 -7080 667.5 -7105 {}
P 1 14 900 -7070 922.5 -7070 927.5 -7070 927.5 -7065 927.5 -7022.5 920 -6997.5 915 -6997.5 885 -6997.5 880 -6997.5 872.5 -7022.5 872.5 -7065 872.5 -7070 877.5 -7070 900 -7070 {bezier=1}
P 1 14 915 -7067.5 920 -7067.5 925 -7067.5 925 -7062.5 925 -7042.5 925 -7037.5 920 -7037.5 910 -7037.5 905 -7037.5 905 -7042.5 905 -7062.5 905 -7067.5 910 -7067.5 915 -7067.5 {bezier=1}
P 1 5 897.5 -7065 902.5 -7065 902.5 -7040 897.5 -7040 897.5 -7065 {}
P 1 14 1110 -7110 1132.5 -7110 1137.5 -7110 1137.5 -7105 1137.5 -7062.5 1130 -7037.5 1125 -7037.5 1095 -7037.5 1090 -7037.5 1082.5 -7062.5 1082.5 -7105 1082.5 -7110 1087.5 -7110 1110 -7110 {bezier=1}
P 1 14 1125 -7107.5 1130 -7107.5 1135 -7107.5 1135 -7102.5 1135 -7082.5 1135 -7077.5 1130 -7077.5 1120 -7077.5 1115 -7077.5 1115 -7082.5 1115 -7102.5 1115 -7107.5 1120 -7107.5 1125 -7107.5 {bezier=1}
P 1 5 1107.5 -7105 1112.5 -7105 1112.5 -7080 1107.5 -7080 1107.5 -7105 {}
P 1 14 1380 -7110 1402.5 -7110 1407.5 -7110 1407.5 -7105 1407.5 -7062.5 1400 -7037.5 1395 -7037.5 1365 -7037.5 1360 -7037.5 1352.5 -7062.5 1352.5 -7105 1352.5 -7110 1357.5 -7110 1380 -7110 {bezier=1}
P 1 14 1395 -7107.5 1400 -7107.5 1405 -7107.5 1405 -7102.5 1405 -7082.5 1405 -7077.5 1400 -7077.5 1390 -7077.5 1385 -7077.5 1385 -7082.5 1385 -7102.5 1385 -7107.5 1390 -7107.5 1395 -7107.5 {bezier=1}
P 1 5 1377.5 -7105 1382.5 -7105 1382.5 -7080 1377.5 -7080 1377.5 -7105 {}
P 1 14 1720 -6970 1742.5 -6970 1747.5 -6970 1747.5 -6965 1747.5 -6922.5 1740 -6897.5 1735 -6897.5 1705 -6897.5 1700 -6897.5 1692.5 -6922.5 1692.5 -6965 1692.5 -6970 1697.5 -6970 1720 -6970 {bezier=1}
P 1 14 1735 -6967.5 1740 -6967.5 1745 -6967.5 1745 -6962.5 1745 -6942.5 1745 -6937.5 1740 -6937.5 1730 -6937.5 1725 -6937.5 1725 -6942.5 1725 -6962.5 1725 -6967.5 1730 -6967.5 1735 -6967.5 {bezier=1}
P 1 5 1717.5 -6965 1722.5 -6965 1722.5 -6940 1717.5 -6940 1717.5 -6965 {}
P 1 14 1970 -7080 1992.5 -7080 1997.5 -7080 1997.5 -7075 1997.5 -7032.5 1990 -7007.5 1985 -7007.5 1955 -7007.5 1950 -7007.5 1942.5 -7032.5 1942.5 -7075 1942.5 -7080 1947.5 -7080 1970 -7080 {bezier=1}
P 1 14 1985 -7077.5 1990 -7077.5 1995 -7077.5 1995 -7072.5 1995 -7052.5 1995 -7047.5 1990 -7047.5 1980 -7047.5 1975 -7047.5 1975 -7052.5 1975 -7072.5 1975 -7077.5 1980 -7077.5 1985 -7077.5 {bezier=1}
P 1 5 1967.5 -7075 1972.5 -7075 1972.5 -7050 1967.5 -7050 1967.5 -7075 {}
P 1 14 2590 -7080 2612.5 -7080 2617.5 -7080 2617.5 -7075 2617.5 -7032.5 2610 -7007.5 2605 -7007.5 2575 -7007.5 2570 -7007.5 2562.5 -7032.5 2562.5 -7075 2562.5 -7080 2567.5 -7080 2590 -7080 {bezier=1}
P 1 14 2605 -7077.5 2610 -7077.5 2615 -7077.5 2615 -7072.5 2615 -7052.5 2615 -7047.5 2610 -7047.5 2600 -7047.5 2595 -7047.5 2595 -7052.5 2595 -7072.5 2595 -7077.5 2600 -7077.5 2605 -7077.5 {bezier=1}
P 1 5 2587.5 -7075 2592.5 -7075 2592.5 -7050 2587.5 -7050 2587.5 -7075 {}
P 1 14 2250 -7080 2272.5 -7080 2277.5 -7080 2277.5 -7075 2277.5 -7032.5 2270 -7007.5 2265 -7007.5 2235 -7007.5 2230 -7007.5 2222.5 -7032.5 2222.5 -7075 2222.5 -7080 2227.5 -7080 2250 -7080 {bezier=1}
P 1 14 2265 -7077.5 2270 -7077.5 2275 -7077.5 2275 -7072.5 2275 -7052.5 2275 -7047.5 2270 -7047.5 2260 -7047.5 2255 -7047.5 2255 -7052.5 2255 -7072.5 2255 -7077.5 2260 -7077.5 2265 -7077.5 {bezier=1}
P 1 5 2247.5 -7075 2252.5 -7075 2252.5 -7050 2247.5 -7050 2247.5 -7075 {}
P 2 7 897.5 -5190 893.75 -5195 885 -5195 888.75 -5190 885 -5185 893.75 -5185 897.5 -5190 {fill=true}
P 2 7 1437.5 -5190 1433.75 -5195 1425 -5195 1428.75 -5190 1425 -5185 1433.75 -5185 1437.5 -5190 {fill=true}
P 2 7 2277.5 -5190 2273.75 -5195 2265 -5195 2268.75 -5190 2265 -5185 2273.75 -5185 2277.5 -5190 {fill=true}
P 2 7 2030 -470 2020 -480 2030 -480 2030 -480 2010 -490 2020 -470 2020 -480 {}
P 2 7 1520 -370 1510 -380 1520 -380 1520 -380 1500 -390 1510 -370 1510 -380 {}
P 2 7 2030 -90 2020 -100 2030 -100 2030 -100 2010 -110 2020 -90 2020 -100 {}
P 2 7 1520 10 1510 0 1520 0 1520 0 1500 -10 1510 10 1510 0 {}
P 3 6 1280 -1050 1280 -1060 1270 -1060 1280 -1080 1290 -1060 1280 -1060 {}
P 3 6 740 -1050 740 -1060 730 -1060 740 -1080 750 -1060 740 -1060 {}
P 5 7 1105 -8220 1101.25 -8225 1092.5 -8225 1096.25 -8220 1092.5 -8215 1101.25 -8215 1105 -8220 {fill=true}
P 5 7 1427.5 -8250 1423.75 -8255 1415 -8255 1418.75 -8250 1415 -8245 1423.75 -8245 1427.5 -8250 {fill=true}
P 5 7 1645 -8220 1641.25 -8225 1632.5 -8225 1636.25 -8220 1632.5 -8215 1641.25 -8215 1645 -8220 {fill=true}
P 5 7 1967.5 -8250 1963.75 -8255 1955 -8255 1958.75 -8250 1955 -8245 1963.75 -8245 1967.5 -8250 {fill=true}
P 5 7 575 -8220 571.25 -8225 562.5 -8225 566.25 -8220 562.5 -8215 571.25 -8215 575 -8220 {fill=true}
P 5 7 897.5 -8250 893.75 -8255 885 -8255 888.75 -8250 885 -8245 893.75 -8245 897.5 -8250 {fill=true}
P 5 7 575 -7760 571.25 -7765 562.5 -7765 566.25 -7760 562.5 -7755 571.25 -7755 575 -7760 {fill=true}
P 5 7 897.5 -7790 893.75 -7795 885 -7795 888.75 -7790 885 -7785 893.75 -7785 897.5 -7790 {fill=true}
P 5 7 1115 -7760 1111.25 -7765 1102.5 -7765 1106.25 -7760 1102.5 -7755 1111.25 -7755 1115 -7760 {fill=true}
P 5 7 1437.5 -7790 1433.75 -7795 1425 -7795 1428.75 -7790 1425 -7785 1433.75 -7785 1437.5 -7790 {fill=true}
P 5 7 575 -6140 571.25 -6145 562.5 -6145 566.25 -6140 562.5 -6135 571.25 -6135 575 -6140 {fill=true}
P 5 7 897.5 -6170 893.75 -6175 885 -6175 888.75 -6170 885 -6165 893.75 -6165 897.5 -6170 {fill=true}
P 5 7 1115 -6140 1111.25 -6145 1102.5 -6145 1106.25 -6140 1102.5 -6135 1111.25 -6135 1115 -6140 {fill=true}
P 5 7 1437.5 -6170 1433.75 -6175 1425 -6175 1428.75 -6170 1425 -6165 1433.75 -6165 1437.5 -6170 {fill=true}
P 5 7 575 -5650 571.25 -5655 562.5 -5655 566.25 -5650 562.5 -5645 571.25 -5645 575 -5650 {fill=true}
P 5 7 897.5 -5680 893.75 -5685 885 -5685 888.75 -5680 885 -5675 893.75 -5675 897.5 -5680 {fill=true}
P 5 7 1115 -5650 1111.25 -5655 1102.5 -5655 1106.25 -5650 1102.5 -5645 1111.25 -5645 1115 -5650 {fill=true}
P 5 7 1437.5 -5680 1433.75 -5685 1425 -5685 1428.75 -5680 1425 -5675 1433.75 -5675 1437.5 -5680 {fill=true}
P 5 7 575 -5160 571.25 -5165 562.5 -5165 566.25 -5160 562.5 -5155 571.25 -5155 575 -5160 {fill=true}
P 5 7 1765 -5160 1761.25 -5165 1752.5 -5165 1756.25 -5160 1752.5 -5155 1761.25 -5155 1765 -5160 {fill=true}
P 5 7 1115 -5160 1111.25 -5165 1102.5 -5165 1106.25 -5160 1102.5 -5155 1111.25 -5155 1115 -5160 {fill=true}
P 5 7 1105 -7390 1101.25 -7395 1092.5 -7395 1096.25 -7390 1092.5 -7385 1101.25 -7385 1105 -7390 {fill=true}
P 5 7 1427.5 -7420 1423.75 -7425 1415 -7425 1418.75 -7420 1415 -7415 1423.75 -7415 1427.5 -7420 {fill=true}
P 5 7 575 -7390 571.25 -7395 562.5 -7395 566.25 -7390 562.5 -7385 571.25 -7385 575 -7390 {fill=true}
P 5 7 897.5 -7420 893.75 -7425 885 -7425 888.75 -7420 885 -7415 893.75 -7415 897.5 -7420 {fill=true}
P 5 7 1605 -7390 1601.25 -7395 1592.5 -7395 1596.25 -7390 1592.5 -7385 1601.25 -7385 1605 -7390 {fill=true}
P 5 7 1927.5 -7420 1923.75 -7425 1915 -7425 1918.75 -7420 1915 -7415 1923.75 -7415 1927.5 -7420 {fill=true}
P 5 7 1645 -8690 1641.25 -8695 1632.5 -8695 1636.25 -8690 1632.5 -8685 1641.25 -8685 1645 -8690 {fill=true}
P 5 7 1967.5 -8720 1963.75 -8725 1955 -8725 1958.75 -8720 1955 -8715 1963.75 -8715 1967.5 -8720 {fill=true}
P 5 7 575 -8690 571.25 -8695 562.5 -8695 566.25 -8690 562.5 -8685 571.25 -8685 575 -8690 {fill=true}
P 5 7 897.5 -8720 893.75 -8725 885 -8725 888.75 -8720 885 -8715 893.75 -8715 897.5 -8720 {fill=true}
P 5 7 2105 -8690 2101.25 -8695 2092.5 -8695 2096.25 -8690 2092.5 -8685 2101.25 -8685 2105 -8690 {fill=true}
P 5 7 2427.5 -8720 2423.75 -8725 2415 -8725 2418.75 -8720 2415 -8715 2423.75 -8715 2427.5 -8720 {fill=true}
P 5 7 595 -4720 591.25 -4725 582.5 -4725 586.25 -4720 582.5 -4715 591.25 -4715 595 -4720 {fill=true}
P 5 7 917.5 -4750 913.75 -4755 905 -4755 908.75 -4750 905 -4745 913.75 -4745 917.5 -4750 {fill=true}
P 5 7 1135 -4720 1131.25 -4725 1122.5 -4725 1126.25 -4720 1122.5 -4715 1131.25 -4715 1135 -4720 {fill=true}
P 5 7 1457.5 -4750 1453.75 -4755 1445 -4755 1448.75 -4750 1445 -4745 1453.75 -4745 1457.5 -4750 {fill=true}
P 5 7 1695 -4720 1691.25 -4725 1682.5 -4725 1686.25 -4720 1682.5 -4715 1691.25 -4715 1695 -4720 {fill=true}
P 5 7 2017.5 -4750 2013.75 -4755 2005 -4755 2008.75 -4750 2005 -4745 2013.75 -4745 2017.5 -4750 {fill=true}
P 5 7 2265 -4720 2261.25 -4725 2252.5 -4725 2256.25 -4720 2252.5 -4715 2261.25 -4715 2265 -4720 {fill=true}
P 5 7 2587.5 -4750 2583.75 -4755 2575 -4755 2578.75 -4750 2575 -4745 2583.75 -4745 2587.5 -4750 {fill=true}
P 5 7 595 -6550 591.25 -6555 582.5 -6555 586.25 -6550 582.5 -6545 591.25 -6545 595 -6550 {fill=true}
P 5 7 917.5 -6580 913.75 -6585 905 -6585 908.75 -6580 905 -6575 913.75 -6575 917.5 -6580 {fill=true}
P 5 7 1135 -6550 1131.25 -6555 1122.5 -6555 1126.25 -6550 1122.5 -6545 1131.25 -6545 1135 -6550 {fill=true}
P 5 7 1457.5 -6580 1453.75 -6585 1445 -6585 1448.75 -6580 1445 -6575 1453.75 -6575 1457.5 -6580 {fill=true}
P 5 7 2265 -6550 2261.25 -6555 2252.5 -6555 2256.25 -6550 2252.5 -6545 2261.25 -6545 2265 -6550 {fill=true}
P 5 7 2587.5 -6580 2583.75 -6585 2575 -6585 2578.75 -6580 2575 -6575 2583.75 -6575 2587.5 -6580 {fill=true}
P 5 7 595 -4340 591.25 -4345 582.5 -4345 586.25 -4340 582.5 -4335 591.25 -4335 595 -4340 {fill=true}
P 5 7 917.5 -4370 913.75 -4375 905 -4375 908.75 -4370 905 -4365 913.75 -4365 917.5 -4370 {fill=true}
P 5 7 1135 -3960 1131.25 -3965 1122.5 -3965 1126.25 -3960 1122.5 -3955 1131.25 -3955 1135 -3960 {fill=true}
P 5 7 1457.5 -3990 1453.75 -3995 1445 -3995 1448.75 -3990 1445 -3985 1453.75 -3985 1457.5 -3990 {fill=true}
P 5 7 2235 -3960 2231.25 -3965 2222.5 -3965 2226.25 -3960 2222.5 -3955 2231.25 -3955 2235 -3960 {fill=true}
P 5 7 2557.5 -3990 2553.75 -3995 2545 -3995 2548.75 -3990 2545 -3985 2553.75 -3985 2557.5 -3990 {fill=true}
P 5 7 1675 -3960 1671.25 -3965 1662.5 -3965 1666.25 -3960 1662.5 -3955 1671.25 -3955 1675 -3960 {fill=true}
P 5 7 1997.5 -3990 1993.75 -3995 1985 -3995 1988.75 -3990 1985 -3985 1993.75 -3985 1997.5 -3990 {fill=true}
P 5 7 1105 -8690 1101.25 -8695 1092.5 -8695 1096.25 -8690 1092.5 -8685 1101.25 -8685 1105 -8690 {fill=true}
P 5 7 1427.5 -8720 1423.75 -8725 1415 -8725 1418.75 -8720 1415 -8715 1423.75 -8715 1427.5 -8720 {fill=true}
P 5 7 655 410 651.25 405 642.5 405 646.25 410 642.5 415 651.25 415 655 410 {fill=true}
P 5 7 977.5 380 973.75 375 965 375 968.75 380 965 385 973.75 385 977.5 380 {fill=true}
P 5 7 1305 410 1301.25 405 1292.5 405 1296.25 410 1292.5 415 1301.25 415 1305 410 {fill=true}
P 5 7 1627.5 380 1623.75 375 1615 375 1618.75 380 1615 385 1623.75 385 1627.5 380 {fill=true}
P 5 7 1135 -4340 1131.25 -4345 1122.5 -4345 1126.25 -4340 1122.5 -4335 1131.25 -4335 1135 -4340 {fill=true}
P 5 7 1457.5 -4370 1453.75 -4375 1445 -4375 1448.75 -4370 1445 -4365 1453.75 -4365 1457.5 -4370 {fill=true}
P 5 7 1695 -4340 1691.25 -4345 1682.5 -4345 1686.25 -4340 1682.5 -4335 1691.25 -4335 1695 -4340 {fill=true}
P 5 7 2017.5 -4370 2013.75 -4375 2005 -4375 2008.75 -4370 2005 -4365 2013.75 -4365 2017.5 -4370 {fill=true}
P 5 7 2265 -4340 2261.25 -4345 2252.5 -4345 2256.25 -4340 2252.5 -4335 2261.25 -4335 2265 -4340 {fill=true}
P 5 7 2587.5 -4370 2583.75 -4375 2575 -4375 2578.75 -4370 2575 -4365 2583.75 -4365 2587.5 -4370 {fill=true}
P 5 7 1865 410 1861.25 405 1852.5 405 1856.25 410 1852.5 415 1861.25 415 1865 410 {fill=true}
P 5 7 2187.5 380 2183.75 375 2175 375 2178.75 380 2175 385 2183.75 385 2187.5 380 {fill=true}
P 5 7 595 -3960 591.25 -3965 582.5 -3965 586.25 -3960 582.5 -3955 591.25 -3955 595 -3960 {fill=true}
P 5 7 917.5 -3990 913.75 -3995 905 -3995 908.75 -3990 905 -3985 913.75 -3985 917.5 -3990 {fill=true}
P 7 14 905 -8077.5 910 -8077.5 915 -8077.5 915 -8072.5 915 -8052.5 915 -8047.5 910 -8047.5 900 -8047.5 895 -8047.5 895 -8052.5 895 -8072.5 895 -8077.5 900 -8077.5 905 -8077.5 {fill=1
bezier=1}
P 7 14 1335 -8077.5 1340 -8077.5 1345 -8077.5 1345 -8072.5 1345 -8052.5 1345 -8047.5 1340 -8047.5 1330 -8047.5 1325 -8047.5 1325 -8052.5 1325 -8072.5 1325 -8077.5 1330 -8077.5 1335 -8077.5 {fill=1
bezier=1}
P 7 14 1405 -7887.5 1410 -7887.5 1415 -7887.5 1415 -7882.5 1415 -7862.5 1415 -7857.5 1410 -7857.5 1400 -7857.5 1395 -7857.5 1395 -7862.5 1395 -7882.5 1395 -7887.5 1400 -7887.5 1405 -7887.5 {fill=1
bezier=1}
P 7 14 1425 -6277.5 1430 -6277.5 1435 -6277.5 1435 -6272.5 1435 -6252.5 1435 -6247.5 1430 -6247.5 1420 -6247.5 1415 -6247.5 1415 -6252.5 1415 -6272.5 1415 -6277.5 1420 -6277.5 1425 -6277.5 {fill=1
bezier=1}
P 7 14 1425 -5787.5 1430 -5787.5 1435 -5787.5 1435 -5782.5 1435 -5762.5 1435 -5757.5 1430 -5757.5 1420 -5757.5 1415 -5757.5 1415 -5762.5 1415 -5782.5 1415 -5787.5 1420 -5787.5 1425 -5787.5 {fill=1
bezier=1}
P 7 14 935 -5057.5 940 -5057.5 945 -5057.5 945 -5052.5 945 -5032.5 945 -5027.5 940 -5027.5 930 -5027.5 925 -5027.5 925 -5032.5 925 -5052.5 925 -5057.5 930 -5057.5 935 -5057.5 {fill=1
bezier=1}
P 7 14 1415 -5067.5 1420 -5067.5 1425 -5067.5 1425 -5062.5 1425 -5042.5 1425 -5037.5 1420 -5037.5 1410 -5037.5 1405 -5037.5 1405 -5042.5 1405 -5062.5 1405 -5067.5 1410 -5067.5 1415 -5067.5 {fill=1
bezier=1}
P 7 14 905 -7247.5 910 -7247.5 915 -7247.5 915 -7242.5 915 -7222.5 915 -7217.5 910 -7217.5 900 -7217.5 895 -7217.5 895 -7222.5 895 -7242.5 895 -7247.5 900 -7247.5 905 -7247.5 {fill=1
bezier=1}
P 7 14 905 -8547.5 910 -8547.5 915 -8547.5 915 -8542.5 915 -8522.5 915 -8517.5 910 -8517.5 900 -8517.5 895 -8517.5 895 -8522.5 895 -8542.5 895 -8547.5 900 -8547.5 905 -8547.5 {fill=1
bezier=1}
P 7 14 1615 -8537.5 1620 -8537.5 1625 -8537.5 1625 -8532.5 1625 -8512.5 1625 -8507.5 1620 -8507.5 1610 -8507.5 1605 -8507.5 1605 -8512.5 1605 -8532.5 1605 -8537.5 1610 -8537.5 1615 -8537.5 {fill=1
bezier=1}
P 7 14 2395 -8527.5 2400 -8527.5 2405 -8527.5 2405 -8522.5 2405 -8502.5 2405 -8497.5 2400 -8497.5 2390 -8497.5 2385 -8497.5 2385 -8502.5 2385 -8522.5 2385 -8527.5 2390 -8527.5 2395 -8527.5 {fill=1
bezier=1}
P 7 14 1475 -4867.5 1480 -4867.5 1485 -4867.5 1485 -4862.5 1485 -4842.5 1485 -4837.5 1480 -4837.5 1470 -4837.5 1465 -4837.5 1465 -4842.5 1465 -4862.5 1465 -4867.5 1470 -4867.5 1475 -4867.5 {fill=1
bezier=1}
P 7 14 1925 -4937.5 1930 -4937.5 1935 -4937.5 1935 -4932.5 1935 -4912.5 1935 -4907.5 1930 -4907.5 1920 -4907.5 1915 -4907.5 1915 -4912.5 1915 -4932.5 1915 -4937.5 1920 -4937.5 1925 -4937.5 {fill=1
bezier=1}
P 7 14 675 -6667.5 680 -6667.5 685 -6667.5 685 -6662.5 685 -6642.5 685 -6637.5 680 -6637.5 670 -6637.5 665 -6637.5 665 -6642.5 665 -6662.5 665 -6667.5 670 -6667.5 675 -6667.5 {fill=1
bezier=1}
P 7 14 1335 -6687.5 1340 -6687.5 1345 -6687.5 1345 -6682.5 1345 -6662.5 1345 -6657.5 1340 -6657.5 1330 -6657.5 1325 -6657.5 1325 -6662.5 1325 -6682.5 1325 -6687.5 1330 -6687.5 1335 -6687.5 {fill=1
bezier=1}
P 7 14 1375 -4127.5 1380 -4127.5 1385 -4127.5 1385 -4122.5 1385 -4102.5 1385 -4097.5 1380 -4097.5 1370 -4097.5 1365 -4097.5 1365 -4102.5 1365 -4122.5 1365 -4127.5 1370 -4127.5 1375 -4127.5 {fill=1}
P 7 14 1775 -4077.5 1780 -4077.5 1785 -4077.5 1785 -4072.5 1785 -4052.5 1785 -4047.5 1780 -4047.5 1770 -4047.5 1765 -4047.5 1765 -4052.5 1765 -4072.5 1765 -4077.5 1770 -4077.5 1775 -4077.5 {fill=1
bezier=1}
P 7 14 1415 -3557.5 1420 -3557.5 1425 -3557.5 1425 -3552.5 1425 -3532.5 1425 -3527.5 1420 -3527.5 1410 -3527.5 1405 -3527.5 1405 -3532.5 1405 -3552.5 1405 -3557.5 1410 -3557.5 1415 -3557.5 {fill=1
bezier=1}
P 7 14 1685 -3557.5 1690 -3557.5 1695 -3557.5 1695 -3552.5 1695 -3532.5 1695 -3527.5 1690 -3527.5 1680 -3527.5 1675 -3527.5 1675 -3532.5 1675 -3552.5 1675 -3557.5 1680 -3557.5 1685 -3557.5 {fill=1
bezier=1}
P 7 14 1415 -3177.5 1420 -3177.5 1425 -3177.5 1425 -3172.5 1425 -3152.5 1425 -3147.5 1420 -3147.5 1410 -3147.5 1405 -3147.5 1405 -3152.5 1405 -3172.5 1405 -3177.5 1410 -3177.5 1415 -3177.5 {fill=1
bezier=1}
P 7 14 2065 -447.5 2070 -447.5 2075 -447.5 2075 -442.5 2075 -422.5 2075 -417.5 2070 -417.5 2060 -417.5 2055 -417.5 2055 -422.5 2055 -442.5 2055 -447.5 2060 -447.5 2065 -447.5 {fill=1
bezier=1}
P 7 14 1555 -417.5 1560 -417.5 1565 -417.5 1565 -412.5 1565 -392.5 1565 -387.5 1560 -387.5 1550 -387.5 1545 -387.5 1545 -392.5 1545 -412.5 1545 -417.5 1550 -417.5 1555 -417.5 {fill=1
bezier=1}
P 7 14 1445 -2817.5 1440 -2817.5 1435 -2817.5 1435 -2812.5 1435 -2792.5 1435 -2787.5 1440 -2787.5 1450 -2787.5 1455 -2787.5 1455 -2792.5 1455 -2812.5 1455 -2817.5 1450 -2817.5 1445 -2817.5 {fill=1
bezier=1}
P 7 14 1945 -2927.5 1950 -2927.5 1955 -2927.5 1955 -2922.5 1955 -2902.5 1955 -2897.5 1950 -2897.5 1940 -2897.5 1935 -2897.5 1935 -2902.5 1935 -2922.5 1935 -2927.5 1940 -2927.5 1945 -2927.5 {fill=1
bezier=1}
P 7 14 1565 -2407.5 1570 -2407.5 1575 -2407.5 1575 -2402.5 1575 -2382.5 1575 -2377.5 1570 -2377.5 1560 -2377.5 1555 -2377.5 1555 -2382.5 1555 -2402.5 1555 -2407.5 1560 -2407.5 1565 -2407.5 {fill=1
bezier=1}
P 7 14 2055 -2467.5 2060 -2467.5 2065 -2467.5 2065 -2462.5 2065 -2442.5 2065 -2437.5 2060 -2437.5 2050 -2437.5 2045 -2437.5 2045 -2442.5 2045 -2462.5 2045 -2467.5 2050 -2467.5 2055 -2467.5 {fill=1
bezier=1}
P 7 14 975 -8817.5 980 -8817.5 985 -8817.5 985 -8812.5 985 -8792.5 985 -8787.5 980 -8787.5 970 -8787.5 965 -8787.5 965 -8792.5 965 -8812.5 965 -8817.5 970 -8817.5 975 -8817.5 {fill=1
bezier=1}
P 7 14 1555 -37.5 1560 -37.5 1565 -37.5 1565 -32.5 1565 -12.5 1565 -7.5 1560 -7.5 1550 -7.5 1545 -7.5 1545 -12.5 1545 -32.5 1545 -37.5 1550 -37.5 1555 -37.5 {fill=1
bezier=1}
P 7 14 2065 12.5 2070 12.5 2075 12.5 2075 17.5 2075 37.5 2075 42.5 2070 42.5 2060 42.5 2055 42.5 2055 37.5 2055 17.5 2055 12.5 2060 12.5 2065 12.5 {fill=1
bezier=1}
P 7 14 2485 -2847.5 2490 -2847.5 2495 -2847.5 2495 -2842.5 2495 -2822.5 2495 -2817.5 2490 -2817.5 2480 -2817.5 2475 -2817.5 2475 -2822.5 2475 -2842.5 2475 -2847.5 2480 -2847.5 2485 -2847.5 {fill=1
bezier=1}
P 7 14 1805 -887.5 1810 -887.5 1815 -887.5 1815 -882.5 1815 -862.5 1815 -857.5 1810 -857.5 1800 -857.5 1795 -857.5 1795 -862.5 1795 -882.5 1795 -887.5 1800 -887.5 1805 -887.5 {fill=1
bezier=1}
P 7 14 655 -817.5 660 -817.5 665 -817.5 665 -812.5 665 -792.5 665 -787.5 660 -787.5 650 -787.5 645 -787.5 645 -792.5 645 -812.5 645 -817.5 650 -817.5 655 -817.5 {fill=1
bezier=1}
P 7 14 775 -817.5 780 -817.5 785 -817.5 785 -812.5 785 -792.5 785 -787.5 780 -787.5 770 -787.5 765 -787.5 765 -792.5 765 -812.5 765 -817.5 770 -817.5 775 -817.5 {fill=1
bezier=1}
P 7 14 1665 512.5 1660 512.5 1655 512.5 1655 517.5 1655 537.5 1655 542.5 1660 542.5 1670 542.5 1675 542.5 1675 537.5 1675 517.5 1675 512.5 1670 512.5 1665 512.5 {fill=1
bezier=1}
P 7 14 445 -4307.5 450 -4307.5 455 -4307.5 455 -4302.5 455 -4282.5 455 -4277.5 450 -4277.5 440 -4277.5 435 -4277.5 435 -4282.5 435 -4302.5 435 -4307.5 440 -4307.5 445 -4307.5 {fill=1
bezier=1}
P 7 14 985 -4487.5 990 -4487.5 995 -4487.5 995 -4482.5 995 -4462.5 995 -4457.5 990 -4457.5 980 -4457.5 975 -4457.5 975 -4462.5 975 -4482.5 975 -4487.5 980 -4487.5 985 -4487.5 {fill=1
bezier=1}
P 7 14 1995 -4277.5 2000 -4277.5 2005 -4277.5 2005 -4272.5 2005 -4252.5 2005 -4247.5 2000 -4247.5 1990 -4247.5 1985 -4247.5 1985 -4252.5 1985 -4272.5 1985 -4277.5 1990 -4277.5 1995 -4277.5 {fill=1
bezier=1}
P 7 14 2565 -4277.5 2570 -4277.5 2575 -4277.5 2575 -4272.5 2575 -4252.5 2575 -4247.5 2570 -4247.5 2560 -4247.5 2555 -4247.5 2555 -4252.5 2555 -4272.5 2555 -4277.5 2560 -4277.5 2565 -4277.5 {fill=1
bezier=1}
P 7 14 2265 -5067.5 2270 -5067.5 2275 -5067.5 2275 -5062.5 2275 -5042.5 2275 -5037.5 2270 -5037.5 2260 -5037.5 2255 -5037.5 2255 -5042.5 2255 -5062.5 2255 -5067.5 2260 -5067.5 2265 -5067.5 {fill=1
bezier=1}
P 7 14 1965 -3177.5 1970 -3177.5 1975 -3177.5 1975 -3172.5 1975 -3152.5 1975 -3147.5 1970 -3147.5 1960 -3147.5 1955 -3147.5 1955 -3152.5 1955 -3172.5 1955 -3177.5 1960 -3177.5 1965 -3177.5 {fill=1
bezier=1}
P 7 14 2325 -1477.5 2330 -1477.5 2335 -1477.5 2335 -1472.5 2335 -1452.5 2335 -1447.5 2330 -1447.5 2320 -1447.5 2315 -1447.5 2315 -1452.5 2315 -1472.5 2315 -1477.5 2320 -1477.5 2325 -1477.5 {fill=1
bezier=1}
P 7 14 795 -1597.5 800 -1597.5 805 -1597.5 805 -1592.5 805 -1572.5 805 -1567.5 800 -1567.5 790 -1567.5 785 -1567.5 785 -1572.5 785 -1592.5 785 -1597.5 790 -1597.5 795 -1597.5 {fill=1
bezier=1}
P 7 14 1335 -1577.5 1340 -1577.5 1345 -1577.5 1345 -1572.5 1345 -1552.5 1345 -1547.5 1340 -1547.5 1330 -1547.5 1325 -1547.5 1325 -1552.5 1325 -1572.5 1325 -1577.5 1330 -1577.5 1335 -1577.5 {fill=1
bezier=1}
P 7 14 1245 -1197.5 1250 -1197.5 1255 -1197.5 1255 -1192.5 1255 -1172.5 1255 -1167.5 1250 -1167.5 1240 -1167.5 1235 -1167.5 1235 -1172.5 1235 -1192.5 1235 -1197.5 1240 -1197.5 1245 -1197.5 {fill=1
bezier=1}
P 7 14 2505 -1147.5 2510 -1147.5 2515 -1147.5 2515 -1142.5 2515 -1122.5 2515 -1117.5 2510 -1117.5 2500 -1117.5 2495 -1117.5 2495 -1122.5 2495 -1142.5 2495 -1147.5 2500 -1147.5 2505 -1147.5 {fill=1
bezier=1}
P 7 14 2495 262.5 2490 262.5 2485 262.5 2485 267.5 2485 287.5 2485 292.5 2490 292.5 2500 292.5 2505 292.5 2505 287.5 2505 267.5 2505 262.5 2500 262.5 2495 262.5 {fill=1
bezier=1}
P 7 14 445 -3967.5 450 -3967.5 455 -3967.5 455 -3962.5 455 -3942.5 455 -3937.5 450 -3937.5 440 -3937.5 435 -3937.5 435 -3942.5 435 -3962.5 435 -3967.5 440 -3967.5 445 -3967.5 {fill=1}
P 7 14 2525 -6737.5 2530 -6737.5 2535 -6737.5 2535 -6732.5 2535 -6712.5 2535 -6707.5 2530 -6707.5 2520 -6707.5 2515 -6707.5 2515 -6712.5 2515 -6732.5 2515 -6737.5 2520 -6737.5 2525 -6737.5 {fill=1
bezier=1}
P 7 14 805 -4837.5 810 -4837.5 815 -4837.5 815 -4832.5 815 -4812.5 815 -4807.5 810 -4807.5 800 -4807.5 795 -4807.5 795 -4812.5 795 -4832.5 795 -4837.5 800 -4837.5 805 -4837.5 {fill=1
bezier=1}
P 7 14 2545 -4847.5 2550 -4847.5 2555 -4847.5 2555 -4842.5 2555 -4822.5 2555 -4817.5 2550 -4817.5 2540 -4817.5 2535 -4817.5 2535 -4822.5 2535 -4842.5 2535 -4847.5 2540 -4847.5 2545 -4847.5 {fill=1
bezier=1}
P 7 14 1335 -7247.5 1340 -7247.5 1345 -7247.5 1345 -7242.5 1345 -7222.5 1345 -7217.5 1340 -7217.5 1330 -7217.5 1325 -7217.5 1325 -7222.5 1325 -7242.5 1325 -7247.5 1330 -7247.5 1335 -7247.5 {fill=1
bezier=1}
P 7 14 2105 -7247.5 2110 -7247.5 2115 -7247.5 2115 -7242.5 2115 -7222.5 2115 -7217.5 2110 -7217.5 2100 -7217.5 2095 -7217.5 2095 -7222.5 2095 -7242.5 2095 -7247.5 2100 -7247.5 2105 -7247.5 {fill=1
bezier=1}
P 7 14 465 -6997.5 470 -6997.5 475 -6997.5 475 -6992.5 475 -6972.5 475 -6967.5 470 -6967.5 460 -6967.5 455 -6967.5 455 -6972.5 455 -6992.5 455 -6997.5 460 -6997.5 465 -6997.5 {fill=1
bezier=1}
P 7 14 655 -7107.5 660 -7107.5 665 -7107.5 665 -7102.5 665 -7082.5 665 -7077.5 660 -7077.5 650 -7077.5 645 -7077.5 645 -7082.5 645 -7102.5 645 -7107.5 650 -7107.5 655 -7107.5 {fill=1
bezier=1}
P 7 14 885 -7067.5 890 -7067.5 895 -7067.5 895 -7062.5 895 -7042.5 895 -7037.5 890 -7037.5 880 -7037.5 875 -7037.5 875 -7042.5 875 -7062.5 875 -7067.5 880 -7067.5 885 -7067.5 {fill=1
bezier=1}
P 7 14 1095 -7107.5 1100 -7107.5 1105 -7107.5 1105 -7102.5 1105 -7082.5 1105 -7077.5 1100 -7077.5 1090 -7077.5 1085 -7077.5 1085 -7082.5 1085 -7102.5 1085 -7107.5 1090 -7107.5 1095 -7107.5 {fill=1
bezier=1}
P 7 14 1365 -7107.5 1370 -7107.5 1375 -7107.5 1375 -7102.5 1375 -7082.5 1375 -7077.5 1370 -7077.5 1360 -7077.5 1355 -7077.5 1355 -7082.5 1355 -7102.5 1355 -7107.5 1360 -7107.5 1365 -7107.5 {fill=1
bezier=1}
P 7 14 1705 -6967.5 1710 -6967.5 1715 -6967.5 1715 -6962.5 1715 -6942.5 1715 -6937.5 1710 -6937.5 1700 -6937.5 1695 -6937.5 1695 -6942.5 1695 -6962.5 1695 -6967.5 1700 -6967.5 1705 -6967.5 {fill=1
bezier=1}
P 7 14 1955 -7077.5 1960 -7077.5 1965 -7077.5 1965 -7072.5 1965 -7052.5 1965 -7047.5 1960 -7047.5 1950 -7047.5 1945 -7047.5 1945 -7052.5 1945 -7072.5 1945 -7077.5 1950 -7077.5 1955 -7077.5 {fill=1
bezier=1}
P 7 14 2575 -7077.5 2580 -7077.5 2585 -7077.5 2585 -7072.5 2585 -7052.5 2585 -7047.5 2580 -7047.5 2570 -7047.5 2565 -7047.5 2565 -7052.5 2565 -7072.5 2565 -7077.5 2570 -7077.5 2575 -7077.5 {fill=1
bezier=1}
P 7 14 2235 -7077.5 2240 -7077.5 2245 -7077.5 2245 -7072.5 2245 -7052.5 2245 -7047.5 2240 -7047.5 2230 -7047.5 2225 -7047.5 2225 -7052.5 2225 -7072.5 2225 -7077.5 2230 -7077.5 2235 -7077.5 {fill=1
bezier=1}
P 7 14 2285 -3557.5 2290 -3557.5 2295 -3557.5 2295 -3552.5 2295 -3532.5 2295 -3527.5 2290 -3527.5 2280 -3527.5 2275 -3527.5 2275 -3532.5 2275 -3552.5 2275 -3557.5 2280 -3557.5 2285 -3557.5 {fill=1
bezier=1}
P 7 14 2335 -4107.5 2340 -4107.5 2345 -4107.5 2345 -4102.5 2345 -4082.5 2345 -4077.5 2340 -4077.5 2330 -4077.5 2325 -4077.5 2325 -4082.5 2325 -4102.5 2325 -4107.5 2330 -4107.5 2335 -4107.5 {fill=1
bezier=1}
P 7 14 2105 -8077.5 2110 -8077.5 2115 -8077.5 2115 -8072.5 2115 -8052.5 2115 -8047.5 2110 -8047.5 2100 -8047.5 2095 -8047.5 2095 -8052.5 2095 -8072.5 2095 -8077.5 2100 -8077.5 2105 -8077.5 {fill=1
bezier=1}
P 9 8 1770 -6630 1912.5 -6602.5 1890 -6570 1980 -6510 1960 -6480 1870 -6540 1845 -6505 1770 -6630 {fill=0}
P 10 7 880 -8050 872.5 -8057.5 877.5 -8062.5 862.5 -8067.5 867.5 -8052.5 872.5 -8057.5 880 -8050 {fill=1}
P 10 7 2110 -8100 2102.5 -8107.5 2107.5 -8112.5 2092.5 -8117.5 2097.5 -8102.5 2102.5 -8107.5 2110 -8100 {fill=1}
P 10 7 1330 -8090 1322.5 -8097.5 1327.5 -8102.5 1312.5 -8107.5 1317.5 -8092.5 1322.5 -8097.5 1330 -8090 {fill=1}
P 10 7 760 -7830 752.5 -7837.5 757.5 -7842.5 742.5 -7847.5 747.5 -7832.5 752.5 -7837.5 760 -7830 {fill=1}
P 10 7 1380 -7830 1372.5 -7837.5 1377.5 -7842.5 1362.5 -7847.5 1367.5 -7832.5 1372.5 -7837.5 1380 -7830 {fill=1}
P 10 7 760 -6210 752.5 -6217.5 757.5 -6222.5 742.5 -6227.5 747.5 -6212.5 752.5 -6217.5 760 -6210 {fill=1}
P 10 7 1380 -6210 1372.5 -6217.5 1377.5 -6222.5 1362.5 -6227.5 1367.5 -6212.5 1372.5 -6217.5 1380 -6210 {fill=1}
P 10 7 760 -5720 752.5 -5727.5 757.5 -5732.5 742.5 -5737.5 747.5 -5722.5 752.5 -5727.5 760 -5720 {fill=1}
P 10 7 1380 -5720 1372.5 -5727.5 1377.5 -5732.5 1362.5 -5737.5 1367.5 -5722.5 1372.5 -5727.5 1380 -5720 {fill=1}
P 10 7 920 -5000 912.5 -5007.5 917.5 -5012.5 902.5 -5017.5 907.5 -5002.5 912.5 -5007.5 920 -5000 {fill=1}
P 10 7 1390 -5060 1382.5 -5067.5 1387.5 -5072.5 1372.5 -5077.5 1377.5 -5062.5 1382.5 -5067.5 1390 -5060 {fill=1}
P 10 7 2240 -5060 2232.5 -5067.5 2237.5 -5072.5 2222.5 -5077.5 2227.5 -5062.5 2232.5 -5067.5 2240 -5060 {fill=1}
P 10 7 880 -7220 872.5 -7227.5 877.5 -7232.5 862.5 -7237.5 867.5 -7222.5 872.5 -7227.5 880 -7220 {fill=1}
P 10 7 2110 -7270 2102.5 -7277.5 2107.5 -7282.5 2092.5 -7287.5 2097.5 -7272.5 2102.5 -7277.5 2110 -7270 {fill=1}
P 10 7 1330 -7260 1322.5 -7267.5 1327.5 -7272.5 1312.5 -7277.5 1317.5 -7262.5 1322.5 -7267.5 1330 -7260 {fill=1}
P 10 7 880 -8520 872.5 -8527.5 877.5 -8532.5 862.5 -8537.5 867.5 -8522.5 872.5 -8527.5 880 -8520 {fill=1}
P 10 7 1630 -8550 1622.5 -8557.5 1627.5 -8562.5 1612.5 -8567.5 1617.5 -8552.5 1622.5 -8557.5 1630 -8550 {fill=1}
P 10 7 2410 -8540 2402.5 -8547.5 2407.5 -8552.5 2392.5 -8557.5 2397.5 -8542.5 2402.5 -8547.5 2410 -8540 {fill=1}
P 10 7 780 -4820 772.5 -4827.5 777.5 -4832.5 762.5 -4837.5 767.5 -4822.5 772.5 -4827.5 780 -4820 {fill=1}
P 10 7 1450 -4820 1442.5 -4827.5 1447.5 -4832.5 1432.5 -4837.5 1437.5 -4822.5 1442.5 -4827.5 1450 -4820 {fill=1}
P 10 7 1950 -4820 1942.5 -4827.5 1947.5 -4832.5 1932.5 -4837.5 1937.5 -4822.5 1942.5 -4827.5 1950 -4820 {fill=1}
P 10 7 2520 -4850 2512.5 -4857.5 2517.5 -4862.5 2502.5 -4867.5 2507.5 -4852.5 2512.5 -4857.5 2520 -4850 {fill=1}
P 10 7 730 -6680 722.5 -6687.5 727.5 -6692.5 712.5 -6697.5 717.5 -6682.5 722.5 -6687.5 730 -6680 {fill=1}
P 10 7 1310 -6680 1302.5 -6687.5 1307.5 -6692.5 1292.5 -6697.5 1297.5 -6682.5 1302.5 -6687.5 1310 -6680 {fill=1}
P 10 7 2520 -6750 2512.5 -6757.5 2517.5 -6762.5 2502.5 -6767.5 2507.5 -6752.5 2512.5 -6757.5 2520 -6750 {fill=1}
P 10 7 1360 -4130 1352.5 -4137.5 1357.5 -4142.5 1342.5 -4147.5 1347.5 -4132.5 1352.5 -4137.5 1360 -4130 {fill=1}
P 10 7 2360 -4120 2352.5 -4127.5 2357.5 -4132.5 2342.5 -4137.5 2347.5 -4122.5 2352.5 -4127.5 2360 -4120 {fill=1}
P 10 7 1800 -4090 1792.5 -4097.5 1797.5 -4102.5 1782.5 -4107.5 1787.5 -4092.5 1792.5 -4097.5 1800 -4090 {fill=1}
P 10 7 1380 -3170 1372.5 -3177.5 1377.5 -3182.5 1362.5 -3187.5 1367.5 -3172.5 1372.5 -3177.5 1380 -3170 {fill=1}
P 10 7 1920 -3210 1912.5 -3217.5 1917.5 -3222.5 1902.5 -3227.5 1907.5 -3212.5 1912.5 -3217.5 1920 -3210 {fill=1}
P 10 7 1380 -3550 1372.5 -3557.5 1377.5 -3562.5 1362.5 -3567.5 1367.5 -3552.5 1372.5 -3557.5 1380 -3550 {fill=1}
P 10 7 1800 -3550 1792.5 -3557.5 1797.5 -3562.5 1782.5 -3567.5 1787.5 -3552.5 1792.5 -3557.5 1800 -3550 {fill=1}
P 10 7 2280 -3570 2272.5 -3577.5 2277.5 -3582.5 2262.5 -3587.5 2267.5 -3572.5 2272.5 -3577.5 2280 -3570 {fill=1}
P 10 7 660 -2070 652.5 -2077.5 657.5 -2082.5 642.5 -2087.5 647.5 -2072.5 652.5 -2077.5 660 -2070 {fill=1}
P 10 7 1240 -2070 1232.5 -2077.5 1237.5 -2082.5 1222.5 -2087.5 1227.5 -2072.5 1232.5 -2077.5 1240 -2070 {fill=1}
P 10 7 1010 -8830 1002.5 -8837.5 1007.5 -8842.5 992.5 -8847.5 997.5 -8832.5 1002.5 -8837.5 1010 -8830 {fill=1}
P 10 7 680 -1830 672.5 -1837.5 677.5 -1842.5 662.5 -1847.5 667.5 -1832.5 672.5 -1837.5 680 -1830 {fill=1}
P 10 7 1300 -1740 1292.5 -1747.5 1297.5 -1752.5 1282.5 -1757.5 1287.5 -1742.5 1292.5 -1747.5 1300 -1740 {fill=1}
P 10 7 760 -1560 752.5 -1567.5 757.5 -1572.5 742.5 -1577.5 747.5 -1562.5 752.5 -1567.5 760 -1560 {fill=1}
P 10 7 1300 -1530 1292.5 -1537.5 1297.5 -1542.5 1282.5 -1547.5 1287.5 -1532.5 1292.5 -1537.5 1300 -1530 {fill=1}
P 10 7 2350 -1500 2342.5 -1507.5 2347.5 -1512.5 2332.5 -1517.5 2337.5 -1502.5 2342.5 -1507.5 2350 -1500 {fill=1}
P 10 7 1830 -780 1822.5 -787.5 1827.5 -792.5 1812.5 -797.5 1817.5 -782.5 1822.5 -787.5 1830 -780 {fill=1}
P 10 7 700 -850 692.5 -857.5 697.5 -862.5 682.5 -867.5 687.5 -852.5 692.5 -857.5 700 -850 {fill=1}
P 10 7 820 -850 812.5 -857.5 817.5 -862.5 802.5 -867.5 807.5 -852.5 812.5 -857.5 820 -850 {fill=1}
P 10 7 930 430 922.5 422.5 927.5 417.5 912.5 412.5 917.5 427.5 922.5 422.5 930 430 {fill=1}
P 10 7 1580 430 1572.5 422.5 1577.5 417.5 1562.5 412.5 1567.5 427.5 1572.5 422.5 1580 430 {fill=1}
P 10 7 760 -1130 752.5 -1137.5 757.5 -1142.5 742.5 -1147.5 747.5 -1132.5 752.5 -1137.5 760 -1130 {fill=1}
P 10 7 1220 -1180 1212.5 -1187.5 1217.5 -1192.5 1202.5 -1197.5 1207.5 -1182.5 1212.5 -1187.5 1220 -1180 {fill=1}
P 10 7 540 -4290 532.5 -4297.5 537.5 -4302.5 522.5 -4307.5 527.5 -4292.5 532.5 -4297.5 540 -4290 {fill=1}
P 10 7 1080 -4470 1072.5 -4477.5 1077.5 -4482.5 1062.5 -4487.5 1067.5 -4472.5 1072.5 -4477.5 1080 -4470 {fill=1}
P 10 7 1970 -4210 1962.5 -4217.5 1967.5 -4222.5 1952.5 -4227.5 1957.5 -4212.5 1962.5 -4217.5 1970 -4210 {fill=1}
P 10 7 2540 -4260 2532.5 -4267.5 2537.5 -4272.5 2522.5 -4277.5 2527.5 -4262.5 2532.5 -4267.5 2540 -4260 {fill=1}
P 10 7 840 -2820 832.5 -2827.5 837.5 -2832.5 822.5 -2837.5 827.5 -2822.5 832.5 -2827.5 840 -2820 {fill=1}
P 10 7 1380 -2820 1372.5 -2827.5 1377.5 -2832.5 1362.5 -2837.5 1367.5 -2822.5 1372.5 -2827.5 1380 -2820 {fill=1}
P 10 7 1920 -2900 1912.5 -2907.5 1917.5 -2912.5 1902.5 -2917.5 1907.5 -2902.5 1912.5 -2907.5 1920 -2900 {fill=1}
P 10 7 2460 -2820 2452.5 -2827.5 2457.5 -2832.5 2442.5 -2837.5 2447.5 -2822.5 2452.5 -2827.5 2460 -2820 {fill=1}
P 10 7 2560 -2570 2552.5 -2577.5 2557.5 -2582.5 2542.5 -2587.5 2547.5 -2572.5 2552.5 -2577.5 2560 -2570 {fill=1}
P 10 7 2030 -2470 2022.5 -2477.5 2027.5 -2482.5 2012.5 -2487.5 2017.5 -2472.5 2022.5 -2477.5 2030 -2470 {fill=1}
P 10 7 1520 -2460 1512.5 -2467.5 1517.5 -2472.5 1502.5 -2477.5 1507.5 -2462.5 1512.5 -2467.5 1520 -2460 {fill=1}
P 10 8 1770 -6630 1912.5 -6602.5 1890 -6570 1980 -6510 1960 -6480 1870 -6540 1845 -6505 1770 -6630 {fill=1}
P 10 7 2470 -1140 2462.5 -1147.5 2467.5 -1152.5 2452.5 -1157.5 2457.5 -1142.5 2462.5 -1147.5 2470 -1140 {fill=1}
P 10 7 2450 250 2442.5 242.5 2447.5 237.5 2432.5 232.5 2437.5 247.5 2442.5 242.5 2450 250 {fill=1}
P 10 7 480 -3980 472.5 -3987.5 477.5 -3992.5 462.5 -3997.5 467.5 -3982.5 472.5 -3987.5 480 -3980 {fill=1}
P 10 7 440 -6970 432.5 -6977.5 437.5 -6982.5 422.5 -6987.5 427.5 -6972.5 432.5 -6977.5 440 -6970 {fill=1}
P 10 7 630 -7080 622.5 -7087.5 627.5 -7092.5 612.5 -7097.5 617.5 -7082.5 622.5 -7087.5 630 -7080 {fill=1}
P 10 7 860 -7040 852.5 -7047.5 857.5 -7052.5 842.5 -7057.5 847.5 -7042.5 852.5 -7047.5 860 -7040 {fill=1}
P 10 7 1070 -7080 1062.5 -7087.5 1067.5 -7092.5 1052.5 -7097.5 1057.5 -7082.5 1062.5 -7087.5 1070 -7080 {fill=1}
P 10 7 1340 -7080 1332.5 -7087.5 1337.5 -7092.5 1322.5 -7097.5 1327.5 -7082.5 1332.5 -7087.5 1340 -7080 {fill=1}
P 10 7 1680 -6940 1672.5 -6947.5 1677.5 -6952.5 1662.5 -6957.5 1667.5 -6942.5 1672.5 -6947.5 1680 -6940 {fill=1}
P 10 7 1930 -7080 1922.5 -7087.5 1927.5 -7092.5 1912.5 -7097.5 1917.5 -7082.5 1922.5 -7087.5 1930 -7080 {fill=1}
P 10 7 2550 -7080 2542.5 -7087.5 2547.5 -7092.5 2532.5 -7097.5 2537.5 -7082.5 2542.5 -7087.5 2550 -7080 {fill=1}
P 10 7 2210 -7080 2202.5 -7087.5 2207.5 -7092.5 2192.5 -7097.5 2197.5 -7082.5 2202.5 -7087.5 2210 -7080 {fill=1}
T {INTUITIVE_INTERFACE CHEAT SHEET} 1110 -9270 0 0 2 2 {hcenter=1}
T {D} 1275 -8247.5 0 0 0.15 0.15 { layer=2}
T {D} 2055 -8257.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -8247.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -7787.5 0 0 0.15 0.15 {}
T {D} 1285 -7787.5 0 0 0.15 0.15 {}
T {D} 745 -6167.5 0 0 0.15 0.15 {}
T {D} 1285 -6167.5 0 0 0.15 0.15 {}
T {D} 745 -5677.5 0 0 0.15 0.15 {}
T {D} 1285 -5677.5 0 0 0.15 0.15 {}
T {D} 745 -5187.5 0 0 0.15 0.15 { layer=2}
T {D} 2125 -5187.5 0 0 0.15 0.15 { layer=2}
T {D} 1285 -5187.5 0 0 0.15 0.15 { layer=2}
T {(Enable Options-> Intuitive Click & Drag interface
or add: `set intuitive_interface 1` in xschemrc file).} 1090 -9130 0 0 1 1 {hcenter=1 layer=1}
T {Move objects} 0 -8320 0 0 1 1 {}
T {Move objects} 0 -7910 0 0 1 1 {}
T {Move objects,
create wires} 0 -6290 0 0 1 1 {}
T {Move objects,
keep attached
wires
} 0 -5800 0 0 1 1 {}
T {Move objects,
keep attached
wires
} 0 -5310 0 0 1 1 {}
T {Shift} 1530 -6255 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1530 -5765 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1520 -5045 0 0 0.5 0.5 {hcenter=1}
T {Duplicate objects} 0 -7470 0 0 1 1 {}
T {D} 1275 -7417.5 0 0 0.15 0.15 { layer=2}
T {D} 2055 -7427.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -7417.5 0 0 0.15 0.15 { layer=2}
T {D} 1775 -7417.5 0 0 0.15 0.15 {}
T {Shift} 1270 -7235 0 0 0.5 0.5 {hcenter=1}
T {D} 1815 -8717.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -8717.5 0 0 0.15 0.15 { layer=2}
T {Select
and unselect
objects} 0 -8770 0 0 1 1 {}
T {Shift} 1710 -8515 0 0 0.5 0.5 {hcenter=1}
T {D} 2275 -8717.5 0 0 0.15 0.15 { layer=2}
T {Alt} 2490 -8505 0 0 0.5 0.5 {hcenter=1}
T {Select} 750 -8520 0 0 0.5 0.5 {}
T {Add
Selection} 1770 -8530 0 0 0.5 0.5 {}
T {Remove
Selection} 2220 -8530 0 0 0.5 0.5 {}
T {D} 765 -4747.5 0 0 0.15 0.15 {}
T {D} 1305 -4747.5 0 0 0.15 0.15 {}
T {D} 1865 -4747.5 0 0 0.15 0.15 {}
T {D} 2435 -4747.5 0 0 0.15 0.15 {}
T {D} 765 -6577.5 0 0 0.15 0.15 {}
T {D} 1305 -6577.5 0 0 0.15 0.15 {}
T {D} 2435 -6577.5 0 0 0.15 0.15 {}
T {D} 765 -4367.5 0 0 0.15 0.15 {}
T {D} 1305 -3987.5 0 0 0.15 0.15 {}
T {D} 2405 -3987.5 0 0 0.15 0.15 {}
T {D} 1845 -3987.5 0 0 0.15 0.15 {}
T {Create and move
wires} 0 -4870 0 0 1 1 {}
T {Resize wires} 0 -6700 0 0 1 1 {}
T {Create wires} 0 -4490 0 0 1 1 {}
T {Stretch circuit} 0 -4110 0 0 1 1 {}
T {Move components, 
create wires,
resize wires} 0 -3320 0 0 1 1 {}
T {Move components,
create new wires} 0 -3700 0 0 1 1 {}
T {Cut wires} 0 -2970 0 0 1 1 {}
T {Stretch multiple
shapes} 0 -2550 0 0 1 1 {}
T {Ctrl} 1710 -4055 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1430 -3705 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1430 -3625 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1700 -3705 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1700 -3625 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1430 -3325 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1430 -3245 0 0 0.5 0.5 {hcenter=1}
T {Accurately position closer
to the wire end to be moved
so it will not be unselected} 1610 -6810 0 0 0.5 0.5 {}
T {Move multiple
objects keeping
connections} 0 -530 0 0 1 1 {}
T {Ctrl} 2080 -505 0 0 0.5 0.5 {hcenter=1}
T {Alt} 1430 -2875 0 0 0.5 0.5 {hcenter=1}
T {Click to select wire, release button
click wire endpoint and drag it away} 660 -6790 0 0 0.5 0.5 {}
T {Ctrl} 1580 -2465 0 0 0.5 0.5 {hcenter=1}
T {D} 655 -2127.5 0 0 0.15 0.15 { layer=2}
T {D} 1235 -2127.5 0 0 0.15 0.15 { layer=2}
T {D} 1885 -2127.5 0 0 0.15 0.15 {}
T {Ctrl} 1960 -2165 0 0 0.5 0.5 {hcenter=1}
T {!} 1960 -2085 0 0 0.5 0.5 {hcenter=1}
T {Break wires
under component
} 0 -2200 0 0 1 1 {}
T {If Shift key is needed for ! 
use also Shift} 2020 -2140 0 0 0.5 0.5 {}
T {D} 1275 -8717.5 0 0 0.15 0.15 { layer=2}
T {Add
Selection} 1090 -8540 0 0 0.5 0.5 {}
T {Shift} 1080 -8795 0 0 0.5 0.5 {hcenter=1}
T {Move multiple
objects keeping
connections,
adding wires} 0 -150 0 0 1 1 {}
T {Ctrl} 2080 -125 0 0 0.5 0.5 {hcenter=1}
T {Shift} 2080 -55 0 0 0.5 0.5 {hcenter=1}
T {Join / Trim wires} 0 -1860 0 0 1 1 {}
T {&} 1920 -1865 0 0 0.5 0.5 {hcenter=1}
T {This wire will not be broken} 1120 -1450 0 0 0.5 0.5 {}
T {&} 1830 -1435 0 0 0.5 0.5 {hcenter=1}
T {This wire is now 
broken} 1890 -1450 0 0 0.5 0.5 {}
T {break wires
at instance
pins} 0 -930 0 0 1 1 {}
T {!} 1290 -785 0 0 0.5 0.5 {hcenter=1}
T {Shift} 790 -715 0 0 0.5 0.5 {hcenter=1}
T {+} 720 -790 0 0 0.5 0.5 {}
T {The single wire line will be
broken at selected instance pins} 1640 -960 0 0 0.5 0.5 {}
T {Single wire line} 640 -950 0 0 0.5 0.5 {}
T {D} 825 382.5 0 0 0.15 0.15 {}
T {D} 1475 382.5 0 0 0.15 0.15 {}
T {Shift} 1650 445 0 0 0.5 0.5 {hcenter=1}
T {Select instance
and all connected
wires} 0 250 0 0 1 1 {}
T {Join / Trim wires} 0 -1580 0 0 1 1 {}
T {Options->Auto join / trim wires to perform this function automatically} 840 -1680 0 0 0.5 0.5 {}
T {Join / Trim wires} 0 -1190 0 0 1 1 {}
T {This wire is broken} 630 -1050 0 0 0.5 0.5 {}
T {This wire is still broken} 1170 -1050 0 0 0.5 0.5 {}
T {This wire is now joined} 1800 -1050 0 0 0.5 0.5 {}
T {&} 1920 -1295 0 0 0.5 0.5 {hcenter=1}
T {Options->Auto join / trim wires to perform this function automatically} 840 -1310 0 0 0.5 0.5 {}
T {Options->Auto join / trim wires to perform this function automatically} 840 -1920 0 0 0.5 0.5 {}
T {multiple overlayed wires create
unneeded connecting dots} 1110 -1840 0 0 0.5 0.5 {}
T {overlayed wires are removed} 2270 -1820 0 0 0.5 0.5 {}
T {D} 1305 -4367.5 0 0 0.15 0.15 {}
T {D} 1865 -4367.5 0 0 0.15 0.15 {}
T {D} 2435 -4367.5 0 0 0.15 0.15 {}
T {Ctrl} 2370 -5045 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1980 -3325 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1980 -3245 0 0 0.5 0.5 {hcenter=1}
T {you can now 
select one of
the cut segments...} 1930 -2840 0 0 0.4 0.4 {}
T {... and move it.} 2420 -2760 0 0 0.4 0.4 {}
T {D} 2035 382.5 0 0 0.15 0.15 {}
T {D} 765 -3987.5 0 0 0.15 0.15 {}
T {Ctrl} 2270 -4085 0 0 0.5 0.5 {hcenter=1}
T {Add / resize
wires} 0 -7020 0 0 1 1 {}
T {Click to
unselect} 860 -6980 0 0 0.5 0.5 {}
T {'Insert' key to
add a component} 1590 -6890 0 0 0.5 0.5 {}
T {Click to select} 1820 -7140 0 0 0.5 0.5 {}
T {Extend wire} 2390 -7150 0 0 0.5 0.5 {}
T {Click to
unselect} 2190 -3660 0 0 0.5 0.5 {}
