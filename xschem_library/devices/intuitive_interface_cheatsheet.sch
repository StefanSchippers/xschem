v {xschem version=3.4.8RC file_version=1.3
*
* This file is part of XSCHEM,
* a schematic capture and Spice/Vhdl/Verilog netlisting tool for circuit
* simulation.
* Copyright (C) 1998-2024 Stefan Frederik Schippers
*
* This program is free software; you can redistribute it and/or modify
* it under the terms of the GNU General Public License as published by
* the Free Software Foundation; either version 2 of the License, or
* (at your option) any later version.
*
* This program is distributed in the hope that it will be useful,
* but WITHOUT ANY WARRANTY; without even the implied warranty of
* MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
* GNU General Public License for more details.
*
* You should have received a copy of the GNU General Public License
* along with this program; if not, write to the Free Software
* Foundation, Inc., 51 Franklin Street, Fifth Floor, Boston, MA 02110-1301 USA
}
G {}
K {}
V {}
S {}
F {}
E {}
L 1 917.5 -12382.5 922.5 -12382.5 {}
L 1 917.5 -12380 922.5 -12380 {}
L 1 917.5 -12377.5 922.5 -12377.5 {}
L 1 917.5 -12375 922.5 -12375 {}
L 1 917.5 -12372.5 922.5 -12372.5 {}
L 1 917.5 -12370 922.5 -12370 {}
L 1 917.5 -12367.5 922.5 -12367.5 {}
L 1 917.5 -12365 922.5 -12365 {}
L 1 917.5 -12362.5 922.5 -12362.5 {}
L 1 1347.5 -12382.5 1352.5 -12382.5 {}
L 1 1347.5 -12380 1352.5 -12380 {}
L 1 1347.5 -12377.5 1352.5 -12377.5 {}
L 1 1347.5 -12375 1352.5 -12375 {}
L 1 1347.5 -12372.5 1352.5 -12372.5 {}
L 1 1347.5 -12370 1352.5 -12370 {}
L 1 1347.5 -12367.5 1352.5 -12367.5 {}
L 1 1347.5 -12365 1352.5 -12365 {}
L 1 1347.5 -12362.5 1352.5 -12362.5 {}
L 1 2117.5 -12382.5 2122.5 -12382.5 {}
L 1 2117.5 -12380 2122.5 -12380 {}
L 1 2117.5 -12377.5 2122.5 -12377.5 {}
L 1 2117.5 -12375 2122.5 -12375 {}
L 1 2117.5 -12372.5 2122.5 -12372.5 {}
L 1 2117.5 -12370 2122.5 -12370 {}
L 1 2117.5 -12367.5 2122.5 -12367.5 {}
L 1 2117.5 -12365 2122.5 -12365 {}
L 1 2117.5 -12362.5 2122.5 -12362.5 {}
L 1 1417.5 -12192.5 1422.5 -12192.5 {}
L 1 1417.5 -12190 1422.5 -12190 {}
L 1 1417.5 -12187.5 1422.5 -12187.5 {}
L 1 1417.5 -12185 1422.5 -12185 {}
L 1 1417.5 -12182.5 1422.5 -12182.5 {}
L 1 1417.5 -12180 1422.5 -12180 {}
L 1 1417.5 -12177.5 1422.5 -12177.5 {}
L 1 1417.5 -12175 1422.5 -12175 {}
L 1 1417.5 -12172.5 1422.5 -12172.5 {}
L 1 1437.5 -7772.5 1442.5 -7772.5 {}
L 1 1437.5 -7770 1442.5 -7770 {}
L 1 1437.5 -7767.5 1442.5 -7767.5 {}
L 1 1437.5 -7765 1442.5 -7765 {}
L 1 1437.5 -7762.5 1442.5 -7762.5 {}
L 1 1437.5 -7760 1442.5 -7760 {}
L 1 1437.5 -7757.5 1442.5 -7757.5 {}
L 1 1437.5 -7755 1442.5 -7755 {}
L 1 1437.5 -7752.5 1442.5 -7752.5 {}
L 1 1437.5 -7372.5 1442.5 -7372.5 {}
L 1 1437.5 -7370 1442.5 -7370 {}
L 1 1437.5 -7367.5 1442.5 -7367.5 {}
L 1 1437.5 -7365 1442.5 -7365 {}
L 1 1437.5 -7362.5 1442.5 -7362.5 {}
L 1 1437.5 -7360 1442.5 -7360 {}
L 1 1437.5 -7357.5 1442.5 -7357.5 {}
L 1 1437.5 -7355 1442.5 -7355 {}
L 1 1437.5 -7352.5 1442.5 -7352.5 {}
L 1 947.5 -6692.5 952.5 -6692.5 {}
L 1 947.5 -6690 952.5 -6690 {}
L 1 947.5 -6687.5 952.5 -6687.5 {}
L 1 947.5 -6685 952.5 -6685 {}
L 1 947.5 -6682.5 952.5 -6682.5 {}
L 1 947.5 -6680 952.5 -6680 {}
L 1 947.5 -6677.5 952.5 -6677.5 {}
L 1 947.5 -6675 952.5 -6675 {}
L 1 947.5 -6672.5 952.5 -6672.5 {}
L 1 1060 -6950 1300 -6950 {}
L 1 1060 -6690 1300 -6690 {}
L 1 1447.5 -6702.5 1452.5 -6702.5 {}
L 1 1447.5 -6700 1452.5 -6700 {}
L 1 1447.5 -6697.5 1452.5 -6697.5 {}
L 1 1447.5 -6695 1452.5 -6695 {}
L 1 1447.5 -6692.5 1452.5 -6692.5 {}
L 1 1447.5 -6690 1452.5 -6690 {}
L 1 1447.5 -6687.5 1452.5 -6687.5 {}
L 1 1447.5 -6685 1452.5 -6685 {}
L 1 1447.5 -6682.5 1452.5 -6682.5 {}
L 1 917.5 -11552.5 922.5 -11552.5 {}
L 1 917.5 -11550 922.5 -11550 {}
L 1 917.5 -11547.5 922.5 -11547.5 {}
L 1 917.5 -11545 922.5 -11545 {}
L 1 917.5 -11542.5 922.5 -11542.5 {}
L 1 917.5 -11540 922.5 -11540 {}
L 1 917.5 -11537.5 922.5 -11537.5 {}
L 1 917.5 -11535 922.5 -11535 {}
L 1 917.5 -11532.5 922.5 -11532.5 {}
L 1 1347.5 -11552.5 1352.5 -11552.5 {}
L 1 1347.5 -11550 1352.5 -11550 {}
L 1 1347.5 -11547.5 1352.5 -11547.5 {}
L 1 1347.5 -11545 1352.5 -11545 {}
L 1 1347.5 -11542.5 1352.5 -11542.5 {}
L 1 1347.5 -11540 1352.5 -11540 {}
L 1 1347.5 -11537.5 1352.5 -11537.5 {}
L 1 1347.5 -11535 1352.5 -11535 {}
L 1 1347.5 -11532.5 1352.5 -11532.5 {}
L 1 2117.5 -11552.5 2122.5 -11552.5 {}
L 1 2117.5 -11550 2122.5 -11550 {}
L 1 2117.5 -11547.5 2122.5 -11547.5 {}
L 1 2117.5 -11545 2122.5 -11545 {}
L 1 2117.5 -11542.5 2122.5 -11542.5 {}
L 1 2117.5 -11540 2122.5 -11540 {}
L 1 2117.5 -11537.5 2122.5 -11537.5 {}
L 1 2117.5 -11535 2122.5 -11535 {}
L 1 2117.5 -11532.5 2122.5 -11532.5 {}
L 1 862.5 -12852.5 867.5 -12852.5 {}
L 1 862.5 -12850 867.5 -12850 {}
L 1 862.5 -12847.5 867.5 -12847.5 {}
L 1 862.5 -12845 867.5 -12845 {}
L 1 862.5 -12842.5 867.5 -12842.5 {}
L 1 862.5 -12840 867.5 -12840 {}
L 1 862.5 -12837.5 867.5 -12837.5 {}
L 1 862.5 -12835 867.5 -12835 {}
L 1 862.5 -12832.5 867.5 -12832.5 {}
L 1 1627.5 -12842.5 1632.5 -12842.5 {}
L 1 1627.5 -12840 1632.5 -12840 {}
L 1 1627.5 -12837.5 1632.5 -12837.5 {}
L 1 1627.5 -12835 1632.5 -12835 {}
L 1 1627.5 -12832.5 1632.5 -12832.5 {}
L 1 1627.5 -12830 1632.5 -12830 {}
L 1 1627.5 -12827.5 1632.5 -12827.5 {}
L 1 1627.5 -12825 1632.5 -12825 {}
L 1 1627.5 -12822.5 1632.5 -12822.5 {}
L 1 2407.5 -12832.5 2412.5 -12832.5 {}
L 1 2407.5 -12830 2412.5 -12830 {}
L 1 2407.5 -12827.5 2412.5 -12827.5 {}
L 1 2407.5 -12825 2412.5 -12825 {}
L 1 2407.5 -12822.5 2412.5 -12822.5 {}
L 1 2407.5 -12820 2412.5 -12820 {}
L 1 2407.5 -12817.5 2412.5 -12817.5 {}
L 1 2407.5 -12815 2412.5 -12815 {}
L 1 2407.5 -12812.5 2412.5 -12812.5 {}
L 1 820 -5750 820 -5420 {}
L 1 1360 -5750 1360 -5420 {}
L 1 1900 -5580 1900 -5420 {}
L 1 820 -5230 820 -5130 {}
L 1 710 -5230 710 -5130 {}
L 1 930 -5230 930 -5130 {}
L 1 820 -6110 820 -5960 {}
L 1 1360 -6110 1360 -5960 {}
L 1 1900 -6110 1900 -6000 {}
L 1 687.5 -10972.5 692.5 -10972.5 {}
L 1 687.5 -10970 692.5 -10970 {}
L 1 687.5 -10967.5 692.5 -10967.5 {}
L 1 687.5 -10965 692.5 -10965 {}
L 1 687.5 -10962.5 692.5 -10962.5 {}
L 1 687.5 -10960 692.5 -10960 {}
L 1 687.5 -10957.5 692.5 -10957.5 {}
L 1 687.5 -10955 692.5 -10955 {}
L 1 687.5 -10952.5 692.5 -10952.5 {}
L 1 1347.5 -10992.5 1352.5 -10992.5 {}
L 1 1347.5 -10990 1352.5 -10990 {}
L 1 1347.5 -10987.5 1352.5 -10987.5 {}
L 1 1347.5 -10985 1352.5 -10985 {}
L 1 1347.5 -10982.5 1352.5 -10982.5 {}
L 1 1347.5 -10980 1352.5 -10980 {}
L 1 1347.5 -10977.5 1352.5 -10977.5 {}
L 1 1347.5 -10975 1352.5 -10975 {}
L 1 1347.5 -10972.5 1352.5 -10972.5 {}
L 1 2537.5 -11042.5 2542.5 -11042.5 {}
L 1 2537.5 -11040 2542.5 -11040 {}
L 1 2537.5 -11037.5 2542.5 -11037.5 {}
L 1 2537.5 -11035 2542.5 -11035 {}
L 1 2537.5 -11032.5 2542.5 -11032.5 {}
L 1 2537.5 -11030 2542.5 -11030 {}
L 1 2537.5 -11027.5 2542.5 -11027.5 {}
L 1 2537.5 -11025 2542.5 -11025 {}
L 1 2537.5 -11022.5 2542.5 -11022.5 {}
L 1 1427.5 -5912.5 1432.5 -5912.5 {}
L 1 1427.5 -5910 1432.5 -5910 {}
L 1 1427.5 -5907.5 1432.5 -5907.5 {}
L 1 1427.5 -5905 1432.5 -5905 {}
L 1 1427.5 -5902.5 1432.5 -5902.5 {}
L 1 1427.5 -5900 1432.5 -5900 {}
L 1 1427.5 -5897.5 1432.5 -5897.5 {}
L 1 1427.5 -5895 1432.5 -5895 {}
L 1 1427.5 -5892.5 1432.5 -5892.5 {}
L 1 820 -3300 820 -3200 {}
L 1 710 -3300 710 -3200 {}
L 1 930 -3300 930 -3200 {}
L 1 820 -3140 820 -3110 {}
L 1 710 -3140 710 -3110 {}
L 1 930 -3140 930 -3110 {}
L 1 2077.5 -3182.5 2082.5 -3182.5 {}
L 1 2077.5 -3180 2082.5 -3180 {}
L 1 2077.5 -3177.5 2082.5 -3177.5 {}
L 1 2077.5 -3175 2082.5 -3175 {}
L 1 2077.5 -3172.5 2082.5 -3172.5 {}
L 1 2077.5 -3170 2082.5 -3170 {}
L 1 2077.5 -3167.5 2082.5 -3167.5 {}
L 1 2077.5 -3165 2082.5 -3165 {}
L 1 2077.5 -3162.5 2082.5 -3162.5 {}
L 1 1567.5 -3152.5 1572.5 -3152.5 {}
L 1 1567.5 -3150 1572.5 -3150 {}
L 1 1567.5 -3147.5 1572.5 -3147.5 {}
L 1 1567.5 -3145 1572.5 -3145 {}
L 1 1567.5 -3142.5 1572.5 -3142.5 {}
L 1 1567.5 -3140 1572.5 -3140 {}
L 1 1567.5 -3137.5 1572.5 -3137.5 {}
L 1 1567.5 -3135 1572.5 -3135 {}
L 1 1567.5 -3132.5 1572.5 -3132.5 {}
L 1 1427.5 -5552.5 1432.5 -5552.5 {}
L 1 1427.5 -5550 1432.5 -5550 {}
L 1 1427.5 -5547.5 1432.5 -5547.5 {}
L 1 1427.5 -5545 1432.5 -5545 {}
L 1 1427.5 -5542.5 1432.5 -5542.5 {}
L 1 1427.5 -5540 1432.5 -5540 {}
L 1 1427.5 -5537.5 1432.5 -5537.5 {}
L 1 1427.5 -5535 1432.5 -5535 {}
L 1 1427.5 -5532.5 1432.5 -5532.5 {}
L 1 1957.5 -5662.5 1962.5 -5662.5 {}
L 1 1957.5 -5660 1962.5 -5660 {}
L 1 1957.5 -5657.5 1962.5 -5657.5 {}
L 1 1957.5 -5655 1962.5 -5655 {}
L 1 1957.5 -5652.5 1962.5 -5652.5 {}
L 1 1957.5 -5650 1962.5 -5650 {}
L 1 1957.5 -5647.5 1962.5 -5647.5 {}
L 1 1957.5 -5645 1962.5 -5645 {}
L 1 1957.5 -5642.5 1962.5 -5642.5 {}
L 1 1577.5 -5142.5 1582.5 -5142.5 {}
L 1 1577.5 -5140 1582.5 -5140 {}
L 1 1577.5 -5137.5 1582.5 -5137.5 {}
L 1 1577.5 -5135 1582.5 -5135 {}
L 1 1577.5 -5132.5 1582.5 -5132.5 {}
L 1 1577.5 -5130 1582.5 -5130 {}
L 1 1577.5 -5127.5 1582.5 -5127.5 {}
L 1 1577.5 -5125 1582.5 -5125 {}
L 1 1577.5 -5122.5 1582.5 -5122.5 {}
L 1 2067.5 -5202.5 2072.5 -5202.5 {}
L 1 2067.5 -5200 2072.5 -5200 {}
L 1 2067.5 -5197.5 2072.5 -5197.5 {}
L 1 2067.5 -5195 2072.5 -5195 {}
L 1 2067.5 -5192.5 2072.5 -5192.5 {}
L 1 2067.5 -5190 2072.5 -5190 {}
L 1 2067.5 -5187.5 2072.5 -5187.5 {}
L 1 2067.5 -5185 2072.5 -5185 {}
L 1 2067.5 -5182.5 2072.5 -5182.5 {}
L 1 2597.5 -5332.5 2602.5 -5332.5 {}
L 1 2597.5 -5330 2602.5 -5330 {}
L 1 2597.5 -5327.5 2602.5 -5327.5 {}
L 1 2597.5 -5325 2602.5 -5325 {}
L 1 2597.5 -5322.5 2602.5 -5322.5 {}
L 1 2597.5 -5320 2602.5 -5320 {}
L 1 2597.5 -5317.5 2602.5 -5317.5 {}
L 1 2597.5 -5315 2602.5 -5315 {}
L 1 2597.5 -5312.5 2602.5 -5312.5 {}
L 1 987.5 -13122.5 992.5 -13122.5 {}
L 1 987.5 -13120 992.5 -13120 {}
L 1 987.5 -13117.5 992.5 -13117.5 {}
L 1 987.5 -13115 992.5 -13115 {}
L 1 987.5 -13112.5 992.5 -13112.5 {}
L 1 987.5 -13110 992.5 -13110 {}
L 1 987.5 -13107.5 992.5 -13107.5 {}
L 1 987.5 -13105 992.5 -13105 {}
L 1 987.5 -13102.5 992.5 -13102.5 {}
L 1 820 -2920 820 -2820 {}
L 1 710 -2920 710 -2820 {}
L 1 930 -2920 930 -2820 {}
L 1 1567.5 -2772.5 1572.5 -2772.5 {}
L 1 1567.5 -2770 1572.5 -2770 {}
L 1 1567.5 -2767.5 1572.5 -2767.5 {}
L 1 1567.5 -2765 1572.5 -2765 {}
L 1 1567.5 -2762.5 1572.5 -2762.5 {}
L 1 1567.5 -2760 1572.5 -2760 {}
L 1 1567.5 -2757.5 1572.5 -2757.5 {}
L 1 1567.5 -2755 1572.5 -2755 {}
L 1 1567.5 -2752.5 1572.5 -2752.5 {}
L 1 2077.5 -2722.5 2082.5 -2722.5 {}
L 1 2077.5 -2720 2082.5 -2720 {}
L 1 2077.5 -2717.5 2082.5 -2717.5 {}
L 1 2077.5 -2715 2082.5 -2715 {}
L 1 2077.5 -2712.5 2082.5 -2712.5 {}
L 1 2077.5 -2710 2082.5 -2710 {}
L 1 2077.5 -2707.5 2082.5 -2707.5 {}
L 1 2077.5 -2705 2082.5 -2705 {}
L 1 2077.5 -2702.5 2082.5 -2702.5 {}
L 1 620 -4500 870 -4500 {}
L 1 1340 -4500 1410 -4500 {}
L 1 1160 -4500 1220 -4500 {}
L 1 1790 -4500 2040 -4500 {}
L 1 2340 -4500 2590 -4500 {}
L 1 620 -4220 870 -4220 {}
L 1 1160 -4220 1410 -4220 {}
L 1 1790 -4220 2040 -4220 {}
L 1 1910 -4340 1910 -4220 {}
L 1 2460 -4220 2590 -4220 {}
L 1 2460 -4340 2460 -4220 {}
L 1 2360 -5580 2360 -5420 {}
L 1 2497.5 -5582.5 2502.5 -5582.5 {}
L 1 2497.5 -5580 2502.5 -5580 {}
L 1 2497.5 -5577.5 2502.5 -5577.5 {}
L 1 2497.5 -5575 2502.5 -5575 {}
L 1 2497.5 -5572.5 2502.5 -5572.5 {}
L 1 2497.5 -5570 2502.5 -5570 {}
L 1 2497.5 -5567.5 2502.5 -5567.5 {}
L 1 2497.5 -5565 2502.5 -5565 {}
L 1 2497.5 -5562.5 2502.5 -5562.5 {}
L 1 1160 -3640 1410 -3640 {}
L 1 1880 -3510 1950 -3510 {}
L 1 1700 -3510 1760 -3510 {}
L 1 1817.5 -3622.5 1822.5 -3622.5 {}
L 1 1817.5 -3620 1822.5 -3620 {}
L 1 1817.5 -3617.5 1822.5 -3617.5 {}
L 1 1817.5 -3615 1822.5 -3615 {}
L 1 1817.5 -3612.5 1822.5 -3612.5 {}
L 1 1817.5 -3610 1822.5 -3610 {}
L 1 1817.5 -3607.5 1822.5 -3607.5 {}
L 1 1817.5 -3605 1822.5 -3605 {}
L 1 1817.5 -3602.5 1822.5 -3602.5 {}
L 1 620 -3640 870 -3640 {}
L 1 667.5 -3552.5 672.5 -3552.5 {}
L 1 667.5 -3550 672.5 -3550 {}
L 1 667.5 -3547.5 672.5 -3547.5 {}
L 1 667.5 -3545 672.5 -3545 {}
L 1 667.5 -3542.5 672.5 -3542.5 {}
L 1 667.5 -3540 672.5 -3540 {}
L 1 667.5 -3537.5 672.5 -3537.5 {}
L 1 667.5 -3535 672.5 -3535 {}
L 1 667.5 -3532.5 672.5 -3532.5 {}
L 1 787.5 -3552.5 792.5 -3552.5 {}
L 1 787.5 -3550 792.5 -3550 {}
L 1 787.5 -3547.5 792.5 -3547.5 {}
L 1 787.5 -3545 792.5 -3545 {}
L 1 787.5 -3542.5 792.5 -3542.5 {}
L 1 787.5 -3540 792.5 -3540 {}
L 1 787.5 -3537.5 792.5 -3537.5 {}
L 1 787.5 -3535 792.5 -3535 {}
L 1 787.5 -3532.5 792.5 -3532.5 {}
L 1 1597.5 -2222.5 1602.5 -2222.5 {}
L 1 1597.5 -2220 1602.5 -2220 {}
L 1 1597.5 -2217.5 1602.5 -2217.5 {}
L 1 1597.5 -2215 1602.5 -2215 {}
L 1 1597.5 -2212.5 1602.5 -2212.5 {}
L 1 1597.5 -2210 1602.5 -2210 {}
L 1 1597.5 -2207.5 1602.5 -2207.5 {}
L 1 1597.5 -2205 1602.5 -2205 {}
L 1 1597.5 -2202.5 1602.5 -2202.5 {}
L 1 620 -3820 870 -3820 {}
L 1 1160 -3820 1410 -3820 {}
L 1 1790 -3820 2040 -3820 {}
L 1 1830 -3990 1830 -3870 {}
L 1 2277.5 -6702.5 2282.5 -6702.5 {}
L 1 2277.5 -6700 2282.5 -6700 {}
L 1 2277.5 -6697.5 2282.5 -6697.5 {}
L 1 2277.5 -6695 2282.5 -6695 {}
L 1 2277.5 -6692.5 2282.5 -6692.5 {}
L 1 2277.5 -6690 2282.5 -6690 {}
L 1 2277.5 -6687.5 2282.5 -6687.5 {}
L 1 2277.5 -6685 2282.5 -6685 {}
L 1 2277.5 -6682.5 2282.5 -6682.5 {}
L 1 1977.5 -5912.5 1982.5 -5912.5 {}
L 1 1977.5 -5910 1982.5 -5910 {}
L 1 1977.5 -5907.5 1982.5 -5907.5 {}
L 1 1977.5 -5905 1982.5 -5905 {}
L 1 1977.5 -5902.5 1982.5 -5902.5 {}
L 1 1977.5 -5900 1982.5 -5900 {}
L 1 1977.5 -5897.5 1982.5 -5897.5 {}
L 1 1977.5 -5895 1982.5 -5895 {}
L 1 1977.5 -5892.5 1982.5 -5892.5 {}
L 1 2337.5 -4212.5 2342.5 -4212.5 {}
L 1 2337.5 -4210 2342.5 -4210 {}
L 1 2337.5 -4207.5 2342.5 -4207.5 {}
L 1 2337.5 -4205 2342.5 -4205 {}
L 1 2337.5 -4202.5 2342.5 -4202.5 {}
L 1 2337.5 -4200 2342.5 -4200 {}
L 1 2337.5 -4197.5 2342.5 -4197.5 {}
L 1 2337.5 -4195 2342.5 -4195 {}
L 1 2337.5 -4192.5 2342.5 -4192.5 {}
L 1 807.5 -4332.5 812.5 -4332.5 {}
L 1 807.5 -4330 812.5 -4330 {}
L 1 807.5 -4327.5 812.5 -4327.5 {}
L 1 807.5 -4325 812.5 -4325 {}
L 1 807.5 -4322.5 812.5 -4322.5 {}
L 1 807.5 -4320 812.5 -4320 {}
L 1 807.5 -4317.5 812.5 -4317.5 {}
L 1 807.5 -4315 812.5 -4315 {}
L 1 807.5 -4312.5 812.5 -4312.5 {}
L 1 1347.5 -4312.5 1352.5 -4312.5 {}
L 1 1347.5 -4310 1352.5 -4310 {}
L 1 1347.5 -4307.5 1352.5 -4307.5 {}
L 1 1347.5 -4305 1352.5 -4305 {}
L 1 1347.5 -4302.5 1352.5 -4302.5 {}
L 1 1347.5 -4300 1352.5 -4300 {}
L 1 1347.5 -4297.5 1352.5 -4297.5 {}
L 1 1347.5 -4295 1352.5 -4295 {}
L 1 1347.5 -4292.5 1352.5 -4292.5 {}
L 1 2320 -3990 2320 -3870 {}
L 1 1257.5 -3932.5 1262.5 -3932.5 {}
L 1 1257.5 -3930 1262.5 -3930 {}
L 1 1257.5 -3927.5 1262.5 -3927.5 {}
L 1 1257.5 -3925 1262.5 -3925 {}
L 1 1257.5 -3922.5 1262.5 -3922.5 {}
L 1 1257.5 -3920 1262.5 -3920 {}
L 1 1257.5 -3917.5 1262.5 -3917.5 {}
L 1 1257.5 -3915 1262.5 -3915 {}
L 1 1257.5 -3912.5 1262.5 -3912.5 {}
L 1 2517.5 -3882.5 2522.5 -3882.5 {}
L 1 2517.5 -3880 2522.5 -3880 {}
L 1 2517.5 -3877.5 2522.5 -3877.5 {}
L 1 2517.5 -3875 2522.5 -3875 {}
L 1 2517.5 -3872.5 2522.5 -3872.5 {}
L 1 2517.5 -3870 2522.5 -3870 {}
L 1 2517.5 -3867.5 2522.5 -3867.5 {}
L 1 2517.5 -3865 2522.5 -3865 {}
L 1 2517.5 -3862.5 2522.5 -3862.5 {}
L 1 2477.5 -2472.5 2482.5 -2472.5 {}
L 1 2477.5 -2470 2482.5 -2470 {}
L 1 2477.5 -2467.5 2482.5 -2467.5 {}
L 1 2477.5 -2465 2482.5 -2465 {}
L 1 2477.5 -2462.5 2482.5 -2462.5 {}
L 1 2477.5 -2460 2482.5 -2460 {}
L 1 2477.5 -2457.5 2482.5 -2457.5 {}
L 1 2477.5 -2455 2482.5 -2455 {}
L 1 2477.5 -2452.5 2482.5 -2452.5 {}
L 1 367.5 -9562.5 372.5 -9562.5 {}
L 1 367.5 -9560 372.5 -9560 {}
L 1 367.5 -9557.5 372.5 -9557.5 {}
L 1 367.5 -9555 372.5 -9555 {}
L 1 367.5 -9552.5 372.5 -9552.5 {}
L 1 367.5 -9550 372.5 -9550 {}
L 1 367.5 -9547.5 372.5 -9547.5 {}
L 1 367.5 -9545 372.5 -9545 {}
L 1 367.5 -9542.5 372.5 -9542.5 {}
L 1 897.5 -9732.5 902.5 -9732.5 {}
L 1 897.5 -9730 902.5 -9730 {}
L 1 897.5 -9727.5 902.5 -9727.5 {}
L 1 897.5 -9725 902.5 -9725 {}
L 1 897.5 -9722.5 902.5 -9722.5 {}
L 1 897.5 -9720 902.5 -9720 {}
L 1 897.5 -9717.5 902.5 -9717.5 {}
L 1 897.5 -9715 902.5 -9715 {}
L 1 897.5 -9712.5 902.5 -9712.5 {}
L 1 800 -9770 800 -9660 {}
L 1 1147.5 -9772.5 1152.5 -9772.5 {}
L 1 1147.5 -9770 1152.5 -9770 {}
L 1 1147.5 -9767.5 1152.5 -9767.5 {}
L 1 1147.5 -9765 1152.5 -9765 {}
L 1 1147.5 -9762.5 1152.5 -9762.5 {}
L 1 1147.5 -9760 1152.5 -9760 {}
L 1 1147.5 -9757.5 1152.5 -9757.5 {}
L 1 1147.5 -9755 1152.5 -9755 {}
L 1 1147.5 -9752.5 1152.5 -9752.5 {}
L 1 1090 -9770 1090 -9660 {}
L 1 1437.5 -9772.5 1442.5 -9772.5 {}
L 1 1437.5 -9770 1442.5 -9770 {}
L 1 1437.5 -9767.5 1442.5 -9767.5 {}
L 1 1437.5 -9765 1442.5 -9765 {}
L 1 1437.5 -9762.5 1442.5 -9762.5 {}
L 1 1437.5 -9760 1442.5 -9760 {}
L 1 1437.5 -9757.5 1442.5 -9757.5 {}
L 1 1437.5 -9755 1442.5 -9755 {}
L 1 1437.5 -9752.5 1442.5 -9752.5 {}
L 1 1320 -9770 1320 -9660 {}
L 1 1610 -9770 1610 -9660 {}
L 1 1897.5 -9732.5 1902.5 -9732.5 {}
L 1 1897.5 -9730 1902.5 -9730 {}
L 1 1897.5 -9727.5 1902.5 -9727.5 {}
L 1 1897.5 -9725 1902.5 -9725 {}
L 1 1897.5 -9722.5 1902.5 -9722.5 {}
L 1 1897.5 -9720 1902.5 -9720 {}
L 1 1897.5 -9717.5 1902.5 -9717.5 {}
L 1 1897.5 -9715 1902.5 -9715 {}
L 1 1897.5 -9712.5 1902.5 -9712.5 {}
L 1 1850 -9770 1850 -9660 {}
L 1 2150 -9770 2150 -9660 {}
L 1 927.5 -6282.5 932.5 -6282.5 {}
L 1 927.5 -6280 932.5 -6280 {}
L 1 927.5 -6277.5 932.5 -6277.5 {}
L 1 927.5 -6275 932.5 -6275 {}
L 1 927.5 -6272.5 932.5 -6272.5 {}
L 1 927.5 -6270 932.5 -6270 {}
L 1 927.5 -6267.5 932.5 -6267.5 {}
L 1 927.5 -6265 932.5 -6265 {}
L 1 927.5 -6262.5 932.5 -6262.5 {}
L 1 1767.5 -6332.5 1772.5 -6332.5 {}
L 1 1767.5 -6330 1772.5 -6330 {}
L 1 1767.5 -6327.5 1772.5 -6327.5 {}
L 1 1767.5 -6325 1772.5 -6325 {}
L 1 1767.5 -6322.5 1772.5 -6322.5 {}
L 1 1767.5 -6320 1772.5 -6320 {}
L 1 1767.5 -6317.5 1772.5 -6317.5 {}
L 1 1767.5 -6315 1772.5 -6315 {}
L 1 1767.5 -6312.5 1772.5 -6312.5 {}
L 1 2527.5 -6332.5 2532.5 -6332.5 {}
L 1 2527.5 -6330 2532.5 -6330 {}
L 1 2527.5 -6327.5 2532.5 -6327.5 {}
L 1 2527.5 -6325 2532.5 -6325 {}
L 1 2527.5 -6322.5 2532.5 -6322.5 {}
L 1 2527.5 -6320 2532.5 -6320 {}
L 1 2527.5 -6317.5 2532.5 -6317.5 {}
L 1 2527.5 -6315 2532.5 -6315 {}
L 1 2527.5 -6312.5 2532.5 -6312.5 {}
L 1 902.5 -11392.5 907.5 -11392.5 {}
L 1 902.5 -11390 907.5 -11390 {}
L 1 902.5 -11387.5 907.5 -11387.5 {}
L 1 902.5 -11385 907.5 -11385 {}
L 1 902.5 -11382.5 907.5 -11382.5 {}
L 1 902.5 -11380 907.5 -11380 {}
L 1 902.5 -11377.5 907.5 -11377.5 {}
L 1 902.5 -11375 907.5 -11375 {}
L 1 902.5 -11372.5 907.5 -11372.5 {}
L 1 1437.5 -11272.5 1442.5 -11272.5 {}
L 1 1437.5 -11270 1442.5 -11270 {}
L 1 1437.5 -11267.5 1442.5 -11267.5 {}
L 1 1437.5 -11265 1442.5 -11265 {}
L 1 1437.5 -11262.5 1442.5 -11262.5 {}
L 1 1437.5 -11260 1442.5 -11260 {}
L 1 1437.5 -11257.5 1442.5 -11257.5 {}
L 1 1437.5 -11255 1442.5 -11255 {}
L 1 1437.5 -11252.5 1442.5 -11252.5 {}
L 1 465 -11430 705 -11430 {}
L 1 1030 -11430 1270 -11430 {}
L 1 1807.5 -11272.5 1812.5 -11272.5 {}
L 1 1807.5 -11270 1812.5 -11270 {}
L 1 1807.5 -11267.5 1812.5 -11267.5 {}
L 1 1807.5 -11265 1812.5 -11265 {}
L 1 1807.5 -11262.5 1812.5 -11262.5 {}
L 1 1807.5 -11260 1812.5 -11260 {}
L 1 1807.5 -11257.5 1812.5 -11257.5 {}
L 1 1807.5 -11255 1812.5 -11255 {}
L 1 1807.5 -11252.5 1812.5 -11252.5 {}
L 1 1530 -11430 1770 -11430 {}
L 1 2297.5 -11272.5 2302.5 -11272.5 {}
L 1 2297.5 -11270 2302.5 -11270 {}
L 1 2297.5 -11267.5 2302.5 -11267.5 {}
L 1 2297.5 -11265 2302.5 -11265 {}
L 1 2297.5 -11262.5 2302.5 -11262.5 {}
L 1 2297.5 -11260 2302.5 -11260 {}
L 1 2297.5 -11257.5 2302.5 -11257.5 {}
L 1 2297.5 -11255 2302.5 -11255 {}
L 1 2297.5 -11252.5 2302.5 -11252.5 {}
L 1 2020 -11430 2260 -11430 {}
L 1 1610 -9770 1670 -9770 {}
L 1 2247.5 -9582.5 2252.5 -9582.5 {}
L 1 2247.5 -9580 2252.5 -9580 {}
L 1 2247.5 -9577.5 2252.5 -9577.5 {}
L 1 2247.5 -9575 2252.5 -9575 {}
L 1 2247.5 -9572.5 2252.5 -9572.5 {}
L 1 2247.5 -9570 2252.5 -9570 {}
L 1 2247.5 -9567.5 2252.5 -9567.5 {}
L 1 2247.5 -9565 2252.5 -9565 {}
L 1 2247.5 -9562.5 2252.5 -9562.5 {}
L 1 2150 -9770 2210 -9770 {}
L 1 2047.5 -9032.5 2052.5 -9032.5 {}
L 1 2047.5 -9030 2052.5 -9030 {}
L 1 2047.5 -9027.5 2052.5 -9027.5 {}
L 1 2047.5 -9025 2052.5 -9025 {}
L 1 2047.5 -9022.5 2052.5 -9022.5 {}
L 1 2047.5 -9020 2052.5 -9020 {}
L 1 2047.5 -9017.5 2052.5 -9017.5 {}
L 1 2047.5 -9015 2052.5 -9015 {}
L 1 2047.5 -9012.5 2052.5 -9012.5 {}
L 1 2047.5 -8602.5 2052.5 -8602.5 {}
L 1 2047.5 -8600 2052.5 -8600 {}
L 1 2047.5 -8597.5 2052.5 -8597.5 {}
L 1 2047.5 -8595 2052.5 -8595 {}
L 1 2047.5 -8592.5 2052.5 -8592.5 {}
L 1 2047.5 -8590 2052.5 -8590 {}
L 1 2047.5 -8587.5 2052.5 -8587.5 {}
L 1 2047.5 -8585 2052.5 -8585 {}
L 1 2047.5 -8582.5 2052.5 -8582.5 {}
L 1 1157.5 -8122.5 1162.5 -8122.5 {}
L 1 1157.5 -8120 1162.5 -8120 {}
L 1 1157.5 -8117.5 1162.5 -8117.5 {}
L 1 1157.5 -8115 1162.5 -8115 {}
L 1 1157.5 -8112.5 1162.5 -8112.5 {}
L 1 1157.5 -8110 1162.5 -8110 {}
L 1 1157.5 -8107.5 1162.5 -8107.5 {}
L 1 1157.5 -8105 1162.5 -8105 {}
L 1 1157.5 -8102.5 1162.5 -8102.5 {}
L 1 2360 -9770 2360 -9660 {}
L 1 2477.5 -9642.5 2482.5 -9642.5 {}
L 1 2477.5 -9640 2482.5 -9640 {}
L 1 2477.5 -9637.5 2482.5 -9637.5 {}
L 1 2477.5 -9635 2482.5 -9635 {}
L 1 2477.5 -9632.5 2482.5 -9632.5 {}
L 1 2477.5 -9630 2482.5 -9630 {}
L 1 2477.5 -9627.5 2482.5 -9627.5 {}
L 1 2477.5 -9625 2482.5 -9625 {}
L 1 2477.5 -9622.5 2482.5 -9622.5 {}
L 1 2360 -9770 2420 -9770 {}
L 1 617.5 -9772.5 622.5 -9772.5 {}
L 1 617.5 -9770 622.5 -9770 {}
L 1 617.5 -9767.5 622.5 -9767.5 {}
L 1 617.5 -9765 622.5 -9765 {}
L 1 617.5 -9762.5 622.5 -9762.5 {}
L 1 617.5 -9760 622.5 -9760 {}
L 1 617.5 -9757.5 622.5 -9757.5 {}
L 1 617.5 -9755 622.5 -9755 {}
L 1 617.5 -9752.5 622.5 -9752.5 {}
L 1 1970 -1690 2040 -1690 {}
L 1 1970 -1670 2040 -1670 {}
L 1 1970 -1650 2040 -1650 {}
L 1 1970 -1630 2040 -1630 {}
L 1 647.5 -1592.5 652.5 -1592.5 {}
L 1 647.5 -1590 652.5 -1590 {}
L 1 647.5 -1587.5 652.5 -1587.5 {}
L 1 647.5 -1585 652.5 -1585 {}
L 1 647.5 -1582.5 652.5 -1582.5 {}
L 1 647.5 -1580 652.5 -1580 {}
L 1 647.5 -1577.5 652.5 -1577.5 {}
L 1 647.5 -1575 652.5 -1575 {}
L 1 647.5 -1572.5 652.5 -1572.5 {}
L 1 1097.5 -1592.5 1102.5 -1592.5 {}
L 1 1097.5 -1590 1102.5 -1590 {}
L 1 1097.5 -1587.5 1102.5 -1587.5 {}
L 1 1097.5 -1585 1102.5 -1585 {}
L 1 1097.5 -1582.5 1102.5 -1582.5 {}
L 1 1097.5 -1580 1102.5 -1580 {}
L 1 1097.5 -1577.5 1102.5 -1577.5 {}
L 1 1097.5 -1575 1102.5 -1575 {}
L 1 1097.5 -1572.5 1102.5 -1572.5 {}
L 1 1517.5 -1562.5 1522.5 -1562.5 {}
L 1 1517.5 -1560 1522.5 -1560 {}
L 1 1517.5 -1557.5 1522.5 -1557.5 {}
L 1 1517.5 -1555 1522.5 -1555 {}
L 1 1517.5 -1552.5 1522.5 -1552.5 {}
L 1 1517.5 -1550 1522.5 -1550 {}
L 1 1517.5 -1547.5 1522.5 -1547.5 {}
L 1 1517.5 -1545 1522.5 -1545 {}
L 1 1517.5 -1542.5 1522.5 -1542.5 {}
L 1 2447.5 -1622.5 2452.5 -1622.5 {}
L 1 2447.5 -1620 2452.5 -1620 {}
L 1 2447.5 -1617.5 2452.5 -1617.5 {}
L 1 2447.5 -1615 2452.5 -1615 {}
L 1 2447.5 -1612.5 2452.5 -1612.5 {}
L 1 2447.5 -1610 2452.5 -1610 {}
L 1 2447.5 -1607.5 2452.5 -1607.5 {}
L 1 2447.5 -1605 2452.5 -1605 {}
L 1 2447.5 -1602.5 2452.5 -1602.5 {}
L 1 2207.5 -13512.5 2212.5 -13512.5 {}
L 1 2207.5 -13510 2212.5 -13510 {}
L 1 2207.5 -13507.5 2212.5 -13507.5 {}
L 1 2207.5 -13505 2212.5 -13505 {}
L 1 2207.5 -13502.5 2212.5 -13502.5 {}
L 1 2207.5 -13500 2212.5 -13500 {}
L 1 2207.5 -13497.5 2212.5 -13497.5 {}
L 1 2207.5 -13495 2212.5 -13495 {}
L 1 2207.5 -13492.5 2212.5 -13492.5 {}
L 1 1110 -12530 1230 -12530 {}
L 1 1030 -12680 1270 -12680 {}
L 1 1270 -12560 1410 -12560 {}
L 1 1030 -12440 1030 -12420 {}
L 1 1030 -12680 1030 -12500 {}
L 1 1030 -12420 1270 -12420 {}
L 1 1650 -12530 1770 -12530 {}
L 1 1570 -12680 1810 -12680 {}
L 1 1810 -12560 1950 -12560 {}
L 1 1570 -12440 1570 -12420 {}
L 1 1570 -12680 1570 -12500 {}
L 1 1570 -12420 1810 -12420 {}
L 1 580 -12530 700 -12530 {}
L 1 500 -12680 740 -12680 {}
L 1 740 -12560 880 -12560 {}
L 1 500 -12440 500 -12420 {}
L 1 500 -12680 500 -12500 {}
L 1 500 -12420 740 -12420 {}
L 1 580 -12070 700 -12070 {}
L 1 740 -12130 740 -12100 {}
L 1 740 -12220 740 -12190 {}
L 1 500 -12220 740 -12220 {}
L 1 740 -12100 880 -12100 {}
L 1 830 -12040 830 -11960 {}
L 1 500 -11980 500 -11960 {}
L 1 500 -12220 500 -12040 {}
L 1 -610 -11870 -610 -11760 {}
L 1 740 -11960 830 -11960 {}
L 1 500 -11960 740 -11960 {}
L 1 1120 -12070 1240 -12070 {}
L 1 1280 -12130 1280 -12100 {}
L 1 1280 -12220 1280 -12190 {}
L 1 1040 -12220 1280 -12220 {}
L 1 1280 -12100 1420 -12100 {}
L 1 1370 -12040 1370 -11960 {}
L 1 1040 -11980 1040 -11960 {}
L 1 1040 -12220 1040 -12040 {}
L 1 1280 -12070 1280 -11960 {}
L 1 1280 -11960 1370 -11960 {}
L 1 1040 -11960 1280 -11960 {}
L 1 580 -7640 700 -7640 {}
L 1 740 -7700 740 -7670 {}
L 1 740 -7790 740 -7760 {}
L 1 500 -7790 740 -7790 {}
L 1 740 -7670 880 -7670 {}
L 1 830 -7610 830 -7530 {}
L 1 500 -7550 500 -7530 {}
L 1 500 -7790 500 -7610 {}
L 1 740 -7640 740 -7530 {}
L 1 740 -7530 830 -7530 {}
L 1 500 -7530 740 -7530 {}
L 1 1120 -7640 1240 -7640 {}
L 1 1280 -7700 1280 -7670 {}
L 1 1280 -7790 1280 -7760 {}
L 1 1040 -7790 1280 -7790 {}
L 1 1280 -7670 1420 -7670 {}
L 1 1370 -7610 1370 -7530 {}
L 1 1040 -7550 1040 -7530 {}
L 1 1040 -7790 1040 -7610 {}
L 1 1280 -7640 1280 -7530 {}
L 1 1280 -7530 1370 -7530 {}
L 1 1040 -7530 1280 -7530 {}
L 1 580 -7240 700 -7240 {}
L 1 740 -7300 740 -7270 {}
L 1 740 -7390 740 -7360 {}
L 1 500 -7390 740 -7390 {}
L 1 740 -7270 880 -7270 {}
L 1 830 -7210 830 -7130 {}
L 1 500 -7150 500 -7130 {}
L 1 500 -7390 500 -7210 {}
L 1 740 -7240 740 -7130 {}
L 1 740 -7130 830 -7130 {}
L 1 500 -7130 740 -7130 {}
L 1 1120 -7240 1240 -7240 {}
L 1 1040 -7390 1280 -7390 {}
L 1 1280 -7270 1420 -7270 {}
L 1 1370 -7210 1370 -7130 {}
L 1 1040 -7150 1040 -7130 {}
L 1 1040 -7390 1040 -7210 {}
L 1 1280 -7240 1280 -7130 {}
L 1 1280 -7130 1370 -7130 {}
L 1 1040 -7130 1280 -7130 {}
L 1 580 -6800 700 -6800 {}
L 1 500 -6950 740 -6950 {}
L 1 500 -6710 500 -6690 {}
L 1 500 -6950 500 -6770 {}
L 1 500 -6690 740 -6690 {}
L 1 1690 -6710 1690 -6690 {}
L 1 1690 -6950 1690 -6770 {}
L 1 1140 -6800 1260 -6800 {}
L 1 1060 -6710 1060 -6690 {}
L 1 1060 -6950 1060 -6770 {}
L 1 1110 -11700 1230 -11700 {}
L 1 1030 -11850 1270 -11850 {}
L 1 1270 -11730 1410 -11730 {}
L 1 1030 -11610 1030 -11590 {}
L 1 1030 -11850 1030 -11670 {}
L 1 1030 -11590 1270 -11590 {}
L 1 580 -11700 700 -11700 {}
L 1 500 -11850 740 -11850 {}
L 1 740 -11730 880 -11730 {}
L 1 500 -11610 500 -11590 {}
L 1 500 -11850 500 -11670 {}
L 1 500 -11590 740 -11590 {}
L 1 1610 -11700 1730 -11700 {}
L 1 1770 -11760 1770 -11730 {}
L 1 1770 -11850 1770 -11820 {}
L 1 1530 -11850 1770 -11850 {}
L 1 1770 -11730 1910 -11730 {}
L 1 1860 -11670 1860 -11590 {}
L 1 1530 -11610 1530 -11590 {}
L 1 1530 -11850 1530 -11670 {}
L 1 1770 -11700 1770 -11590 {}
L 1 1770 -11590 1860 -11590 {}
L 1 1530 -11590 1770 -11590 {}
L 1 1650 -13000 1770 -13000 {}
L 1 1570 -13150 1810 -13150 {}
L 1 1810 -13030 1950 -13030 {}
L 1 1570 -12890 1810 -12890 {}
L 1 525 -13000 645 -13000 {}
L 1 445 -13150 685 -13150 {}
L 1 685 -13030 825 -13030 {}
L 1 445 -12910 445 -12890 {}
L 1 445 -13150 445 -12970 {}
L 1 445 -12890 685 -12890 {}
L 1 2110 -13000 2230 -13000 {}
L 1 2030 -13150 2270 -13150 {}
L 1 2270 -13030 2410 -13030 {}
L 1 2030 -12890 2270 -12890 {}
L 1 2360 -12970 2360 -12890 {}
L 1 600 -10860 720 -10860 {}
L 1 760 -10920 760 -10890 {}
L 1 760 -11010 760 -10980 {}
L 1 760 -10890 900 -10890 {}
L 1 850 -10830 850 -10750 {}
L 1 520 -10770 520 -10750 {}
L 1 520 -11010 520 -10830 {}
L 1 760 -10860 760 -10750 {}
L 1 760 -10750 850 -10750 {}
L 1 520 -10750 760 -10750 {}
L 1 1140 -10860 1260 -10860 {}
L 1 1300 -10920 1300 -10890 {}
L 1 1300 -11010 1300 -10980 {}
L 1 1300 -10890 1440 -10890 {}
L 1 1390 -10830 1390 -10750 {}
L 1 1060 -10770 1060 -10750 {}
L 1 1060 -11010 1060 -10830 {}
L 1 1300 -10860 1300 -10750 {}
L 1 1300 -10750 1390 -10750 {}
L 1 1060 -10750 1300 -10750 {}
L 1 2270 -10860 2390 -10860 {}
L 1 2430 -10920 2430 -10890 {}
L 1 2430 -11010 2430 -10980 {}
L 1 2430 -10890 2570 -10890 {}
L 1 2520 -10830 2520 -10750 {}
L 1 2190 -10770 2190 -10750 {}
L 1 2190 -11010 2190 -10830 {}
L 1 2430 -10860 2430 -10750 {}
L 1 2430 -10750 2520 -10750 {}
L 1 2190 -10750 2430 -10750 {}
L 1 690 -4930 690 -4750 {}
L 1 1230 -4930 1230 -4750 {}
L 1 1880 -4930 1880 -4870 {}
L 1 1880 -4810 1880 -4750 {}
L 1 1110 -13000 1230 -13000 {}
L 1 1030 -13150 1270 -13150 {}
L 1 1270 -13030 1410 -13030 {}
L 1 1030 -12890 1270 -12890 {}
L 1 1030 -12910 1030 -12890 {}
L 1 1030 -13150 1030 -12970 {}
L 1 660 -2330 780 -2330 {}
L 1 820 -2390 820 -2360 {}
L 1 820 -2480 820 -2450 {}
L 1 580 -2480 820 -2480 {}
L 1 820 -2360 960 -2360 {}
L 1 910 -2300 910 -2220 {}
L 1 580 -2240 580 -2220 {}
L 1 580 -2480 580 -2300 {}
L 1 820 -2330 820 -2220 {}
L 1 820 -2220 910 -2220 {}
L 1 580 -2220 820 -2220 {}
L 1 1260 -2330 1380 -2330 {}
L 1 1420 -2390 1420 -2360 {}
L 1 1420 -2480 1420 -2450 {}
L 1 1180 -2480 1420 -2480 {}
L 1 1180 -2480 1180 -2300 {}
L 1 1870 -2330 1990 -2330 {}
L 1 2030 -2390 2030 -2360 {}
L 1 2030 -2480 2030 -2450 {}
L 1 1790 -2480 2030 -2480 {}
L 1 1790 -2480 1790 -2300 {}
L 1 600 -6390 720 -6390 {}
L 1 760 -6450 760 -6420 {}
L 1 760 -6540 760 -6510 {}
L 1 520 -6540 760 -6540 {}
L 1 760 -6420 900 -6420 {}
L 1 520 -6300 520 -6280 {}
L 1 520 -6540 520 -6360 {}
L 1 760 -6390 760 -6280 {}
L 1 760 -6280 850 -6280 {}
L 1 520 -6280 760 -6280 {}
L 1 1160 -6390 1280 -6390 {}
L 1 1320 -6450 1320 -6420 {}
L 1 1320 -6540 1320 -6510 {}
L 1 1080 -6540 1320 -6540 {}
L 1 1320 -6420 1460 -6420 {}
L 1 1080 -6300 1080 -6280 {}
L 1 1080 -6540 1080 -6360 {}
L 1 1320 -6390 1320 -6280 {}
L 1 1320 -6280 1410 -6280 {}
L 1 1080 -6280 1320 -6280 {}
L 1 545 -11280 665 -11280 {}
L 1 705 -11340 705 -11310 {}
L 1 705 -11430 705 -11400 {}
L 1 795 -11250 795 -11170 {}
L 1 465 -11190 465 -11170 {}
L 1 465 -11430 465 -11250 {}
L 1 705 -11280 705 -11170 {}
L 1 705 -11170 795 -11170 {}
L 1 465 -11170 705 -11170 {}
L 1 1110 -11280 1230 -11280 {}
L 1 1270 -11340 1270 -11310 {}
L 1 1270 -11430 1270 -11400 {}
L 1 1360 -11250 1360 -11170 {}
L 1 1030 -11190 1030 -11170 {}
L 1 1030 -11430 1030 -11250 {}
L 1 1270 -11280 1270 -11170 {}
L 1 1270 -11170 1360 -11170 {}
L 1 1030 -11170 1270 -11170 {}
L 1 1610 -11280 1730 -11280 {}
L 1 1770 -11340 1770 -11310 {}
L 1 1770 -11430 1770 -11400 {}
L 1 1860 -11250 1860 -11170 {}
L 1 1530 -11190 1530 -11170 {}
L 1 1530 -11430 1530 -11250 {}
L 1 1770 -11280 1770 -11170 {}
L 1 1770 -11170 1860 -11170 {}
L 1 1530 -11170 1770 -11170 {}
L 1 2100 -11280 2220 -11280 {}
L 1 2260 -11340 2260 -11310 {}
L 1 2260 -11430 2260 -11400 {}
L 1 2350 -11250 2350 -11170 {}
L 1 2020 -11190 2020 -11170 {}
L 1 2020 -11430 2020 -11250 {}
L 1 2260 -11280 2260 -11170 {}
L 1 2260 -11170 2350 -11170 {}
L 1 2020 -11170 2260 -11170 {}
L 1 580 -1320 670 -1320 {}
L 1 970 -1320 1060 -1320 {}
L 1 957.5 -1262.5 962.5 -1262.5 {}
L 1 957.5 -1260 962.5 -1260 {}
L 1 957.5 -1257.5 962.5 -1257.5 {}
L 1 957.5 -1255 962.5 -1255 {}
L 1 957.5 -1252.5 962.5 -1252.5 {}
L 1 957.5 -1250 962.5 -1250 {}
L 1 957.5 -1247.5 962.5 -1247.5 {}
L 1 957.5 -1245 962.5 -1245 {}
L 1 957.5 -1242.5 962.5 -1242.5 {}
L 1 1280 -1320 1370 -1320 {}
L 1 1387.5 -1222.5 1392.5 -1222.5 {}
L 1 1387.5 -1220 1392.5 -1220 {}
L 1 1387.5 -1217.5 1392.5 -1217.5 {}
L 1 1387.5 -1215 1392.5 -1215 {}
L 1 1387.5 -1212.5 1392.5 -1212.5 {}
L 1 1387.5 -1210 1392.5 -1210 {}
L 1 1387.5 -1207.5 1392.5 -1207.5 {}
L 1 1387.5 -1205 1392.5 -1205 {}
L 1 1387.5 -1202.5 1392.5 -1202.5 {}
L 1 1610 -1320 1700 -1320 {}
L 1 1717.5 -1222.5 1722.5 -1222.5 {}
L 1 1717.5 -1220 1722.5 -1220 {}
L 1 1717.5 -1217.5 1722.5 -1217.5 {}
L 1 1717.5 -1215 1722.5 -1215 {}
L 1 1717.5 -1212.5 1722.5 -1212.5 {}
L 1 1717.5 -1210 1722.5 -1210 {}
L 1 1717.5 -1207.5 1722.5 -1207.5 {}
L 1 1717.5 -1205 1722.5 -1205 {}
L 1 1717.5 -1202.5 1722.5 -1202.5 {}
L 1 1930 -1320 2020 -1320 {}
L 1 2037.5 -1222.5 2042.5 -1222.5 {}
L 1 2037.5 -1220 2042.5 -1220 {}
L 1 2037.5 -1217.5 2042.5 -1217.5 {}
L 1 2037.5 -1215 2042.5 -1215 {}
L 1 2037.5 -1212.5 2042.5 -1212.5 {}
L 1 2037.5 -1210 2042.5 -1210 {}
L 1 2037.5 -1207.5 2042.5 -1207.5 {}
L 1 2037.5 -1205 2042.5 -1205 {}
L 1 2037.5 -1202.5 2042.5 -1202.5 {}
L 1 670 -990 670 -960 {}
L 1 540 -960 670 -960 {}
L 1 540 -990 540 -850 {}
L 1 540 -790 540 -770 {}
L 1 540 -710 540 -690 {}
L 1 540 -1070 540 -1020 {}
L 1 540 -1070 670 -1070 {}
L 1 670 -1070 670 -1020 {}
L 1 540 -740 540 -710 {}
L 1 540 -820 590 -820 {}
L 1 590 -820 590 -710 {}
L 1 540 -710 590 -710 {}
L 1 500 -1020 500 -820 {}
L 1 630 -1020 630 -940 {}
L 1 480 -940 630 -940 {}
L 1 480 -940 480 -740 {}
L 1 480 -740 500 -740 {}
L 1 440 -840 480 -840 {}
L 1 440 -870 500 -870 {}
L 1 1040 -990 1040 -960 {}
L 1 910 -960 1040 -960 {}
L 1 910 -990 910 -850 {}
L 1 910 -790 910 -770 {}
L 1 910 -710 910 -690 {}
L 1 910 -1070 910 -1020 {}
L 1 910 -1070 1040 -1070 {}
L 1 1040 -1070 1040 -1020 {}
L 1 910 -820 960 -820 {}
L 1 960 -820 960 -710 {}
L 1 910 -710 960 -710 {}
L 1 870 -1020 870 -820 {}
L 1 1000 -1020 1000 -940 {}
L 1 850 -940 1000 -940 {}
L 1 850 -940 850 -740 {}
L 1 850 -740 870 -740 {}
L 1 810 -840 850 -840 {}
L 1 810 -870 870 -870 {}
L 1 1087.5 -982.5 1092.5 -982.5 {}
L 1 1087.5 -980 1092.5 -980 {}
L 1 1087.5 -977.5 1092.5 -977.5 {}
L 1 1087.5 -975 1092.5 -975 {}
L 1 1087.5 -972.5 1092.5 -972.5 {}
L 1 1087.5 -970 1092.5 -970 {}
L 1 1087.5 -967.5 1092.5 -967.5 {}
L 1 1087.5 -965 1092.5 -965 {}
L 1 1087.5 -962.5 1092.5 -962.5 {}
L 1 2370 -990 2370 -960 {}
L 1 2240 -960 2370 -960 {}
L 1 2240 -990 2240 -850 {}
L 1 2240 -790 2240 -770 {}
L 1 2240 -710 2240 -690 {}
L 1 2240 -1070 2240 -1020 {}
L 1 2240 -1070 2370 -1070 {}
L 1 2370 -1070 2370 -1020 {}
L 1 2240 -740 2240 -710 {}
L 1 2240 -820 2290 -820 {}
L 1 2290 -820 2290 -710 {}
L 1 2240 -710 2290 -710 {}
L 1 2200 -1020 2200 -820 {}
L 1 2330 -1020 2330 -940 {}
L 1 2180 -940 2330 -940 {}
L 1 2180 -940 2180 -740 {}
L 1 2180 -740 2200 -740 {}
L 1 2140 -840 2180 -840 {}
L 1 2140 -870 2200 -870 {}
L 1 537.5 -512.5 542.5 -512.5 {}
L 1 537.5 -510 542.5 -510 {}
L 1 537.5 -507.5 542.5 -507.5 {}
L 1 537.5 -505 542.5 -505 {}
L 1 537.5 -502.5 542.5 -502.5 {}
L 1 537.5 -500 542.5 -500 {}
L 1 537.5 -497.5 542.5 -497.5 {}
L 1 537.5 -495 542.5 -495 {}
L 1 537.5 -492.5 542.5 -492.5 {}
L 1 947.5 -572.5 952.5 -572.5 {}
L 1 947.5 -570 952.5 -570 {}
L 1 947.5 -567.5 952.5 -567.5 {}
L 1 947.5 -565 952.5 -565 {}
L 1 947.5 -562.5 952.5 -562.5 {}
L 1 947.5 -560 952.5 -560 {}
L 1 947.5 -557.5 952.5 -557.5 {}
L 1 947.5 -555 952.5 -555 {}
L 1 947.5 -552.5 952.5 -552.5 {}
L 1 1237.5 -452.5 1242.5 -452.5 {}
L 1 1237.5 -450 1242.5 -450 {}
L 1 1237.5 -447.5 1242.5 -447.5 {}
L 1 1237.5 -445 1242.5 -445 {}
L 1 1237.5 -442.5 1242.5 -442.5 {}
L 1 1237.5 -440 1242.5 -440 {}
L 1 1237.5 -437.5 1242.5 -437.5 {}
L 1 1237.5 -435 1242.5 -435 {}
L 1 1237.5 -432.5 1242.5 -432.5 {}
L 1 1417.5 -512.5 1422.5 -512.5 {}
L 1 1417.5 -510 1422.5 -510 {}
L 1 1417.5 -507.5 1422.5 -507.5 {}
L 1 1417.5 -505 1422.5 -505 {}
L 1 1417.5 -502.5 1422.5 -502.5 {}
L 1 1417.5 -500 1422.5 -500 {}
L 1 1417.5 -497.5 1422.5 -497.5 {}
L 1 1417.5 -495 1422.5 -495 {}
L 1 1417.5 -492.5 1422.5 -492.5 {}
L 1 1717.5 -482.5 1722.5 -482.5 {}
L 1 1717.5 -480 1722.5 -480 {}
L 1 1717.5 -477.5 1722.5 -477.5 {}
L 1 1717.5 -475 1722.5 -475 {}
L 1 1717.5 -472.5 1722.5 -472.5 {}
L 1 1717.5 -470 1722.5 -470 {}
L 1 1717.5 -467.5 1722.5 -467.5 {}
L 1 1717.5 -465 1722.5 -465 {}
L 1 1717.5 -462.5 1722.5 -462.5 {}
L 1 2087.5 -472.5 2092.5 -472.5 {}
L 1 2087.5 -470 2092.5 -470 {}
L 1 2087.5 -467.5 2092.5 -467.5 {}
L 1 2087.5 -465 2092.5 -465 {}
L 1 2087.5 -462.5 2092.5 -462.5 {}
L 1 2087.5 -460 2092.5 -460 {}
L 1 2087.5 -457.5 2092.5 -457.5 {}
L 1 2087.5 -455 2092.5 -455 {}
L 1 2087.5 -452.5 2092.5 -452.5 {}
L 1 2347.5 -422.5 2352.5 -422.5 {}
L 1 2347.5 -420 2352.5 -420 {}
L 1 2347.5 -417.5 2352.5 -417.5 {}
L 1 2347.5 -415 2352.5 -415 {}
L 1 2347.5 -412.5 2352.5 -412.5 {}
L 1 2347.5 -410 2352.5 -410 {}
L 1 2347.5 -407.5 2352.5 -407.5 {}
L 1 2347.5 -405 2352.5 -405 {}
L 1 2347.5 -402.5 2352.5 -402.5 {}
L 1 817.5 -121.25 822.5 -121.25 {}
L 1 817.5 -118.75 822.5 -118.75 {}
L 1 817.5 -116.25 822.5 -116.25 {}
L 1 817.5 -113.75 822.5 -113.75 {}
L 1 817.5 -111.25 822.5 -111.25 {}
L 1 817.5 -108.75 822.5 -108.75 {}
L 1 817.5 -106.25 822.5 -106.25 {}
L 1 817.5 -103.75 822.5 -103.75 {}
L 1 817.5 -101.25 822.5 -101.25 {}
L 1 1707.5 -142.5 1712.5 -142.5 {}
L 1 1707.5 -140 1712.5 -140 {}
L 1 1707.5 -137.5 1712.5 -137.5 {}
L 1 1707.5 -135 1712.5 -135 {}
L 1 1707.5 -132.5 1712.5 -132.5 {}
L 1 1707.5 -130 1712.5 -130 {}
L 1 1707.5 -127.5 1712.5 -127.5 {}
L 1 1707.5 -125 1712.5 -125 {}
L 1 1707.5 -122.5 1712.5 -122.5 {}
L 1 2257.5 -192.5 2262.5 -192.5 {}
L 1 2257.5 -190 2262.5 -190 {}
L 1 2257.5 -187.5 2262.5 -187.5 {}
L 1 2257.5 -185 2262.5 -185 {}
L 1 2257.5 -182.5 2262.5 -182.5 {}
L 1 2257.5 -180 2262.5 -180 {}
L 1 2257.5 -177.5 2262.5 -177.5 {}
L 1 2257.5 -175 2262.5 -175 {}
L 1 2257.5 -172.5 2262.5 -172.5 {}
L 1 1297.5 -10492.5 1302.5 -10492.5 {}
L 1 1297.5 -10490 1302.5 -10490 {}
L 1 1297.5 -10487.5 1302.5 -10487.5 {}
L 1 1297.5 -10485 1302.5 -10485 {}
L 1 1297.5 -10482.5 1302.5 -10482.5 {}
L 1 1297.5 -10480 1302.5 -10480 {}
L 1 1297.5 -10477.5 1302.5 -10477.5 {}
L 1 1297.5 -10475 1302.5 -10475 {}
L 1 1297.5 -10472.5 1302.5 -10472.5 {}
L 1 2547.5 -10552.5 2552.5 -10552.5 {}
L 1 2547.5 -10550 2552.5 -10550 {}
L 1 2547.5 -10547.5 2552.5 -10547.5 {}
L 1 2547.5 -10545 2552.5 -10545 {}
L 1 2547.5 -10542.5 2552.5 -10542.5 {}
L 1 2547.5 -10540 2552.5 -10540 {}
L 1 2547.5 -10537.5 2552.5 -10537.5 {}
L 1 2547.5 -10535 2552.5 -10535 {}
L 1 2547.5 -10532.5 2552.5 -10532.5 {}
L 1 1767.5 -10622.5 1772.5 -10622.5 {}
L 1 1767.5 -10620 1772.5 -10620 {}
L 1 1767.5 -10617.5 1772.5 -10617.5 {}
L 1 1767.5 -10615 1772.5 -10615 {}
L 1 1767.5 -10612.5 1772.5 -10612.5 {}
L 1 1767.5 -10610 1772.5 -10610 {}
L 1 1767.5 -10607.5 1772.5 -10607.5 {}
L 1 1767.5 -10605 1772.5 -10605 {}
L 1 1767.5 -10602.5 1772.5 -10602.5 {}
L 1 2547.5 -10142.5 2552.5 -10142.5 {}
L 1 2547.5 -10140 2552.5 -10140 {}
L 1 2547.5 -10137.5 2552.5 -10137.5 {}
L 1 2547.5 -10135 2552.5 -10135 {}
L 1 2547.5 -10132.5 2552.5 -10132.5 {}
L 1 2547.5 -10130 2552.5 -10130 {}
L 1 2547.5 -10127.5 2552.5 -10127.5 {}
L 1 2547.5 -10125 2552.5 -10125 {}
L 1 2547.5 -10122.5 2552.5 -10122.5 {}
L 1 1337.5 -10172.5 1342.5 -10172.5 {}
L 1 1337.5 -10170 1342.5 -10170 {}
L 1 1337.5 -10167.5 1342.5 -10167.5 {}
L 1 1337.5 -10165 1342.5 -10165 {}
L 1 1337.5 -10162.5 1342.5 -10162.5 {}
L 1 1337.5 -10160 1342.5 -10160 {}
L 1 1337.5 -10157.5 1342.5 -10157.5 {}
L 1 1337.5 -10155 1342.5 -10155 {}
L 1 1337.5 -10152.5 1342.5 -10152.5 {}
L 2 1255 -12560 1255 -12500 {}
L 2 1255 -12550 1270 -12550 {}
L 2 1270 -12560 1270 -12550 {}
L 2 1255 -12510 1270 -12510 {}
L 2 1270 -12510 1270 -12500 {}
L 2 1245 -12545 1245 -12515 {}
L 2 1245 -12530 1245 -12525 {}
L 2 1230 -12530 1237.5 -12530 {}
L 2 1230 -12530 1245 -12530 {}
L 2 1260 -12530 1270 -12530 {}
L 2 1255 -12535 1260 -12530 {}
L 2 1255 -12525 1260 -12530 {}
L 2 1270 -12600 1270 -12590 {}
L 2 1270 -12600 1277.5 -12602.5 {}
L 2 1262.5 -12607.5 1277.5 -12602.5 {}
L 2 1262.5 -12607.5 1277.5 -12612.5 {}
L 2 1262.5 -12617.5 1277.5 -12612.5 {}
L 2 1262.5 -12617.5 1277.5 -12622.5 {}
L 2 1262.5 -12627.5 1277.5 -12622.5 {}
L 2 1262.5 -12627.5 1277.5 -12632.5 {}
L 2 1262.5 -12637.5 1277.5 -12632.5 {}
L 2 1262.5 -12637.5 1270 -12640 {}
L 2 1270 -12650 1270 -12640 {}
L 2 1272.5 -12642.5 1277.5 -12642.5 {}
L 2 1275 -12645 1275 -12640 {}
L 2 1360 -12525 1360 -12500 {}
L 2 1360 -12560 1360 -12535 {}
L 2 1350 -12535 1370 -12535 {}
L 2 1350 -12525 1370 -12525 {}
L 2 1362.5 -12552.5 1367.5 -12552.5 {}
L 2 1365 -12555 1365 -12550 {}
L 2 1270 -12590 1270 -12560 {}
L 2 1270 -12680 1270 -12650 {}
L 2 1360 -12500 1360 -12420 {}
L 2 1270 -12530 1270 -12420 {}
L 2 1270 -12420 1360 -12420 {}
L 2 2035 -12570 2035 -12510 {}
L 2 2035 -12560 2050 -12560 {}
L 2 2050 -12570 2050 -12560 {}
L 2 2035 -12520 2050 -12520 {}
L 2 2050 -12520 2050 -12510 {}
L 2 2025 -12555 2025 -12525 {}
L 2 2025 -12540 2025 -12535 {}
L 2 2010 -12540 2017.5 -12540 {}
L 2 2010 -12540 2025 -12540 {}
L 2 2040 -12540 2050 -12540 {}
L 2 2035 -12545 2040 -12540 {}
L 2 2035 -12535 2040 -12540 {}
L 2 2050 -12610 2050 -12600 {}
L 2 2050 -12610 2057.5 -12612.5 {}
L 2 2042.5 -12617.5 2057.5 -12612.5 {}
L 2 2042.5 -12617.5 2057.5 -12622.5 {}
L 2 2042.5 -12627.5 2057.5 -12622.5 {}
L 2 2042.5 -12627.5 2057.5 -12632.5 {}
L 2 2042.5 -12637.5 2057.5 -12632.5 {}
L 2 2042.5 -12637.5 2057.5 -12642.5 {}
L 2 2042.5 -12647.5 2057.5 -12642.5 {}
L 2 2042.5 -12647.5 2050 -12650 {}
L 2 2050 -12660 2050 -12650 {}
L 2 2052.5 -12652.5 2057.5 -12652.5 {}
L 2 2055 -12655 2055 -12650 {}
L 2 2140 -12535 2140 -12510 {}
L 2 2140 -12570 2140 -12545 {}
L 2 2130 -12545 2150 -12545 {}
L 2 2130 -12535 2150 -12535 {}
L 2 2142.5 -12562.5 2147.5 -12562.5 {}
L 2 2145 -12565 2145 -12560 {}
L 2 2050 -12600 2050 -12570 {}
L 2 2050 -12690 2050 -12660 {}
L 2 2140 -12510 2140 -12430 {}
L 2 2050 -12540 2050 -12430 {}
L 2 2050 -12430 2140 -12430 {}
L 2 1360 -12140 1360 -12130 {}
L 2 1360 -12140 1367.5 -12142.5 {}
L 2 1352.5 -12147.5 1367.5 -12142.5 {}
L 2 1352.5 -12147.5 1367.5 -12152.5 {}
L 2 1352.5 -12157.5 1367.5 -12152.5 {}
L 2 1352.5 -12157.5 1367.5 -12162.5 {}
L 2 1352.5 -12167.5 1367.5 -12162.5 {}
L 2 1352.5 -12167.5 1367.5 -12172.5 {}
L 2 1352.5 -12177.5 1367.5 -12172.5 {}
L 2 1352.5 -12177.5 1360 -12180 {}
L 2 1360 -12190 1360 -12180 {}
L 2 1362.5 -12182.5 1367.5 -12182.5 {}
L 2 1365 -12185 1365 -12180 {}
L 2 1360 -7710 1360 -7700 {}
L 2 1360 -7710 1367.5 -7712.5 {}
L 2 1352.5 -7717.5 1367.5 -7712.5 {}
L 2 1352.5 -7717.5 1367.5 -7722.5 {}
L 2 1352.5 -7727.5 1367.5 -7722.5 {}
L 2 1352.5 -7727.5 1367.5 -7732.5 {}
L 2 1352.5 -7737.5 1367.5 -7732.5 {}
L 2 1352.5 -7737.5 1367.5 -7742.5 {}
L 2 1352.5 -7747.5 1367.5 -7742.5 {}
L 2 1352.5 -7747.5 1360 -7750 {}
L 2 1360 -7760 1360 -7750 {}
L 2 1362.5 -7752.5 1367.5 -7752.5 {}
L 2 1365 -7755 1365 -7750 {}
L 2 1280 -7760 1360 -7760 {}
L 2 1280 -7700 1360 -7700 {}
L 2 1360 -7310 1360 -7300 {}
L 2 1360 -7310 1367.5 -7312.5 {}
L 2 1352.5 -7317.5 1367.5 -7312.5 {}
L 2 1352.5 -7317.5 1367.5 -7322.5 {}
L 2 1352.5 -7327.5 1367.5 -7322.5 {}
L 2 1352.5 -7327.5 1367.5 -7332.5 {}
L 2 1352.5 -7337.5 1367.5 -7332.5 {}
L 2 1352.5 -7337.5 1367.5 -7342.5 {}
L 2 1352.5 -7347.5 1367.5 -7342.5 {}
L 2 1352.5 -7347.5 1360 -7350 {}
L 2 1360 -7360 1360 -7350 {}
L 2 1362.5 -7352.5 1367.5 -7352.5 {}
L 2 1365 -7355 1365 -7350 {}
L 2 1280 -7270 1360 -7300 {}
L 2 1280 -7390 1360 -7360 {}
L 2 725 -12560 725 -12500 {}
L 2 725 -12550 740 -12550 {}
L 2 740 -12560 740 -12550 {}
L 2 725 -12510 740 -12510 {}
L 2 740 -12510 740 -12500 {}
L 2 715 -12545 715 -12515 {}
L 2 715 -12530 715 -12525 {}
L 2 700 -12530 707.5 -12530 {}
L 2 700 -12530 715 -12530 {}
L 2 730 -12530 740 -12530 {}
L 2 725 -12535 730 -12530 {}
L 2 725 -12525 730 -12530 {}
L 2 740 -12600 740 -12590 {}
L 2 740 -12600 747.5 -12602.5 {}
L 2 732.5 -12607.5 747.5 -12602.5 {}
L 2 732.5 -12607.5 747.5 -12612.5 {}
L 2 732.5 -12617.5 747.5 -12612.5 {}
L 2 732.5 -12617.5 747.5 -12622.5 {}
L 2 732.5 -12627.5 747.5 -12622.5 {}
L 2 732.5 -12627.5 747.5 -12632.5 {}
L 2 732.5 -12637.5 747.5 -12632.5 {}
L 2 732.5 -12637.5 740 -12640 {}
L 2 740 -12650 740 -12640 {}
L 2 742.5 -12642.5 747.5 -12642.5 {}
L 2 745 -12645 745 -12640 {}
L 2 830 -12525 830 -12500 {}
L 2 830 -12560 830 -12535 {}
L 2 820 -12535 840 -12535 {}
L 2 820 -12525 840 -12525 {}
L 2 832.5 -12552.5 837.5 -12552.5 {}
L 2 835 -12555 835 -12550 {}
L 2 740 -12590 740 -12560 {}
L 2 740 -12680 740 -12650 {}
L 2 830 -12500 830 -12420 {}
L 2 740 -12530 740 -12420 {}
L 2 740 -12420 830 -12420 {}
L 2 725 -6830 725 -6770 {}
L 2 725 -6820 740 -6820 {}
L 2 740 -6830 740 -6820 {}
L 2 725 -6780 740 -6780 {}
L 2 740 -6780 740 -6770 {}
L 2 715 -6815 715 -6785 {}
L 2 715 -6800 715 -6795 {}
L 2 700 -6800 707.5 -6800 {}
L 2 700 -6800 715 -6800 {}
L 2 730 -6800 740 -6800 {}
L 2 725 -6805 730 -6800 {}
L 2 725 -6795 730 -6800 {}
L 2 740 -6870 740 -6860 {}
L 2 740 -6870 747.5 -6872.5 {}
L 2 732.5 -6877.5 747.5 -6872.5 {}
L 2 732.5 -6877.5 747.5 -6882.5 {}
L 2 732.5 -6887.5 747.5 -6882.5 {}
L 2 732.5 -6887.5 747.5 -6892.5 {}
L 2 732.5 -6897.5 747.5 -6892.5 {}
L 2 732.5 -6897.5 747.5 -6902.5 {}
L 2 732.5 -6907.5 747.5 -6902.5 {}
L 2 732.5 -6907.5 740 -6910 {}
L 2 740 -6920 740 -6910 {}
L 2 742.5 -6912.5 747.5 -6912.5 {}
L 2 745 -6915 745 -6910 {}
L 2 830 -6795 830 -6770 {}
L 2 830 -6830 830 -6805 {}
L 2 820 -6805 840 -6805 {}
L 2 820 -6795 840 -6795 {}
L 2 832.5 -6822.5 837.5 -6822.5 {}
L 2 835 -6825 835 -6820 {}
L 2 740 -6860 740 -6830 {}
L 2 740 -6950 740 -6920 {}
L 2 830 -6770 830 -6690 {}
L 2 740 -6800 740 -6690 {}
L 2 740 -6690 830 -6690 {}
L 2 880 -6830 888.75 -6830 {}
L 2 740 -6830 880 -6830 {}
L 2 1285 -6830 1285 -6770 {}
L 2 1285 -6820 1300 -6820 {}
L 2 1300 -6830 1300 -6820 {}
L 2 1285 -6780 1300 -6780 {}
L 2 1300 -6780 1300 -6770 {}
L 2 1275 -6815 1275 -6785 {}
L 2 1275 -6800 1275 -6795 {}
L 2 1260 -6800 1267.5 -6800 {}
L 2 1260 -6800 1275 -6800 {}
L 2 1290 -6800 1300 -6800 {}
L 2 1285 -6805 1290 -6800 {}
L 2 1285 -6795 1290 -6800 {}
L 2 1300 -6870 1300 -6860 {}
L 2 1300 -6870 1307.5 -6872.5 {}
L 2 1292.5 -6877.5 1307.5 -6872.5 {}
L 2 1292.5 -6877.5 1307.5 -6882.5 {}
L 2 1292.5 -6887.5 1307.5 -6882.5 {}
L 2 1292.5 -6887.5 1307.5 -6892.5 {}
L 2 1292.5 -6897.5 1307.5 -6892.5 {}
L 2 1292.5 -6897.5 1307.5 -6902.5 {}
L 2 1292.5 -6907.5 1307.5 -6902.5 {}
L 2 1292.5 -6907.5 1300 -6910 {}
L 2 1300 -6920 1300 -6910 {}
L 2 1302.5 -6912.5 1307.5 -6912.5 {}
L 2 1305 -6915 1305 -6910 {}
L 2 1390 -6795 1390 -6770 {}
L 2 1390 -6830 1390 -6805 {}
L 2 1380 -6805 1400 -6805 {}
L 2 1380 -6795 1400 -6795 {}
L 2 1392.5 -6822.5 1397.5 -6822.5 {}
L 2 1395 -6825 1395 -6820 {}
L 2 1440 -6830 1448.75 -6830 {}
L 2 1300 -6860 1300 -6830 {}
L 2 1300 -6950 1300 -6920 {}
L 2 1300 -6830 1440 -6830 {}
L 2 1390 -6770 1390 -6690 {}
L 2 1300 -6800 1300 -6690 {}
L 2 1300 -6690 1390 -6690 {}
L 2 2105 -6830 2105 -6770 {}
L 2 2105 -6820 2120 -6820 {}
L 2 2120 -6830 2120 -6820 {}
L 2 2105 -6780 2120 -6780 {}
L 2 2120 -6780 2120 -6770 {}
L 2 2095 -6815 2095 -6785 {}
L 2 2095 -6800 2095 -6795 {}
L 2 2080 -6800 2087.5 -6800 {}
L 2 2080 -6800 2095 -6800 {}
L 2 2110 -6800 2120 -6800 {}
L 2 2105 -6805 2110 -6800 {}
L 2 2105 -6795 2110 -6800 {}
L 2 2120 -6870 2120 -6860 {}
L 2 2120 -6870 2127.5 -6872.5 {}
L 2 2112.5 -6877.5 2127.5 -6872.5 {}
L 2 2112.5 -6877.5 2127.5 -6882.5 {}
L 2 2112.5 -6887.5 2127.5 -6882.5 {}
L 2 2112.5 -6887.5 2127.5 -6892.5 {}
L 2 2112.5 -6897.5 2127.5 -6892.5 {}
L 2 2112.5 -6897.5 2127.5 -6902.5 {}
L 2 2112.5 -6907.5 2127.5 -6902.5 {}
L 2 2112.5 -6907.5 2120 -6910 {}
L 2 2120 -6920 2120 -6910 {}
L 2 2122.5 -6912.5 2127.5 -6912.5 {}
L 2 2125 -6915 2125 -6910 {}
L 2 2210 -6795 2210 -6770 {}
L 2 2210 -6830 2210 -6805 {}
L 2 2200 -6805 2220 -6805 {}
L 2 2200 -6795 2220 -6795 {}
L 2 2212.5 -6822.5 2217.5 -6822.5 {}
L 2 2215 -6825 2215 -6820 {}
L 2 2260 -6830 2268.75 -6830 {}
L 2 2120 -6860 2120 -6830 {}
L 2 2120 -6950 2120 -6920 {}
L 2 2120 -6830 2260 -6830 {}
L 2 2210 -6770 2210 -6690 {}
L 2 2120 -6800 2120 -6690 {}
L 2 2120 -6690 2210 -6690 {}
L 2 1770 -6800 2080 -6800 {}
L 2 1690 -6950 2120 -6950 {}
L 2 1690 -6690 2120 -6690 {}
L 2 1255 -11730 1255 -11670 {}
L 2 1255 -11720 1270 -11720 {}
L 2 1270 -11730 1270 -11720 {}
L 2 1255 -11680 1270 -11680 {}
L 2 1270 -11680 1270 -11670 {}
L 2 1245 -11715 1245 -11685 {}
L 2 1245 -11700 1245 -11695 {}
L 2 1230 -11700 1237.5 -11700 {}
L 2 1230 -11700 1245 -11700 {}
L 2 1260 -11700 1270 -11700 {}
L 2 1255 -11705 1260 -11700 {}
L 2 1255 -11695 1260 -11700 {}
L 2 1270 -11770 1270 -11760 {}
L 2 1270 -11770 1277.5 -11772.5 {}
L 2 1262.5 -11777.5 1277.5 -11772.5 {}
L 2 1262.5 -11777.5 1277.5 -11782.5 {}
L 2 1262.5 -11787.5 1277.5 -11782.5 {}
L 2 1262.5 -11787.5 1277.5 -11792.5 {}
L 2 1262.5 -11797.5 1277.5 -11792.5 {}
L 2 1262.5 -11797.5 1277.5 -11802.5 {}
L 2 1262.5 -11807.5 1277.5 -11802.5 {}
L 2 1262.5 -11807.5 1270 -11810 {}
L 2 1270 -11820 1270 -11810 {}
L 2 1272.5 -11812.5 1277.5 -11812.5 {}
L 2 1275 -11815 1275 -11810 {}
L 2 1360 -11695 1360 -11670 {}
L 2 1360 -11730 1360 -11705 {}
L 2 1350 -11705 1370 -11705 {}
L 2 1350 -11695 1370 -11695 {}
L 2 1362.5 -11722.5 1367.5 -11722.5 {}
L 2 1365 -11725 1365 -11720 {}
L 2 1270 -11760 1270 -11730 {}
L 2 1270 -11850 1270 -11820 {}
L 2 1360 -11670 1360 -11590 {}
L 2 1270 -11700 1270 -11590 {}
L 2 1270 -11590 1360 -11590 {}
L 2 2035 -11740 2035 -11680 {}
L 2 2035 -11730 2050 -11730 {}
L 2 2050 -11740 2050 -11730 {}
L 2 2035 -11690 2050 -11690 {}
L 2 2050 -11690 2050 -11680 {}
L 2 2025 -11725 2025 -11695 {}
L 2 2025 -11710 2025 -11705 {}
L 2 2010 -11710 2017.5 -11710 {}
L 2 2010 -11710 2025 -11710 {}
L 2 2040 -11710 2050 -11710 {}
L 2 2035 -11715 2040 -11710 {}
L 2 2035 -11705 2040 -11710 {}
L 2 2050 -11780 2050 -11770 {}
L 2 2050 -11780 2057.5 -11782.5 {}
L 2 2042.5 -11787.5 2057.5 -11782.5 {}
L 2 2042.5 -11787.5 2057.5 -11792.5 {}
L 2 2042.5 -11797.5 2057.5 -11792.5 {}
L 2 2042.5 -11797.5 2057.5 -11802.5 {}
L 2 2042.5 -11807.5 2057.5 -11802.5 {}
L 2 2042.5 -11807.5 2057.5 -11812.5 {}
L 2 2042.5 -11817.5 2057.5 -11812.5 {}
L 2 2042.5 -11817.5 2050 -11820 {}
L 2 2050 -11830 2050 -11820 {}
L 2 2052.5 -11822.5 2057.5 -11822.5 {}
L 2 2055 -11825 2055 -11820 {}
L 2 2140 -11705 2140 -11680 {}
L 2 2140 -11740 2140 -11715 {}
L 2 2130 -11715 2150 -11715 {}
L 2 2130 -11705 2150 -11705 {}
L 2 2142.5 -11732.5 2147.5 -11732.5 {}
L 2 2145 -11735 2145 -11730 {}
L 2 2050 -11770 2050 -11740 {}
L 2 2050 -11860 2050 -11830 {}
L 2 2140 -11680 2140 -11600 {}
L 2 2050 -11710 2050 -11600 {}
L 2 2050 -11600 2140 -11600 {}
L 2 725 -11730 725 -11670 {}
L 2 725 -11720 740 -11720 {}
L 2 740 -11730 740 -11720 {}
L 2 725 -11680 740 -11680 {}
L 2 740 -11680 740 -11670 {}
L 2 715 -11715 715 -11685 {}
L 2 715 -11700 715 -11695 {}
L 2 700 -11700 707.5 -11700 {}
L 2 700 -11700 715 -11700 {}
L 2 730 -11700 740 -11700 {}
L 2 725 -11705 730 -11700 {}
L 2 725 -11695 730 -11700 {}
L 2 740 -11770 740 -11760 {}
L 2 740 -11770 747.5 -11772.5 {}
L 2 732.5 -11777.5 747.5 -11772.5 {}
L 2 732.5 -11777.5 747.5 -11782.5 {}
L 2 732.5 -11787.5 747.5 -11782.5 {}
L 2 732.5 -11787.5 747.5 -11792.5 {}
L 2 732.5 -11797.5 747.5 -11792.5 {}
L 2 732.5 -11797.5 747.5 -11802.5 {}
L 2 732.5 -11807.5 747.5 -11802.5 {}
L 2 732.5 -11807.5 740 -11810 {}
L 2 740 -11820 740 -11810 {}
L 2 742.5 -11812.5 747.5 -11812.5 {}
L 2 745 -11815 745 -11810 {}
L 2 830 -11695 830 -11670 {}
L 2 830 -11730 830 -11705 {}
L 2 820 -11705 840 -11705 {}
L 2 820 -11695 840 -11695 {}
L 2 832.5 -11722.5 837.5 -11722.5 {}
L 2 835 -11725 835 -11720 {}
L 2 740 -11760 740 -11730 {}
L 2 740 -11850 740 -11820 {}
L 2 830 -11670 830 -11590 {}
L 2 740 -11700 740 -11590 {}
L 2 740 -11590 830 -11590 {}
L 2 1795 -13030 1795 -12970 {}
L 2 1795 -13020 1810 -13020 {}
L 2 1810 -13030 1810 -13020 {}
L 2 1795 -12980 1810 -12980 {}
L 2 1810 -12980 1810 -12970 {}
L 2 1785 -13015 1785 -12985 {}
L 2 1785 -13000 1785 -12995 {}
L 2 1770 -13000 1777.5 -13000 {}
L 2 1770 -13000 1785 -13000 {}
L 2 1800 -13000 1810 -13000 {}
L 2 1795 -13005 1800 -13000 {}
L 2 1795 -12995 1800 -13000 {}
L 2 1810 -13070 1810 -13060 {}
L 2 1810 -13070 1817.5 -13072.5 {}
L 2 1802.5 -13077.5 1817.5 -13072.5 {}
L 2 1802.5 -13077.5 1817.5 -13082.5 {}
L 2 1802.5 -13087.5 1817.5 -13082.5 {}
L 2 1802.5 -13087.5 1817.5 -13092.5 {}
L 2 1802.5 -13097.5 1817.5 -13092.5 {}
L 2 1802.5 -13097.5 1817.5 -13102.5 {}
L 2 1802.5 -13107.5 1817.5 -13102.5 {}
L 2 1802.5 -13107.5 1810 -13110 {}
L 2 1810 -13120 1810 -13110 {}
L 2 1812.5 -13112.5 1817.5 -13112.5 {}
L 2 1815 -13115 1815 -13110 {}
L 2 1900 -12995 1900 -12970 {}
L 2 1900 -13030 1900 -13005 {}
L 2 1890 -13005 1910 -13005 {}
L 2 1890 -12995 1910 -12995 {}
L 2 1902.5 -13022.5 1907.5 -13022.5 {}
L 2 1905 -13025 1905 -13020 {}
L 2 1810 -13060 1810 -13030 {}
L 2 1810 -13150 1810 -13120 {}
L 2 1900 -12970 1900 -12890 {}
L 2 1810 -13000 1810 -12890 {}
L 2 1810 -12890 1900 -12890 {}
L 2 670 -13030 670 -12970 {}
L 2 670 -13020 685 -13020 {}
L 2 685 -13030 685 -13020 {}
L 2 670 -12980 685 -12980 {}
L 2 685 -12980 685 -12970 {}
L 2 660 -13015 660 -12985 {}
L 2 660 -13000 660 -12995 {}
L 2 645 -13000 652.5 -13000 {}
L 2 645 -13000 660 -13000 {}
L 2 675 -13000 685 -13000 {}
L 2 670 -13005 675 -13000 {}
L 2 670 -12995 675 -13000 {}
L 2 685 -13070 685 -13060 {}
L 2 685 -13070 692.5 -13072.5 {}
L 2 677.5 -13077.5 692.5 -13072.5 {}
L 2 677.5 -13077.5 692.5 -13082.5 {}
L 2 677.5 -13087.5 692.5 -13082.5 {}
L 2 677.5 -13087.5 692.5 -13092.5 {}
L 2 677.5 -13097.5 692.5 -13092.5 {}
L 2 677.5 -13097.5 692.5 -13102.5 {}
L 2 677.5 -13107.5 692.5 -13102.5 {}
L 2 677.5 -13107.5 685 -13110 {}
L 2 685 -13120 685 -13110 {}
L 2 687.5 -13112.5 692.5 -13112.5 {}
L 2 690 -13115 690 -13110 {}
L 2 775 -12995 775 -12970 {}
L 2 775 -13030 775 -13005 {}
L 2 765 -13005 785 -13005 {}
L 2 765 -12995 785 -12995 {}
L 2 777.5 -13022.5 782.5 -13022.5 {}
L 2 780 -13025 780 -13020 {}
L 2 685 -13060 685 -13030 {}
L 2 685 -13150 685 -13120 {}
L 2 775 -12970 775 -12890 {}
L 2 685 -13000 685 -12890 {}
L 2 685 -12890 775 -12890 {}
L 2 1572.5 -12962.5 1577.5 -12962.5 {}
L 2 1575 -12965 1575 -12960 {}
L 2 1570 -12970 1570 -12910 {}
L 2 1570 -12910 1570 -12890 {}
L 2 1570 -13150 1570 -12970 {}
L 2 2255 -13030 2255 -12970 {}
L 2 2255 -13020 2270 -13020 {}
L 2 2270 -13030 2270 -13020 {}
L 2 2255 -12980 2270 -12980 {}
L 2 2270 -12980 2270 -12970 {}
L 2 2245 -13015 2245 -12985 {}
L 2 2245 -13000 2245 -12995 {}
L 2 2230 -13000 2237.5 -13000 {}
L 2 2230 -13000 2245 -13000 {}
L 2 2260 -13000 2270 -13000 {}
L 2 2255 -13005 2260 -13000 {}
L 2 2255 -12995 2260 -13000 {}
L 2 2270 -13070 2270 -13060 {}
L 2 2270 -13070 2277.5 -13072.5 {}
L 2 2262.5 -13077.5 2277.5 -13072.5 {}
L 2 2262.5 -13077.5 2277.5 -13082.5 {}
L 2 2262.5 -13087.5 2277.5 -13082.5 {}
L 2 2262.5 -13087.5 2277.5 -13092.5 {}
L 2 2262.5 -13097.5 2277.5 -13092.5 {}
L 2 2262.5 -13097.5 2277.5 -13102.5 {}
L 2 2262.5 -13107.5 2277.5 -13102.5 {}
L 2 2262.5 -13107.5 2270 -13110 {}
L 2 2270 -13120 2270 -13110 {}
L 2 2272.5 -13112.5 2277.5 -13112.5 {}
L 2 2275 -13115 2275 -13110 {}
L 2 2270 -13060 2270 -13030 {}
L 2 2270 -13150 2270 -13120 {}
L 2 2270 -13000 2270 -12890 {}
L 2 2270 -12890 2360 -12890 {}
L 2 2032.5 -12962.5 2037.5 -12962.5 {}
L 2 2035 -12965 2035 -12960 {}
L 2 2030 -12970 2030 -12910 {}
L 2 2030 -12910 2030 -12890 {}
L 2 2030 -13150 2030 -12970 {}
L 2 520 -11010 760 -11010 {}
L 2 1060 -11010 1300 -11010 {}
L 2 2190 -11010 2500 -11080 {}
L 2 1360 -5910 1360 -5900 {}
L 2 1360 -5910 1367.5 -5912.5 {}
L 2 1352.5 -5917.5 1367.5 -5912.5 {}
L 2 1352.5 -5917.5 1367.5 -5922.5 {}
L 2 1352.5 -5927.5 1367.5 -5922.5 {}
L 2 1352.5 -5927.5 1367.5 -5932.5 {}
L 2 1352.5 -5937.5 1367.5 -5932.5 {}
L 2 1352.5 -5937.5 1367.5 -5942.5 {}
L 2 1352.5 -5947.5 1367.5 -5942.5 {}
L 2 1352.5 -5947.5 1360 -5950 {}
L 2 1360 -5960 1360 -5950 {}
L 2 1362.5 -5952.5 1367.5 -5952.5 {}
L 2 1365 -5955 1365 -5950 {}
L 2 1900 -5940 1900 -5900 {}
L 2 1360 -5230 1360 -5130 {}
L 2 1250 -5230 1250 -5130 {}
L 2 1470 -5230 1470 -5130 {}
L 2 1900 -5230 1900 -5130 {}
L 2 1790 -5230 1790 -5130 {}
L 2 2010 -5230 2010 -5130 {}
L 2 2430 -5330 2430 -5130 {}
L 2 2320 -5330 2320 -5130 {}
L 2 2540 -5330 2540 -5130 {}
L 2 1360 -3300 1360 -3200 {}
L 2 1250 -3300 1250 -3200 {}
L 2 1470 -3300 1470 -3200 {}
L 2 1250 -3150 1250 -3140 {}
L 2 1250 -3150 1257.5 -3152.5 {}
L 2 1242.5 -3157.5 1257.5 -3152.5 {}
L 2 1242.5 -3157.5 1257.5 -3162.5 {}
L 2 1242.5 -3167.5 1257.5 -3162.5 {}
L 2 1242.5 -3167.5 1257.5 -3172.5 {}
L 2 1242.5 -3177.5 1257.5 -3172.5 {}
L 2 1242.5 -3177.5 1257.5 -3182.5 {}
L 2 1242.5 -3187.5 1257.5 -3182.5 {}
L 2 1242.5 -3187.5 1250 -3190 {}
L 2 1250 -3200 1250 -3190 {}
L 2 1252.5 -3192.5 1257.5 -3192.5 {}
L 2 1255 -3195 1255 -3190 {}
L 2 1360 -3150 1360 -3140 {}
L 2 1360 -3150 1367.5 -3152.5 {}
L 2 1352.5 -3157.5 1367.5 -3152.5 {}
L 2 1352.5 -3157.5 1367.5 -3162.5 {}
L 2 1352.5 -3167.5 1367.5 -3162.5 {}
L 2 1352.5 -3167.5 1367.5 -3172.5 {}
L 2 1352.5 -3177.5 1367.5 -3172.5 {}
L 2 1352.5 -3177.5 1367.5 -3182.5 {}
L 2 1352.5 -3187.5 1367.5 -3182.5 {}
L 2 1352.5 -3187.5 1360 -3190 {}
L 2 1360 -3200 1360 -3190 {}
L 2 1362.5 -3192.5 1367.5 -3192.5 {}
L 2 1365 -3195 1365 -3190 {}
L 2 1470 -3150 1470 -3140 {}
L 2 1470 -3150 1477.5 -3152.5 {}
L 2 1462.5 -3157.5 1477.5 -3152.5 {}
L 2 1462.5 -3157.5 1477.5 -3162.5 {}
L 2 1462.5 -3167.5 1477.5 -3162.5 {}
L 2 1462.5 -3167.5 1477.5 -3172.5 {}
L 2 1462.5 -3177.5 1477.5 -3172.5 {}
L 2 1462.5 -3177.5 1477.5 -3182.5 {}
L 2 1462.5 -3187.5 1477.5 -3182.5 {}
L 2 1462.5 -3187.5 1470 -3190 {}
L 2 1470 -3200 1470 -3190 {}
L 2 1472.5 -3192.5 1477.5 -3192.5 {}
L 2 1475 -3195 1475 -3190 {}
L 2 1360 -3140 1360 -3110 {}
L 2 1250 -3140 1250 -3110 {}
L 2 1470 -3140 1470 -3110 {}
L 2 1900 -3300 1900 -3250 {}
L 2 1790 -3300 1790 -3250 {}
L 2 2010 -3300 2010 -3250 {}
L 2 1790 -3200 1790 -3190 {}
L 2 1790 -3200 1797.5 -3202.5 {}
L 2 1782.5 -3207.5 1797.5 -3202.5 {}
L 2 1782.5 -3207.5 1797.5 -3212.5 {}
L 2 1782.5 -3217.5 1797.5 -3212.5 {}
L 2 1782.5 -3217.5 1797.5 -3222.5 {}
L 2 1782.5 -3227.5 1797.5 -3222.5 {}
L 2 1782.5 -3227.5 1797.5 -3232.5 {}
L 2 1782.5 -3237.5 1797.5 -3232.5 {}
L 2 1782.5 -3237.5 1790 -3240 {}
L 2 1790 -3250 1790 -3240 {}
L 2 1792.5 -3242.5 1797.5 -3242.5 {}
L 2 1795 -3245 1795 -3240 {}
L 2 1900 -3200 1900 -3190 {}
L 2 1900 -3200 1907.5 -3202.5 {}
L 2 1892.5 -3207.5 1907.5 -3202.5 {}
L 2 1892.5 -3207.5 1907.5 -3212.5 {}
L 2 1892.5 -3217.5 1907.5 -3212.5 {}
L 2 1892.5 -3217.5 1907.5 -3222.5 {}
L 2 1892.5 -3227.5 1907.5 -3222.5 {}
L 2 1892.5 -3227.5 1907.5 -3232.5 {}
L 2 1892.5 -3237.5 1907.5 -3232.5 {}
L 2 1892.5 -3237.5 1900 -3240 {}
L 2 1900 -3250 1900 -3240 {}
L 2 1902.5 -3242.5 1907.5 -3242.5 {}
L 2 1905 -3245 1905 -3240 {}
L 2 2010 -3200 2010 -3190 {}
L 2 2010 -3200 2017.5 -3202.5 {}
L 2 2002.5 -3207.5 2017.5 -3202.5 {}
L 2 2002.5 -3207.5 2017.5 -3212.5 {}
L 2 2002.5 -3217.5 2017.5 -3212.5 {}
L 2 2002.5 -3217.5 2017.5 -3222.5 {}
L 2 2002.5 -3227.5 2017.5 -3222.5 {}
L 2 2002.5 -3227.5 2017.5 -3232.5 {}
L 2 2002.5 -3237.5 2017.5 -3232.5 {}
L 2 2002.5 -3237.5 2010 -3240 {}
L 2 2010 -3250 2010 -3240 {}
L 2 2012.5 -3242.5 2017.5 -3242.5 {}
L 2 2015 -3245 2015 -3240 {}
L 2 1900 -3190 1900 -3110 {}
L 2 1790 -3190 1790 -3110 {}
L 2 2010 -3190 2010 -3110 {}
L 2 635 -4870 635 -4810 {}
L 2 635 -4860 650 -4860 {}
L 2 650 -4870 650 -4860 {}
L 2 635 -4820 650 -4820 {}
L 2 650 -4820 650 -4810 {}
L 2 625 -4855 625 -4825 {}
L 2 625 -4840 625 -4835 {}
L 2 610 -4840 617.5 -4840 {}
L 2 610 -4840 625 -4840 {}
L 2 640 -4840 650 -4840 {}
L 2 635 -4845 640 -4840 {}
L 2 635 -4835 640 -4840 {}
L 2 1215 -4870 1215 -4810 {}
L 2 1215 -4860 1230 -4860 {}
L 2 1230 -4870 1230 -4860 {}
L 2 1215 -4820 1230 -4820 {}
L 2 1230 -4820 1230 -4810 {}
L 2 1205 -4855 1205 -4825 {}
L 2 1205 -4840 1205 -4835 {}
L 2 1190 -4840 1197.5 -4840 {}
L 2 1190 -4840 1205 -4840 {}
L 2 1220 -4840 1230 -4840 {}
L 2 1215 -4845 1220 -4840 {}
L 2 1215 -4835 1220 -4840 {}
L 2 1255 -13030 1255 -12970 {}
L 2 1255 -13020 1270 -13020 {}
L 2 1270 -13030 1270 -13020 {}
L 2 1255 -12980 1270 -12980 {}
L 2 1270 -12980 1270 -12970 {}
L 2 1245 -13015 1245 -12985 {}
L 2 1245 -13000 1245 -12995 {}
L 2 1230 -13000 1237.5 -13000 {}
L 2 1230 -13000 1245 -13000 {}
L 2 1260 -13000 1270 -13000 {}
L 2 1255 -13005 1260 -13000 {}
L 2 1255 -12995 1260 -13000 {}
L 2 1270 -13070 1270 -13060 {}
L 2 1270 -13070 1277.5 -13072.5 {}
L 2 1262.5 -13077.5 1277.5 -13072.5 {}
L 2 1262.5 -13077.5 1277.5 -13082.5 {}
L 2 1262.5 -13087.5 1277.5 -13082.5 {}
L 2 1262.5 -13087.5 1277.5 -13092.5 {}
L 2 1262.5 -13097.5 1277.5 -13092.5 {}
L 2 1262.5 -13097.5 1277.5 -13102.5 {}
L 2 1262.5 -13107.5 1277.5 -13102.5 {}
L 2 1262.5 -13107.5 1270 -13110 {}
L 2 1270 -13120 1270 -13110 {}
L 2 1272.5 -13112.5 1277.5 -13112.5 {}
L 2 1275 -13115 1275 -13110 {}
L 2 1360 -12995 1360 -12970 {}
L 2 1360 -13030 1360 -13005 {}
L 2 1350 -13005 1370 -13005 {}
L 2 1350 -12995 1370 -12995 {}
L 2 1362.5 -13022.5 1367.5 -13022.5 {}
L 2 1365 -13025 1365 -13020 {}
L 2 1270 -13060 1270 -13030 {}
L 2 1270 -13150 1270 -13120 {}
L 2 1360 -12970 1360 -12890 {}
L 2 1270 -13000 1270 -12890 {}
L 2 1270 -12890 1360 -12890 {}
L 2 1360 -2920 1360 -2820 {}
L 2 1250 -2920 1250 -2820 {}
L 2 1470 -2920 1470 -2820 {}
L 2 1250 -2770 1250 -2760 {}
L 2 1250 -2770 1257.5 -2772.5 {}
L 2 1242.5 -2777.5 1257.5 -2772.5 {}
L 2 1242.5 -2777.5 1257.5 -2782.5 {}
L 2 1242.5 -2787.5 1257.5 -2782.5 {}
L 2 1242.5 -2787.5 1257.5 -2792.5 {}
L 2 1242.5 -2797.5 1257.5 -2792.5 {}
L 2 1242.5 -2797.5 1257.5 -2802.5 {}
L 2 1242.5 -2807.5 1257.5 -2802.5 {}
L 2 1242.5 -2807.5 1250 -2810 {}
L 2 1250 -2820 1250 -2810 {}
L 2 1252.5 -2812.5 1257.5 -2812.5 {}
L 2 1255 -2815 1255 -2810 {}
L 2 1360 -2770 1360 -2760 {}
L 2 1360 -2770 1367.5 -2772.5 {}
L 2 1352.5 -2777.5 1367.5 -2772.5 {}
L 2 1352.5 -2777.5 1367.5 -2782.5 {}
L 2 1352.5 -2787.5 1367.5 -2782.5 {}
L 2 1352.5 -2787.5 1367.5 -2792.5 {}
L 2 1352.5 -2797.5 1367.5 -2792.5 {}
L 2 1352.5 -2797.5 1367.5 -2802.5 {}
L 2 1352.5 -2807.5 1367.5 -2802.5 {}
L 2 1352.5 -2807.5 1360 -2810 {}
L 2 1360 -2820 1360 -2810 {}
L 2 1362.5 -2812.5 1367.5 -2812.5 {}
L 2 1365 -2815 1365 -2810 {}
L 2 1470 -2770 1470 -2760 {}
L 2 1470 -2770 1477.5 -2772.5 {}
L 2 1462.5 -2777.5 1477.5 -2772.5 {}
L 2 1462.5 -2777.5 1477.5 -2782.5 {}
L 2 1462.5 -2787.5 1477.5 -2782.5 {}
L 2 1462.5 -2787.5 1477.5 -2792.5 {}
L 2 1462.5 -2797.5 1477.5 -2792.5 {}
L 2 1462.5 -2797.5 1477.5 -2802.5 {}
L 2 1462.5 -2807.5 1477.5 -2802.5 {}
L 2 1462.5 -2807.5 1470 -2810 {}
L 2 1470 -2820 1470 -2810 {}
L 2 1472.5 -2812.5 1477.5 -2812.5 {}
L 2 1475 -2815 1475 -2810 {}
L 2 1900 -2920 1900 -2870 {}
L 2 1790 -2920 1790 -2870 {}
L 2 2010 -2920 2010 -2870 {}
L 2 1790 -2820 1790 -2810 {}
L 2 1790 -2820 1797.5 -2822.5 {}
L 2 1782.5 -2827.5 1797.5 -2822.5 {}
L 2 1782.5 -2827.5 1797.5 -2832.5 {}
L 2 1782.5 -2837.5 1797.5 -2832.5 {}
L 2 1782.5 -2837.5 1797.5 -2842.5 {}
L 2 1782.5 -2847.5 1797.5 -2842.5 {}
L 2 1782.5 -2847.5 1797.5 -2852.5 {}
L 2 1782.5 -2857.5 1797.5 -2852.5 {}
L 2 1782.5 -2857.5 1790 -2860 {}
L 2 1790 -2870 1790 -2860 {}
L 2 1792.5 -2862.5 1797.5 -2862.5 {}
L 2 1795 -2865 1795 -2860 {}
L 2 1900 -2820 1900 -2810 {}
L 2 1900 -2820 1907.5 -2822.5 {}
L 2 1892.5 -2827.5 1907.5 -2822.5 {}
L 2 1892.5 -2827.5 1907.5 -2832.5 {}
L 2 1892.5 -2837.5 1907.5 -2832.5 {}
L 2 1892.5 -2837.5 1907.5 -2842.5 {}
L 2 1892.5 -2847.5 1907.5 -2842.5 {}
L 2 1892.5 -2847.5 1907.5 -2852.5 {}
L 2 1892.5 -2857.5 1907.5 -2852.5 {}
L 2 1892.5 -2857.5 1900 -2860 {}
L 2 1900 -2870 1900 -2860 {}
L 2 1902.5 -2862.5 1907.5 -2862.5 {}
L 2 1905 -2865 1905 -2860 {}
L 2 2010 -2820 2010 -2810 {}
L 2 2010 -2820 2017.5 -2822.5 {}
L 2 2002.5 -2827.5 2017.5 -2822.5 {}
L 2 2002.5 -2827.5 2017.5 -2832.5 {}
L 2 2002.5 -2837.5 2017.5 -2832.5 {}
L 2 2002.5 -2837.5 2017.5 -2842.5 {}
L 2 2002.5 -2847.5 2017.5 -2842.5 {}
L 2 2002.5 -2847.5 2017.5 -2852.5 {}
L 2 2002.5 -2857.5 2017.5 -2852.5 {}
L 2 2002.5 -2857.5 2010 -2860 {}
L 2 2010 -2870 2010 -2860 {}
L 2 2012.5 -2862.5 2017.5 -2862.5 {}
L 2 2015 -2865 2015 -2860 {}
L 2 1900 -2810 1900 -2730 {}
L 2 1790 -2810 1790 -2730 {}
L 2 2010 -2810 2010 -2730 {}
L 2 600 -4590 720 -4590 {}
L 2 1220 -4500 1340 -4500 {}
L 2 740 -4370 740 -4250 {}
L 2 1280 -4340 1280 -4220 {}
L 2 2280 -4260 2410 -4260 {}
L 2 2360 -5750 2440 -5580 {}
L 2 1900 -5750 1900 -5580 {}
L 2 1760 -3540 1880 -3540 {}
L 2 680 -3590 680 -3580 {}
L 2 680 -3590 687.5 -3592.5 {}
L 2 672.5 -3597.5 687.5 -3592.5 {}
L 2 672.5 -3597.5 687.5 -3602.5 {}
L 2 672.5 -3607.5 687.5 -3602.5 {}
L 2 672.5 -3607.5 687.5 -3612.5 {}
L 2 672.5 -3617.5 687.5 -3612.5 {}
L 2 672.5 -3617.5 687.5 -3622.5 {}
L 2 672.5 -3627.5 687.5 -3622.5 {}
L 2 672.5 -3627.5 680 -3630 {}
L 2 680 -3640 680 -3630 {}
L 2 682.5 -3632.5 687.5 -3632.5 {}
L 2 685 -3635 685 -3630 {}
L 2 800 -3590 800 -3580 {}
L 2 800 -3590 807.5 -3592.5 {}
L 2 792.5 -3597.5 807.5 -3592.5 {}
L 2 792.5 -3597.5 807.5 -3602.5 {}
L 2 792.5 -3607.5 807.5 -3602.5 {}
L 2 792.5 -3607.5 807.5 -3612.5 {}
L 2 792.5 -3617.5 807.5 -3612.5 {}
L 2 792.5 -3617.5 807.5 -3622.5 {}
L 2 792.5 -3627.5 807.5 -3622.5 {}
L 2 792.5 -3627.5 800 -3630 {}
L 2 800 -3640 800 -3630 {}
L 2 802.5 -3632.5 807.5 -3632.5 {}
L 2 805 -3635 805 -3630 {}
L 2 1220 -3590 1220 -3580 {}
L 2 1220 -3590 1227.5 -3592.5 {}
L 2 1212.5 -3597.5 1227.5 -3592.5 {}
L 2 1212.5 -3597.5 1227.5 -3602.5 {}
L 2 1212.5 -3607.5 1227.5 -3602.5 {}
L 2 1212.5 -3607.5 1227.5 -3612.5 {}
L 2 1212.5 -3617.5 1227.5 -3612.5 {}
L 2 1212.5 -3617.5 1227.5 -3622.5 {}
L 2 1212.5 -3627.5 1227.5 -3622.5 {}
L 2 1212.5 -3627.5 1220 -3630 {}
L 2 1220 -3640 1220 -3630 {}
L 2 1222.5 -3632.5 1227.5 -3632.5 {}
L 2 1225 -3635 1225 -3630 {}
L 2 1340 -3590 1340 -3580 {}
L 2 1340 -3590 1347.5 -3592.5 {}
L 2 1332.5 -3597.5 1347.5 -3592.5 {}
L 2 1332.5 -3597.5 1347.5 -3602.5 {}
L 2 1332.5 -3607.5 1347.5 -3602.5 {}
L 2 1332.5 -3607.5 1347.5 -3612.5 {}
L 2 1332.5 -3617.5 1347.5 -3612.5 {}
L 2 1332.5 -3617.5 1347.5 -3622.5 {}
L 2 1332.5 -3627.5 1347.5 -3622.5 {}
L 2 1332.5 -3627.5 1340 -3630 {}
L 2 1340 -3640 1340 -3630 {}
L 2 1342.5 -3632.5 1347.5 -3632.5 {}
L 2 1345 -3635 1345 -3630 {}
L 2 1510 -2325 1510 -2300 {}
L 2 1510 -2360 1510 -2335 {}
L 2 1500 -2335 1520 -2335 {}
L 2 1500 -2325 1520 -2325 {}
L 2 1512.5 -2352.5 1517.5 -2352.5 {}
L 2 1515 -2355 1515 -2350 {}
L 2 1510 -2300 1510 -2220 {}
L 2 1180 -2240 1180 -2220 {}
L 2 1420 -2330 1420 -2220 {}
L 2 1420 -2220 1510 -2220 {}
L 2 1180 -2220 1420 -2220 {}
L 2 1420 -2360 1560 -2360 {}
L 2 740 -3940 740 -3820 {}
L 2 1200 -3990 1200 -3870 {}
L 2 2360 -3900 2610 -3900 {}
L 2 2430 -2505 2430 -2480 {}
L 2 2430 -2540 2430 -2515 {}
L 2 2420 -2515 2440 -2515 {}
L 2 2420 -2505 2440 -2505 {}
L 2 2432.5 -2532.5 2437.5 -2532.5 {}
L 2 2435 -2535 2435 -2530 {}
L 2 2430 -2480 2430 -2400 {}
L 2 2100 -2420 2100 -2400 {}
L 2 2340 -2510 2340 -2400 {}
L 2 2340 -2400 2430 -2400 {}
L 2 2100 -2400 2340 -2400 {}
L 2 2340 -2540 2480 -2540 {}
L 2 560 -9770 560 -9660 {}
L 2 1320 -9770 1380 -9770 {}
L 2 850 -6385 850 -6360 {}
L 2 850 -6420 850 -6395 {}
L 2 840 -6395 860 -6395 {}
L 2 840 -6385 860 -6385 {}
L 2 852.5 -6412.5 857.5 -6412.5 {}
L 2 855 -6415 855 -6410 {}
L 2 850 -6360 850 -6280 {}
L 2 1710 -6385 1710 -6360 {}
L 2 1710 -6420 1710 -6395 {}
L 2 1700 -6395 1720 -6395 {}
L 2 1700 -6385 1720 -6385 {}
L 2 1712.5 -6412.5 1717.5 -6412.5 {}
L 2 1715 -6415 1715 -6410 {}
L 2 1710 -6360 1710 -6280 {}
L 2 2470 -6385 2470 -6360 {}
L 2 2470 -6420 2470 -6395 {}
L 2 2460 -6395 2480 -6395 {}
L 2 2460 -6385 2480 -6385 {}
L 2 2472.5 -6412.5 2477.5 -6412.5 {}
L 2 2475 -6415 2475 -6410 {}
L 2 2470 -6360 2470 -6280 {}
L 2 805 -11420 885 -11420 {}
L 2 1330 -11310 1410 -11310 {}
L 2 1830 -11310 1910 -11310 {}
L 2 2260 -11310 2400 -11310 {}
L 2 1850 -9770 1910 -9770 {}
L 2 2150 -9600 2210 -9600 {}
L 2 515 -9410 515 -9350 {}
L 2 515 -9400 530 -9400 {}
L 2 530 -9410 530 -9400 {}
L 2 515 -9360 530 -9360 {}
L 2 530 -9360 530 -9350 {}
L 2 505 -9395 505 -9365 {}
L 2 505 -9380 505 -9375 {}
L 2 490 -9380 497.5 -9380 {}
L 2 490 -9380 505 -9380 {}
L 2 520 -9380 530 -9380 {}
L 2 515 -9385 520 -9380 {}
L 2 515 -9375 520 -9380 {}
L 2 455 -9380 460 -9380 {}
L 2 460 -9380 490 -9380 {}
L 2 530 -9380 530 -9270 {}
L 2 790 -9325 850 -9325 {}
L 2 840 -9325 840 -9310 {}
L 2 840 -9310 850 -9310 {}
L 2 800 -9325 800 -9310 {}
L 2 790 -9310 800 -9310 {}
L 2 805 -9335 835 -9335 {}
L 2 815 -9335 820 -9335 {}
L 2 820 -9350 820 -9342.5 {}
L 2 820 -9350 820 -9335 {}
L 2 820 -9320 820 -9310 {}
L 2 820 -9320 825 -9325 {}
L 2 815 -9325 820 -9320 {}
L 2 820 -9385 820 -9380 {}
L 2 820 -9380 820 -9350 {}
L 2 710 -9310 820 -9310 {}
L 2 1115 -9340 1115 -9280 {}
L 2 1100 -9290 1115 -9290 {}
L 2 1100 -9290 1100 -9280 {}
L 2 1100 -9330 1115 -9330 {}
L 2 1100 -9340 1100 -9330 {}
L 2 1125 -9325 1125 -9295 {}
L 2 1125 -9315 1125 -9310 {}
L 2 1132.5 -9310 1140 -9310 {}
L 2 1125 -9310 1140 -9310 {}
L 2 1100 -9310 1110 -9310 {}
L 2 1110 -9310 1115 -9305 {}
L 2 1110 -9310 1115 -9315 {}
L 2 1170 -9310 1175 -9310 {}
L 2 1140 -9310 1170 -9310 {}
L 2 1100 -9420 1100 -9310 {}
L 2 1380 -9375 1440 -9375 {}
L 2 1390 -9390 1390 -9375 {}
L 2 1380 -9390 1390 -9390 {}
L 2 1430 -9390 1430 -9375 {}
L 2 1430 -9390 1440 -9390 {}
L 2 1395 -9365 1425 -9365 {}
L 2 1410 -9365 1415 -9365 {}
L 2 1410 -9357.5 1410 -9350 {}
L 2 1410 -9365 1410 -9350 {}
L 2 1410 -9390 1410 -9380 {}
L 2 1405 -9375 1410 -9380 {}
L 2 1410 -9380 1415 -9375 {}
L 2 1410 -9320 1410 -9315 {}
L 2 1410 -9350 1410 -9320 {}
L 2 1410 -9390 1520 -9390 {}
L 2 1720 -9375 1780 -9375 {}
L 2 1770 -9390 1770 -9375 {}
L 2 1770 -9390 1780 -9390 {}
L 2 1730 -9390 1730 -9375 {}
L 2 1720 -9390 1730 -9390 {}
L 2 1735 -9365 1765 -9365 {}
L 2 1745 -9365 1750 -9365 {}
L 2 1750 -9357.5 1750 -9350 {}
L 2 1750 -9365 1750 -9350 {}
L 2 1750 -9390 1750 -9380 {}
L 2 1750 -9380 1755 -9375 {}
L 2 1745 -9375 1750 -9380 {}
L 2 1750 -9320 1750 -9315 {}
L 2 1750 -9350 1750 -9320 {}
L 2 1640 -9390 1750 -9390 {}
L 2 2050 -9335 2110 -9335 {}
L 2 2100 -9335 2100 -9320 {}
L 2 2100 -9320 2110 -9320 {}
L 2 2060 -9335 2060 -9320 {}
L 2 2050 -9320 2060 -9320 {}
L 2 2065 -9345 2095 -9345 {}
L 2 2075 -9345 2080 -9345 {}
L 2 2080 -9360 2080 -9352.5 {}
L 2 2080 -9360 2080 -9345 {}
L 2 2080 -9330 2080 -9320 {}
L 2 2080 -9330 2085 -9335 {}
L 2 2075 -9335 2080 -9330 {}
L 2 2080 -9395 2080 -9390 {}
L 2 2080 -9390 2080 -9360 {}
L 2 1970 -9320 2080 -9320 {}
L 2 530 -9030 770 -9030 {}
L 2 755 -8910 755 -8850 {}
L 2 755 -8900 770 -8900 {}
L 2 770 -8910 770 -8900 {}
L 2 755 -8860 770 -8860 {}
L 2 770 -8860 770 -8850 {}
L 2 745 -8895 745 -8865 {}
L 2 745 -8880 745 -8875 {}
L 2 730 -8880 737.5 -8880 {}
L 2 730 -8880 745 -8880 {}
L 2 760 -8880 770 -8880 {}
L 2 755 -8885 760 -8880 {}
L 2 755 -8875 760 -8880 {}
L 2 770 -8950 770 -8940 {}
L 2 770 -8950 777.5 -8952.5 {}
L 2 762.5 -8957.5 777.5 -8952.5 {}
L 2 762.5 -8957.5 777.5 -8962.5 {}
L 2 762.5 -8967.5 777.5 -8962.5 {}
L 2 762.5 -8967.5 777.5 -8972.5 {}
L 2 762.5 -8977.5 777.5 -8972.5 {}
L 2 762.5 -8977.5 777.5 -8982.5 {}
L 2 762.5 -8987.5 777.5 -8982.5 {}
L 2 762.5 -8987.5 770 -8990 {}
L 2 770 -9000 770 -8990 {}
L 2 772.5 -8992.5 777.5 -8992.5 {}
L 2 775 -8995 775 -8990 {}
L 2 860 -8875 860 -8850 {}
L 2 860 -8910 860 -8885 {}
L 2 850 -8885 870 -8885 {}
L 2 850 -8875 870 -8875 {}
L 2 862.5 -8902.5 867.5 -8902.5 {}
L 2 865 -8905 865 -8900 {}
L 2 532.5 -8842.5 537.5 -8842.5 {}
L 2 535 -8845 535 -8840 {}
L 2 530 -8850 530 -8790 {}
L 2 640 -8770 640 -8757.5 {}
L 2 635 -8757.5 645 -8757.5 {}
L 2 640 -8752.5 645 -8757.5 {}
L 2 635 -8757.5 640 -8752.5 {}
L 2 640 -9050 640 -9030 {}
L 2 630 -9050 650 -9050 {}
L 2 605 -8880 610 -8880 {}
L 2 610 -8880 730 -8880 {}
L 2 770 -8940 770 -8910 {}
L 2 770 -9030 770 -9000 {}
L 2 860 -8850 860 -8770 {}
L 2 530 -8790 530 -8770 {}
L 2 530 -9030 530 -8850 {}
L 2 770 -8880 770 -8770 {}
L 2 770 -8770 860 -8770 {}
L 2 530 -8770 770 -8770 {}
L 2 1005 -9030 1245 -9030 {}
L 2 1230 -8910 1230 -8850 {}
L 2 1230 -8900 1245 -8900 {}
L 2 1245 -8910 1245 -8900 {}
L 2 1230 -8860 1245 -8860 {}
L 2 1245 -8860 1245 -8850 {}
L 2 1220 -8895 1220 -8865 {}
L 2 1220 -8880 1220 -8875 {}
L 2 1205 -8880 1212.5 -8880 {}
L 2 1205 -8880 1220 -8880 {}
L 2 1235 -8880 1245 -8880 {}
L 2 1230 -8885 1235 -8880 {}
L 2 1230 -8875 1235 -8880 {}
L 2 1245 -8950 1245 -8940 {}
L 2 1245 -8950 1252.5 -8952.5 {}
L 2 1237.5 -8957.5 1252.5 -8952.5 {}
L 2 1237.5 -8957.5 1252.5 -8962.5 {}
L 2 1237.5 -8967.5 1252.5 -8962.5 {}
L 2 1237.5 -8967.5 1252.5 -8972.5 {}
L 2 1237.5 -8977.5 1252.5 -8972.5 {}
L 2 1237.5 -8977.5 1252.5 -8982.5 {}
L 2 1237.5 -8987.5 1252.5 -8982.5 {}
L 2 1237.5 -8987.5 1245 -8990 {}
L 2 1245 -9000 1245 -8990 {}
L 2 1247.5 -8992.5 1252.5 -8992.5 {}
L 2 1250 -8995 1250 -8990 {}
L 2 1335 -8875 1335 -8850 {}
L 2 1335 -8910 1335 -8885 {}
L 2 1325 -8885 1345 -8885 {}
L 2 1325 -8875 1345 -8875 {}
L 2 1337.5 -8902.5 1342.5 -8902.5 {}
L 2 1340 -8905 1340 -8900 {}
L 2 1007.5 -8842.5 1012.5 -8842.5 {}
L 2 1010 -8845 1010 -8840 {}
L 2 1005 -8850 1005 -8790 {}
L 2 1115 -8770 1115 -8757.5 {}
L 2 1110 -8757.5 1120 -8757.5 {}
L 2 1115 -8752.5 1120 -8757.5 {}
L 2 1110 -8757.5 1115 -8752.5 {}
L 2 1115 -9050 1115 -9030 {}
L 2 1105 -9050 1125 -9050 {}
L 2 1080 -8880 1085 -8880 {}
L 2 1085 -8880 1205 -8880 {}
L 2 1245 -8940 1245 -8910 {}
L 2 1245 -9030 1245 -9000 {}
L 2 1335 -8850 1335 -8770 {}
L 2 1005 -8790 1005 -8770 {}
L 2 1005 -9030 1005 -8850 {}
L 2 1245 -8880 1245 -8770 {}
L 2 1245 -8770 1335 -8770 {}
L 2 1005 -8770 1245 -8770 {}
L 2 1850 -9030 1850 -8790 {}
L 2 1670 -8805 1730 -8805 {}
L 2 1720 -8805 1720 -8790 {}
L 2 1720 -8790 1730 -8790 {}
L 2 1680 -8805 1680 -8790 {}
L 2 1670 -8790 1680 -8790 {}
L 2 1685 -8815 1715 -8815 {}
L 2 1695 -8815 1700 -8815 {}
L 2 1700 -8830 1700 -8822.5 {}
L 2 1700 -8830 1700 -8815 {}
L 2 1700 -8800 1700 -8790 {}
L 2 1700 -8800 1705 -8805 {}
L 2 1695 -8805 1700 -8800 {}
L 2 1760 -8790 1770 -8790 {}
L 2 1770 -8790 1772.5 -8782.5 {}
L 2 1772.5 -8782.5 1777.5 -8797.5 {}
L 2 1777.5 -8797.5 1782.5 -8782.5 {}
L 2 1782.5 -8782.5 1787.5 -8797.5 {}
L 2 1787.5 -8797.5 1792.5 -8782.5 {}
L 2 1792.5 -8782.5 1797.5 -8797.5 {}
L 2 1797.5 -8797.5 1802.5 -8782.5 {}
L 2 1802.5 -8782.5 1807.5 -8797.5 {}
L 2 1807.5 -8797.5 1810 -8790 {}
L 2 1810 -8790 1820 -8790 {}
L 2 1812.5 -8787.5 1812.5 -8782.5 {}
L 2 1810 -8785 1815 -8785 {}
L 2 1670 -8700 1695 -8700 {}
L 2 1705 -8700 1730 -8700 {}
L 2 1705 -8710 1705 -8690 {}
L 2 1695 -8710 1695 -8690 {}
L 2 1722.5 -8697.5 1722.5 -8692.5 {}
L 2 1720 -8695 1725 -8695 {}
L 2 1662.5 -9027.5 1662.5 -9022.5 {}
L 2 1660 -9025 1665 -9025 {}
L 2 1610 -9030 1670 -9030 {}
L 2 1577.5 -8920 1590 -8920 {}
L 2 1577.5 -8925 1577.5 -8915 {}
L 2 1572.5 -8920 1577.5 -8915 {}
L 2 1572.5 -8920 1577.5 -8925 {}
L 2 1850 -8920 1870 -8920 {}
L 2 1870 -8930 1870 -8910 {}
L 2 1700 -8955 1700 -8950 {}
L 2 1700 -8950 1700 -8830 {}
L 2 1730 -8790 1760 -8790 {}
L 2 1820 -8790 1850 -8790 {}
L 2 1590 -8700 1670 -8700 {}
L 2 1590 -9030 1610 -9030 {}
L 2 1670 -9030 1850 -9030 {}
L 2 1590 -8790 1700 -8790 {}
L 2 1590 -8790 1590 -8700 {}
L 2 1590 -9030 1590 -8790 {}
L 2 530 -8600 770 -8600 {}
L 2 755 -8480 755 -8420 {}
L 2 755 -8470 770 -8470 {}
L 2 770 -8480 770 -8470 {}
L 2 755 -8430 770 -8430 {}
L 2 770 -8430 770 -8420 {}
L 2 745 -8465 745 -8435 {}
L 2 745 -8450 745 -8445 {}
L 2 730 -8450 737.5 -8450 {}
L 2 730 -8450 745 -8450 {}
L 2 760 -8450 770 -8450 {}
L 2 755 -8455 760 -8450 {}
L 2 755 -8445 760 -8450 {}
L 2 770 -8520 770 -8510 {}
L 2 770 -8520 777.5 -8522.5 {}
L 2 762.5 -8527.5 777.5 -8522.5 {}
L 2 762.5 -8527.5 777.5 -8532.5 {}
L 2 762.5 -8537.5 777.5 -8532.5 {}
L 2 762.5 -8537.5 777.5 -8542.5 {}
L 2 762.5 -8547.5 777.5 -8542.5 {}
L 2 762.5 -8547.5 777.5 -8552.5 {}
L 2 762.5 -8557.5 777.5 -8552.5 {}
L 2 762.5 -8557.5 770 -8560 {}
L 2 770 -8570 770 -8560 {}
L 2 772.5 -8562.5 777.5 -8562.5 {}
L 2 775 -8565 775 -8560 {}
L 2 860 -8445 860 -8420 {}
L 2 860 -8480 860 -8455 {}
L 2 850 -8455 870 -8455 {}
L 2 850 -8445 870 -8445 {}
L 2 862.5 -8472.5 867.5 -8472.5 {}
L 2 865 -8475 865 -8470 {}
L 2 532.5 -8412.5 537.5 -8412.5 {}
L 2 535 -8415 535 -8410 {}
L 2 530 -8420 530 -8360 {}
L 2 640 -8340 640 -8327.5 {}
L 2 635 -8327.5 645 -8327.5 {}
L 2 640 -8322.5 645 -8327.5 {}
L 2 635 -8327.5 640 -8322.5 {}
L 2 640 -8620 640 -8600 {}
L 2 630 -8620 650 -8620 {}
L 2 605 -8450 610 -8450 {}
L 2 610 -8450 730 -8450 {}
L 2 770 -8510 770 -8480 {}
L 2 770 -8600 770 -8570 {}
L 2 860 -8420 860 -8340 {}
L 2 530 -8360 530 -8340 {}
L 2 530 -8600 530 -8420 {}
L 2 770 -8450 770 -8340 {}
L 2 770 -8340 860 -8340 {}
L 2 530 -8340 770 -8340 {}
L 2 980 -8600 1220 -8600 {}
L 2 1205 -8480 1205 -8420 {}
L 2 1205 -8470 1220 -8470 {}
L 2 1220 -8480 1220 -8470 {}
L 2 1205 -8430 1220 -8430 {}
L 2 1220 -8430 1220 -8420 {}
L 2 1195 -8465 1195 -8435 {}
L 2 1195 -8450 1195 -8445 {}
L 2 1180 -8450 1187.5 -8450 {}
L 2 1180 -8450 1195 -8450 {}
L 2 1210 -8450 1220 -8450 {}
L 2 1205 -8455 1210 -8450 {}
L 2 1205 -8445 1210 -8450 {}
L 2 1220 -8520 1220 -8510 {}
L 2 1220 -8520 1227.5 -8522.5 {}
L 2 1212.5 -8527.5 1227.5 -8522.5 {}
L 2 1212.5 -8527.5 1227.5 -8532.5 {}
L 2 1212.5 -8537.5 1227.5 -8532.5 {}
L 2 1212.5 -8537.5 1227.5 -8542.5 {}
L 2 1212.5 -8547.5 1227.5 -8542.5 {}
L 2 1212.5 -8547.5 1227.5 -8552.5 {}
L 2 1212.5 -8557.5 1227.5 -8552.5 {}
L 2 1212.5 -8557.5 1220 -8560 {}
L 2 1220 -8570 1220 -8560 {}
L 2 1222.5 -8562.5 1227.5 -8562.5 {}
L 2 1225 -8565 1225 -8560 {}
L 2 1310 -8445 1310 -8420 {}
L 2 1310 -8480 1310 -8455 {}
L 2 1300 -8455 1320 -8455 {}
L 2 1300 -8445 1320 -8445 {}
L 2 1312.5 -8472.5 1317.5 -8472.5 {}
L 2 1315 -8475 1315 -8470 {}
L 2 982.5 -8412.5 987.5 -8412.5 {}
L 2 985 -8415 985 -8410 {}
L 2 980 -8420 980 -8360 {}
L 2 1090 -8340 1090 -8327.5 {}
L 2 1085 -8327.5 1095 -8327.5 {}
L 2 1090 -8322.5 1095 -8327.5 {}
L 2 1085 -8327.5 1090 -8322.5 {}
L 2 1090 -8620 1090 -8600 {}
L 2 1080 -8620 1100 -8620 {}
L 2 1055 -8450 1060 -8450 {}
L 2 1060 -8450 1180 -8450 {}
L 2 1220 -8510 1220 -8480 {}
L 2 1220 -8600 1220 -8570 {}
L 2 1310 -8420 1310 -8340 {}
L 2 980 -8360 980 -8340 {}
L 2 980 -8600 980 -8420 {}
L 2 1220 -8450 1220 -8340 {}
L 2 1220 -8340 1310 -8340 {}
L 2 980 -8340 1220 -8340 {}
L 2 1600 -8600 1840 -8600 {}
L 2 1615 -8480 1615 -8420 {}
L 2 1600 -8470 1615 -8470 {}
L 2 1600 -8480 1600 -8470 {}
L 2 1600 -8430 1615 -8430 {}
L 2 1600 -8430 1600 -8420 {}
L 2 1625 -8465 1625 -8435 {}
L 2 1625 -8450 1625 -8445 {}
L 2 1632.5 -8450 1640 -8450 {}
L 2 1625 -8450 1640 -8450 {}
L 2 1600 -8450 1610 -8450 {}
L 2 1610 -8450 1615 -8455 {}
L 2 1610 -8450 1615 -8445 {}
L 2 1600 -8520 1600 -8510 {}
L 2 1592.5 -8522.5 1600 -8520 {}
L 2 1592.5 -8522.5 1607.5 -8527.5 {}
L 2 1592.5 -8532.5 1607.5 -8527.5 {}
L 2 1592.5 -8532.5 1607.5 -8537.5 {}
L 2 1592.5 -8542.5 1607.5 -8537.5 {}
L 2 1592.5 -8542.5 1607.5 -8547.5 {}
L 2 1592.5 -8552.5 1607.5 -8547.5 {}
L 2 1592.5 -8552.5 1607.5 -8557.5 {}
L 2 1600 -8560 1607.5 -8557.5 {}
L 2 1600 -8570 1600 -8560 {}
L 2 1592.5 -8562.5 1597.5 -8562.5 {}
L 2 1595 -8565 1595 -8560 {}
L 2 1510 -8445 1510 -8420 {}
L 2 1510 -8480 1510 -8455 {}
L 2 1500 -8455 1520 -8455 {}
L 2 1500 -8445 1520 -8445 {}
L 2 1502.5 -8472.5 1507.5 -8472.5 {}
L 2 1505 -8475 1505 -8470 {}
L 2 1832.5 -8412.5 1837.5 -8412.5 {}
L 2 1835 -8415 1835 -8410 {}
L 2 1840 -8420 1840 -8360 {}
L 2 1730 -8340 1730 -8327.5 {}
L 2 1725 -8327.5 1735 -8327.5 {}
L 2 1725 -8327.5 1730 -8322.5 {}
L 2 1730 -8322.5 1735 -8327.5 {}
L 2 1730 -8620 1730 -8600 {}
L 2 1720 -8620 1740 -8620 {}
L 2 1760 -8450 1765 -8450 {}
L 2 1640 -8450 1760 -8450 {}
L 2 1600 -8510 1600 -8480 {}
L 2 1600 -8600 1600 -8570 {}
L 2 1510 -8420 1510 -8340 {}
L 2 1840 -8360 1840 -8340 {}
L 2 1840 -8600 1840 -8420 {}
L 2 1600 -8450 1600 -8340 {}
L 2 1510 -8340 1600 -8340 {}
L 2 1600 -8340 1840 -8340 {}
L 2 610 -8170 610 -8160 {}
L 2 610 -8170 617.5 -8172.5 {}
L 2 602.5 -8177.5 617.5 -8172.5 {}
L 2 602.5 -8177.5 617.5 -8182.5 {}
L 2 602.5 -8187.5 617.5 -8182.5 {}
L 2 602.5 -8187.5 617.5 -8192.5 {}
L 2 602.5 -8197.5 617.5 -8192.5 {}
L 2 602.5 -8197.5 617.5 -8202.5 {}
L 2 602.5 -8207.5 617.5 -8202.5 {}
L 2 602.5 -8207.5 610 -8210 {}
L 2 610 -8220 610 -8210 {}
L 2 612.5 -8212.5 617.5 -8212.5 {}
L 2 615 -8215 615 -8210 {}
L 2 610 -8055 610 -8030 {}
L 2 610 -8090 610 -8065 {}
L 2 600 -8065 620 -8065 {}
L 2 600 -8055 620 -8055 {}
L 2 612.5 -8082.5 617.5 -8082.5 {}
L 2 615 -8085 615 -8080 {}
L 2 610 -7930 610 -7920 {}
L 2 610 -7930 617.5 -7932.5 {}
L 2 602.5 -7937.5 617.5 -7932.5 {}
L 2 602.5 -7937.5 617.5 -7942.5 {}
L 2 602.5 -7947.5 617.5 -7942.5 {}
L 2 602.5 -7947.5 617.5 -7952.5 {}
L 2 602.5 -7957.5 617.5 -7952.5 {}
L 2 602.5 -7957.5 617.5 -7962.5 {}
L 2 602.5 -7967.5 617.5 -7962.5 {}
L 2 602.5 -7967.5 610 -7970 {}
L 2 610 -7980 610 -7970 {}
L 2 612.5 -7972.5 617.5 -7972.5 {}
L 2 615 -7975 615 -7970 {}
L 2 900 -8190 910 -8190 {}
L 2 910 -8190 912.5 -8182.5 {}
L 2 912.5 -8182.5 917.5 -8197.5 {}
L 2 917.5 -8197.5 922.5 -8182.5 {}
L 2 922.5 -8182.5 927.5 -8197.5 {}
L 2 927.5 -8197.5 932.5 -8182.5 {}
L 2 932.5 -8182.5 937.5 -8197.5 {}
L 2 937.5 -8197.5 942.5 -8182.5 {}
L 2 942.5 -8182.5 947.5 -8197.5 {}
L 2 947.5 -8197.5 950 -8190 {}
L 2 950 -8190 960 -8190 {}
L 2 952.5 -8187.5 952.5 -8182.5 {}
L 2 950 -8185 955 -8185 {}
L 2 900 -8060 925 -8060 {}
L 2 935 -8060 960 -8060 {}
L 2 935 -8070 935 -8050 {}
L 2 925 -8070 925 -8050 {}
L 2 952.5 -8057.5 952.5 -8052.5 {}
L 2 950 -8055 955 -8055 {}
L 2 900 -7950 910 -7950 {}
L 2 910 -7950 912.5 -7942.5 {}
L 2 912.5 -7942.5 917.5 -7957.5 {}
L 2 917.5 -7957.5 922.5 -7942.5 {}
L 2 922.5 -7942.5 927.5 -7957.5 {}
L 2 927.5 -7957.5 932.5 -7942.5 {}
L 2 932.5 -7942.5 937.5 -7957.5 {}
L 2 937.5 -7957.5 942.5 -7942.5 {}
L 2 942.5 -7942.5 947.5 -7957.5 {}
L 2 947.5 -7957.5 950 -7950 {}
L 2 950 -7950 960 -7950 {}
L 2 952.5 -7947.5 952.5 -7942.5 {}
L 2 950 -7945 955 -7945 {}
L 2 2360 -9600 2420 -9600 {}
L 2 2420 -9770 2420 -9660 {}
L 2 1440 -1690 1510 -1690 {}
L 2 1440 -1670 1510 -1670 {}
L 2 1440 -1650 1510 -1650 {}
L 2 1440 -1630 1510 -1630 {}
L 2 2200 -1690 2290 -1690 {}
L 2 960 -1700 1080 -1700 {}
L 2 960 -1620 1080 -1620 {}
L 2 960 -1700 960 -1620 {}
L 2 1080 -1700 1080 -1620 {}
L 2 1080 -1690 1100 -1690 {}
L 2 940 -1690 960 -1690 {}
L 2 940 -1670 960 -1670 {}
L 2 940 -1650 960 -1650 {}
L 2 940 -1630 960 -1630 {}
L 2 540 -1700 660 -1700 {}
L 2 540 -1620 660 -1620 {}
L 2 540 -1700 540 -1620 {}
L 2 660 -1700 660 -1620 {}
L 2 660 -1690 680 -1690 {}
L 2 520 -1690 540 -1690 {}
L 2 520 -1670 540 -1670 {}
L 2 520 -1650 540 -1650 {}
L 2 520 -1630 540 -1630 {}
L 2 910 -740 910 -710 {}
L 2 895 -1050 895 -990 {}
L 2 895 -1000 910 -1000 {}
L 2 910 -1000 910 -990 {}
L 2 895 -1040 910 -1040 {}
L 2 910 -1050 910 -1040 {}
L 2 885 -1035 885 -1005 {}
L 2 885 -1025 885 -1020 {}
L 2 882.5 -1025 885 -1022.5 {}
L 2 880 -1025 882.5 -1025 {}
L 2 877.5 -1022.5 880 -1025 {}
L 2 877.5 -1022.5 877.5 -1017.5 {}
L 2 877.5 -1017.5 880 -1015 {}
L 2 880 -1015 882.5 -1015 {}
L 2 882.5 -1015 885 -1017.5 {}
L 2 870 -1020 877.5 -1020 {}
L 2 900 -1020 910 -1020 {}
L 2 895 -1025 900 -1020 {}
L 2 895 -1015 900 -1020 {}
L 2 1025 -1050 1025 -990 {}
L 2 1025 -1000 1040 -1000 {}
L 2 1040 -1000 1040 -990 {}
L 2 1025 -1040 1040 -1040 {}
L 2 1040 -1050 1040 -1040 {}
L 2 1015 -1035 1015 -1005 {}
L 2 1015 -1025 1015 -1020 {}
L 2 1012.5 -1025 1015 -1022.5 {}
L 2 1010 -1025 1012.5 -1025 {}
L 2 1007.5 -1022.5 1010 -1025 {}
L 2 1007.5 -1022.5 1007.5 -1017.5 {}
L 2 1007.5 -1017.5 1010 -1015 {}
L 2 1010 -1015 1012.5 -1015 {}
L 2 1012.5 -1015 1015 -1017.5 {}
L 2 1000 -1020 1007.5 -1020 {}
L 2 1030 -1020 1040 -1020 {}
L 2 1025 -1025 1030 -1020 {}
L 2 1025 -1015 1030 -1020 {}
L 2 895 -850 895 -790 {}
L 2 895 -840 910 -840 {}
L 2 910 -850 910 -840 {}
L 2 895 -800 910 -800 {}
L 2 910 -800 910 -790 {}
L 2 885 -835 885 -805 {}
L 2 885 -820 885 -815 {}
L 2 870 -820 877.5 -820 {}
L 2 870 -820 885 -820 {}
L 2 900 -820 910 -820 {}
L 2 895 -825 900 -820 {}
L 2 895 -815 900 -820 {}
L 2 895 -770 895 -710 {}
L 2 895 -760 910 -760 {}
L 2 910 -770 910 -760 {}
L 2 895 -720 910 -720 {}
L 2 910 -720 910 -710 {}
L 2 885 -755 885 -725 {}
L 2 885 -740 885 -735 {}
L 2 870 -740 877.5 -740 {}
L 2 870 -740 885 -740 {}
L 2 900 -740 910 -740 {}
L 2 895 -745 900 -740 {}
L 2 895 -735 900 -740 {}
L 2 2427.5 -472.5 2432.5 -472.5 {dash=4}
L 2 2427.5 -470 2432.5 -470 {dash=4}
L 2 2427.5 -467.5 2432.5 -467.5 {dash=4}
L 2 2427.5 -465 2432.5 -465 {dash=4}
L 2 2427.5 -462.5 2432.5 -462.5 {dash=4}
L 2 2427.5 -460 2432.5 -460 {dash=4}
L 2 2427.5 -457.5 2432.5 -457.5 {dash=4}
L 2 2427.5 -455 2432.5 -455 {dash=4}
L 2 2427.5 -452.5 2432.5 -452.5 {dash=4}
L 4 1032.5 -12492.5 1037.5 -12492.5 {}
L 4 1035 -12495 1035 -12490 {}
L 4 1030 -12500 1030 -12440 {}
L 4 1140 -12420 1140 -12407.5 {}
L 4 1135 -12407.5 1145 -12407.5 {}
L 4 1140 -12402.5 1145 -12407.5 {}
L 4 1135 -12407.5 1140 -12402.5 {}
L 4 1140 -12700 1140 -12680 {}
L 4 1130 -12700 1150 -12700 {}
L 4 1572.5 -12492.5 1577.5 -12492.5 {}
L 4 1575 -12495 1575 -12490 {}
L 4 1570 -12500 1570 -12440 {}
L 4 1680 -12420 1680 -12407.5 {}
L 4 1675 -12407.5 1685 -12407.5 {}
L 4 1680 -12402.5 1685 -12407.5 {}
L 4 1675 -12407.5 1680 -12402.5 {}
L 4 1680 -12700 1680 -12680 {}
L 4 1670 -12700 1690 -12700 {}
L 4 502.5 -12492.5 507.5 -12492.5 {}
L 4 505 -12495 505 -12490 {}
L 4 500 -12500 500 -12440 {}
L 4 610 -12420 610 -12407.5 {}
L 4 605 -12407.5 615 -12407.5 {}
L 4 610 -12402.5 615 -12407.5 {}
L 4 605 -12407.5 610 -12402.5 {}
L 4 610 -12700 610 -12680 {}
L 4 600 -12700 620 -12700 {}
L 4 725 -12100 725 -12040 {}
L 4 725 -12090 740 -12090 {}
L 4 740 -12100 740 -12090 {}
L 4 725 -12050 740 -12050 {}
L 4 740 -12050 740 -12040 {}
L 4 715 -12085 715 -12055 {}
L 4 715 -12070 715 -12065 {}
L 4 700 -12070 707.5 -12070 {}
L 4 700 -12070 715 -12070 {}
L 4 730 -12070 740 -12070 {}
L 4 725 -12075 730 -12070 {}
L 4 725 -12065 730 -12070 {}
L 4 740 -12140 740 -12130 {}
L 4 740 -12140 747.5 -12142.5 {}
L 4 732.5 -12147.5 747.5 -12142.5 {}
L 4 732.5 -12147.5 747.5 -12152.5 {}
L 4 732.5 -12157.5 747.5 -12152.5 {}
L 4 732.5 -12157.5 747.5 -12162.5 {}
L 4 732.5 -12167.5 747.5 -12162.5 {}
L 4 732.5 -12167.5 747.5 -12172.5 {}
L 4 732.5 -12177.5 747.5 -12172.5 {}
L 4 732.5 -12177.5 740 -12180 {}
L 4 740 -12190 740 -12180 {}
L 4 742.5 -12182.5 747.5 -12182.5 {}
L 4 745 -12185 745 -12180 {}
L 4 830 -12065 830 -12040 {}
L 4 830 -12100 830 -12075 {}
L 4 820 -12075 840 -12075 {}
L 4 820 -12065 840 -12065 {}
L 4 832.5 -12092.5 837.5 -12092.5 {}
L 4 835 -12095 835 -12090 {}
L 4 502.5 -12032.5 507.5 -12032.5 {}
L 4 505 -12035 505 -12030 {}
L 4 500 -12040 500 -11980 {}
L 4 610 -11960 610 -11947.5 {}
L 4 605 -11947.5 615 -11947.5 {}
L 4 610 -11942.5 615 -11947.5 {}
L 4 605 -11947.5 610 -11942.5 {}
L 4 610 -12240 610 -12220 {}
L 4 600 -12240 620 -12240 {}
L 4 1265 -12100 1265 -12040 {}
L 4 1265 -12090 1280 -12090 {}
L 4 1280 -12100 1280 -12090 {}
L 4 1265 -12050 1280 -12050 {}
L 4 1280 -12050 1280 -12040 {}
L 4 1255 -12085 1255 -12055 {}
L 4 1255 -12070 1255 -12065 {}
L 4 1240 -12070 1247.5 -12070 {}
L 4 1240 -12070 1255 -12070 {}
L 4 1270 -12070 1280 -12070 {}
L 4 1265 -12075 1270 -12070 {}
L 4 1265 -12065 1270 -12070 {}
L 4 1370 -12065 1370 -12040 {}
L 4 1370 -12100 1370 -12075 {}
L 4 1360 -12075 1380 -12075 {}
L 4 1360 -12065 1380 -12065 {}
L 4 1372.5 -12092.5 1377.5 -12092.5 {}
L 4 1375 -12095 1375 -12090 {}
L 4 1042.5 -12032.5 1047.5 -12032.5 {}
L 4 1045 -12035 1045 -12030 {}
L 4 1040 -12040 1040 -11980 {}
L 4 1150 -11960 1150 -11947.5 {}
L 4 1145 -11947.5 1155 -11947.5 {}
L 4 1150 -11942.5 1155 -11947.5 {}
L 4 1145 -11947.5 1150 -11942.5 {}
L 4 1150 -12240 1150 -12220 {}
L 4 1140 -12240 1160 -12240 {}
L 4 725 -7670 725 -7610 {}
L 4 725 -7660 740 -7660 {}
L 4 740 -7670 740 -7660 {}
L 4 725 -7620 740 -7620 {}
L 4 740 -7620 740 -7610 {}
L 4 715 -7655 715 -7625 {}
L 4 715 -7640 715 -7635 {}
L 4 700 -7640 707.5 -7640 {}
L 4 700 -7640 715 -7640 {}
L 4 730 -7640 740 -7640 {}
L 4 725 -7645 730 -7640 {}
L 4 725 -7635 730 -7640 {}
L 4 740 -7710 740 -7700 {}
L 4 740 -7710 747.5 -7712.5 {}
L 4 732.5 -7717.5 747.5 -7712.5 {}
L 4 732.5 -7717.5 747.5 -7722.5 {}
L 4 732.5 -7727.5 747.5 -7722.5 {}
L 4 732.5 -7727.5 747.5 -7732.5 {}
L 4 732.5 -7737.5 747.5 -7732.5 {}
L 4 732.5 -7737.5 747.5 -7742.5 {}
L 4 732.5 -7747.5 747.5 -7742.5 {}
L 4 732.5 -7747.5 740 -7750 {}
L 4 740 -7760 740 -7750 {}
L 4 742.5 -7752.5 747.5 -7752.5 {}
L 4 745 -7755 745 -7750 {}
L 4 830 -7635 830 -7610 {}
L 4 830 -7670 830 -7645 {}
L 4 820 -7645 840 -7645 {}
L 4 820 -7635 840 -7635 {}
L 4 832.5 -7662.5 837.5 -7662.5 {}
L 4 835 -7665 835 -7660 {}
L 4 502.5 -7602.5 507.5 -7602.5 {}
L 4 505 -7605 505 -7600 {}
L 4 500 -7610 500 -7550 {}
L 4 610 -7530 610 -7517.5 {}
L 4 605 -7517.5 615 -7517.5 {}
L 4 610 -7512.5 615 -7517.5 {}
L 4 605 -7517.5 610 -7512.5 {}
L 4 610 -7810 610 -7790 {}
L 4 600 -7810 620 -7810 {}
L 4 1265 -7670 1265 -7610 {}
L 4 1265 -7660 1280 -7660 {}
L 4 1280 -7670 1280 -7660 {}
L 4 1265 -7620 1280 -7620 {}
L 4 1280 -7620 1280 -7610 {}
L 4 1255 -7655 1255 -7625 {}
L 4 1255 -7640 1255 -7635 {}
L 4 1240 -7640 1247.5 -7640 {}
L 4 1240 -7640 1255 -7640 {}
L 4 1270 -7640 1280 -7640 {}
L 4 1265 -7645 1270 -7640 {}
L 4 1265 -7635 1270 -7640 {}
L 4 1370 -7635 1370 -7610 {}
L 4 1370 -7670 1370 -7645 {}
L 4 1360 -7645 1380 -7645 {}
L 4 1360 -7635 1380 -7635 {}
L 4 1372.5 -7662.5 1377.5 -7662.5 {}
L 4 1375 -7665 1375 -7660 {}
L 4 1042.5 -7602.5 1047.5 -7602.5 {}
L 4 1045 -7605 1045 -7600 {}
L 4 1040 -7610 1040 -7550 {}
L 4 1150 -7530 1150 -7517.5 {}
L 4 1145 -7517.5 1155 -7517.5 {}
L 4 1150 -7512.5 1155 -7517.5 {}
L 4 1145 -7517.5 1150 -7512.5 {}
L 4 1150 -7810 1150 -7790 {}
L 4 1140 -7810 1160 -7810 {}
L 4 725 -7270 725 -7210 {}
L 4 725 -7260 740 -7260 {}
L 4 740 -7270 740 -7260 {}
L 4 725 -7220 740 -7220 {}
L 4 740 -7220 740 -7210 {}
L 4 715 -7255 715 -7225 {}
L 4 715 -7240 715 -7235 {}
L 4 700 -7240 707.5 -7240 {}
L 4 700 -7240 715 -7240 {}
L 4 730 -7240 740 -7240 {}
L 4 725 -7245 730 -7240 {}
L 4 725 -7235 730 -7240 {}
L 4 740 -7310 740 -7300 {}
L 4 740 -7310 747.5 -7312.5 {}
L 4 732.5 -7317.5 747.5 -7312.5 {}
L 4 732.5 -7317.5 747.5 -7322.5 {}
L 4 732.5 -7327.5 747.5 -7322.5 {}
L 4 732.5 -7327.5 747.5 -7332.5 {}
L 4 732.5 -7337.5 747.5 -7332.5 {}
L 4 732.5 -7337.5 747.5 -7342.5 {}
L 4 732.5 -7347.5 747.5 -7342.5 {}
L 4 732.5 -7347.5 740 -7350 {}
L 4 740 -7360 740 -7350 {}
L 4 742.5 -7352.5 747.5 -7352.5 {}
L 4 745 -7355 745 -7350 {}
L 4 830 -7235 830 -7210 {}
L 4 830 -7270 830 -7245 {}
L 4 820 -7245 840 -7245 {}
L 4 820 -7235 840 -7235 {}
L 4 832.5 -7262.5 837.5 -7262.5 {}
L 4 835 -7265 835 -7260 {}
L 4 502.5 -7202.5 507.5 -7202.5 {}
L 4 505 -7205 505 -7200 {}
L 4 500 -7210 500 -7150 {}
L 4 610 -7130 610 -7117.5 {}
L 4 605 -7117.5 615 -7117.5 {}
L 4 610 -7112.5 615 -7117.5 {}
L 4 605 -7117.5 610 -7112.5 {}
L 4 610 -7410 610 -7390 {}
L 4 600 -7410 620 -7410 {}
L 4 1265 -7270 1265 -7210 {}
L 4 1265 -7260 1280 -7260 {}
L 4 1280 -7270 1280 -7260 {}
L 4 1265 -7220 1280 -7220 {}
L 4 1280 -7220 1280 -7210 {}
L 4 1255 -7255 1255 -7225 {}
L 4 1255 -7240 1255 -7235 {}
L 4 1240 -7240 1247.5 -7240 {}
L 4 1240 -7240 1255 -7240 {}
L 4 1270 -7240 1280 -7240 {}
L 4 1265 -7245 1270 -7240 {}
L 4 1265 -7235 1270 -7240 {}
L 4 1370 -7235 1370 -7210 {}
L 4 1370 -7270 1370 -7245 {}
L 4 1360 -7245 1380 -7245 {}
L 4 1360 -7235 1380 -7235 {}
L 4 1372.5 -7262.5 1377.5 -7262.5 {}
L 4 1375 -7265 1375 -7260 {}
L 4 1042.5 -7202.5 1047.5 -7202.5 {}
L 4 1045 -7205 1045 -7200 {}
L 4 1040 -7210 1040 -7150 {}
L 4 1150 -7130 1150 -7117.5 {}
L 4 1145 -7117.5 1155 -7117.5 {}
L 4 1150 -7112.5 1155 -7117.5 {}
L 4 1145 -7117.5 1150 -7112.5 {}
L 4 1150 -7410 1150 -7390 {}
L 4 1140 -7410 1160 -7410 {}
L 4 502.5 -6762.5 507.5 -6762.5 {}
L 4 505 -6765 505 -6760 {}
L 4 500 -6770 500 -6710 {}
L 4 610 -6690 610 -6677.5 {}
L 4 605 -6677.5 615 -6677.5 {}
L 4 610 -6672.5 615 -6677.5 {}
L 4 605 -6677.5 610 -6672.5 {}
L 4 610 -6970 610 -6950 {}
L 4 600 -6970 620 -6970 {}
L 4 1692.5 -6762.5 1697.5 -6762.5 {}
L 4 1695 -6765 1695 -6760 {}
L 4 1690 -6770 1690 -6710 {}
L 4 1800 -6690 1800 -6677.5 {}
L 4 1795 -6677.5 1805 -6677.5 {}
L 4 1800 -6672.5 1805 -6677.5 {}
L 4 1795 -6677.5 1800 -6672.5 {}
L 4 1800 -6970 1800 -6950 {}
L 4 1790 -6970 1810 -6970 {}
L 4 1062.5 -6762.5 1067.5 -6762.5 {}
L 4 1065 -6765 1065 -6760 {}
L 4 1060 -6770 1060 -6710 {}
L 4 1170 -6690 1170 -6677.5 {}
L 4 1165 -6677.5 1175 -6677.5 {}
L 4 1170 -6672.5 1175 -6677.5 {}
L 4 1165 -6677.5 1170 -6672.5 {}
L 4 1170 -6970 1170 -6950 {}
L 4 1160 -6970 1180 -6970 {}
L 4 1032.5 -11662.5 1037.5 -11662.5 {}
L 4 1035 -11665 1035 -11660 {}
L 4 1030 -11670 1030 -11610 {}
L 4 1140 -11590 1140 -11577.5 {}
L 4 1135 -11577.5 1145 -11577.5 {}
L 4 1140 -11572.5 1145 -11577.5 {}
L 4 1135 -11577.5 1140 -11572.5 {}
L 4 1140 -11870 1140 -11850 {}
L 4 1130 -11870 1150 -11870 {}
L 4 502.5 -11662.5 507.5 -11662.5 {}
L 4 505 -11665 505 -11660 {}
L 4 500 -11670 500 -11610 {}
L 4 610 -11590 610 -11577.5 {}
L 4 605 -11577.5 615 -11577.5 {}
L 4 610 -11572.5 615 -11577.5 {}
L 4 605 -11577.5 610 -11572.5 {}
L 4 610 -11870 610 -11850 {}
L 4 600 -11870 620 -11870 {}
L 4 1755 -11730 1755 -11670 {}
L 4 1755 -11720 1770 -11720 {}
L 4 1770 -11730 1770 -11720 {}
L 4 1755 -11680 1770 -11680 {}
L 4 1770 -11680 1770 -11670 {}
L 4 1745 -11715 1745 -11685 {}
L 4 1745 -11700 1745 -11695 {}
L 4 1730 -11700 1737.5 -11700 {}
L 4 1730 -11700 1745 -11700 {}
L 4 1760 -11700 1770 -11700 {}
L 4 1755 -11705 1760 -11700 {}
L 4 1755 -11695 1760 -11700 {}
L 4 1770 -11770 1770 -11760 {}
L 4 1770 -11770 1777.5 -11772.5 {}
L 4 1762.5 -11777.5 1777.5 -11772.5 {}
L 4 1762.5 -11777.5 1777.5 -11782.5 {}
L 4 1762.5 -11787.5 1777.5 -11782.5 {}
L 4 1762.5 -11787.5 1777.5 -11792.5 {}
L 4 1762.5 -11797.5 1777.5 -11792.5 {}
L 4 1762.5 -11797.5 1777.5 -11802.5 {}
L 4 1762.5 -11807.5 1777.5 -11802.5 {}
L 4 1762.5 -11807.5 1770 -11810 {}
L 4 1770 -11820 1770 -11810 {}
L 4 1772.5 -11812.5 1777.5 -11812.5 {}
L 4 1775 -11815 1775 -11810 {}
L 4 1860 -11695 1860 -11670 {}
L 4 1860 -11730 1860 -11705 {}
L 4 1850 -11705 1870 -11705 {}
L 4 1850 -11695 1870 -11695 {}
L 4 1862.5 -11722.5 1867.5 -11722.5 {}
L 4 1865 -11725 1865 -11720 {}
L 4 1532.5 -11662.5 1537.5 -11662.5 {}
L 4 1535 -11665 1535 -11660 {}
L 4 1530 -11670 1530 -11610 {}
L 4 1640 -11590 1640 -11577.5 {}
L 4 1635 -11577.5 1645 -11577.5 {}
L 4 1640 -11572.5 1645 -11577.5 {}
L 4 1635 -11577.5 1640 -11572.5 {}
L 4 1640 -11870 1640 -11850 {}
L 4 1630 -11870 1650 -11870 {}
L 4 1680 -12890 1680 -12877.5 {}
L 4 1675 -12877.5 1685 -12877.5 {}
L 4 1680 -12872.5 1685 -12877.5 {}
L 4 1675 -12877.5 1680 -12872.5 {}
L 4 1680 -13170 1680 -13150 {}
L 4 1670 -13170 1690 -13170 {}
L 4 447.5 -12962.5 452.5 -12962.5 {}
L 4 450 -12965 450 -12960 {}
L 4 445 -12970 445 -12910 {}
L 4 555 -12890 555 -12877.5 {}
L 4 550 -12877.5 560 -12877.5 {}
L 4 555 -12872.5 560 -12877.5 {}
L 4 550 -12877.5 555 -12872.5 {}
L 4 555 -13170 555 -13150 {}
L 4 545 -13170 565 -13170 {}
L 4 2140 -12890 2140 -12877.5 {}
L 4 2135 -12877.5 2145 -12877.5 {}
L 4 2140 -12872.5 2145 -12877.5 {}
L 4 2135 -12877.5 2140 -12872.5 {}
L 4 2140 -13170 2140 -13150 {}
L 4 2130 -13170 2150 -13170 {}
L 4 2360 -12995 2360 -12970 {}
L 4 2360 -13030 2360 -13005 {}
L 4 2350 -13005 2370 -13005 {}
L 4 2350 -12995 2370 -12995 {}
L 4 2362.5 -13022.5 2367.5 -13022.5 {}
L 4 2365 -13025 2365 -13020 {}
L 4 745 -10890 745 -10830 {}
L 4 745 -10880 760 -10880 {}
L 4 760 -10890 760 -10880 {}
L 4 745 -10840 760 -10840 {}
L 4 760 -10840 760 -10830 {}
L 4 735 -10875 735 -10845 {}
L 4 735 -10860 735 -10855 {}
L 4 720 -10860 727.5 -10860 {}
L 4 720 -10860 735 -10860 {}
L 4 750 -10860 760 -10860 {}
L 4 745 -10865 750 -10860 {}
L 4 745 -10855 750 -10860 {}
L 4 760 -10930 760 -10920 {}
L 4 760 -10930 767.5 -10932.5 {}
L 4 752.5 -10937.5 767.5 -10932.5 {}
L 4 752.5 -10937.5 767.5 -10942.5 {}
L 4 752.5 -10947.5 767.5 -10942.5 {}
L 4 752.5 -10947.5 767.5 -10952.5 {}
L 4 752.5 -10957.5 767.5 -10952.5 {}
L 4 752.5 -10957.5 767.5 -10962.5 {}
L 4 752.5 -10967.5 767.5 -10962.5 {}
L 4 752.5 -10967.5 760 -10970 {}
L 4 760 -10980 760 -10970 {}
L 4 762.5 -10972.5 767.5 -10972.5 {}
L 4 765 -10975 765 -10970 {}
L 4 850 -10855 850 -10830 {}
L 4 850 -10890 850 -10865 {}
L 4 840 -10865 860 -10865 {}
L 4 840 -10855 860 -10855 {}
L 4 852.5 -10882.5 857.5 -10882.5 {}
L 4 855 -10885 855 -10880 {}
L 4 522.5 -10822.5 527.5 -10822.5 {}
L 4 525 -10825 525 -10820 {}
L 4 520 -10830 520 -10770 {}
L 4 630 -10750 630 -10737.5 {}
L 4 625 -10737.5 635 -10737.5 {}
L 4 630 -10732.5 635 -10737.5 {}
L 4 625 -10737.5 630 -10732.5 {}
L 4 630 -11030 630 -11010 {}
L 4 620 -11030 640 -11030 {}
L 4 1285 -10890 1285 -10830 {}
L 4 1285 -10880 1300 -10880 {}
L 4 1300 -10890 1300 -10880 {}
L 4 1285 -10840 1300 -10840 {}
L 4 1300 -10840 1300 -10830 {}
L 4 1275 -10875 1275 -10845 {}
L 4 1275 -10860 1275 -10855 {}
L 4 1260 -10860 1267.5 -10860 {}
L 4 1260 -10860 1275 -10860 {}
L 4 1290 -10860 1300 -10860 {}
L 4 1285 -10865 1290 -10860 {}
L 4 1285 -10855 1290 -10860 {}
L 4 1300 -10930 1300 -10920 {}
L 4 1300 -10930 1307.5 -10932.5 {}
L 4 1292.5 -10937.5 1307.5 -10932.5 {}
L 4 1292.5 -10937.5 1307.5 -10942.5 {}
L 4 1292.5 -10947.5 1307.5 -10942.5 {}
L 4 1292.5 -10947.5 1307.5 -10952.5 {}
L 4 1292.5 -10957.5 1307.5 -10952.5 {}
L 4 1292.5 -10957.5 1307.5 -10962.5 {}
L 4 1292.5 -10967.5 1307.5 -10962.5 {}
L 4 1292.5 -10967.5 1300 -10970 {}
L 4 1300 -10980 1300 -10970 {}
L 4 1302.5 -10972.5 1307.5 -10972.5 {}
L 4 1305 -10975 1305 -10970 {}
L 4 1390 -10855 1390 -10830 {}
L 4 1390 -10890 1390 -10865 {}
L 4 1380 -10865 1400 -10865 {}
L 4 1380 -10855 1400 -10855 {}
L 4 1392.5 -10882.5 1397.5 -10882.5 {}
L 4 1395 -10885 1395 -10880 {}
L 4 1062.5 -10822.5 1067.5 -10822.5 {}
L 4 1065 -10825 1065 -10820 {}
L 4 1060 -10830 1060 -10770 {}
L 4 1170 -10750 1170 -10737.5 {}
L 4 1165 -10737.5 1175 -10737.5 {}
L 4 1170 -10732.5 1175 -10737.5 {}
L 4 1165 -10737.5 1170 -10732.5 {}
L 4 1170 -11030 1170 -11010 {}
L 4 1160 -11030 1180 -11030 {}
L 4 2415 -10890 2415 -10830 {}
L 4 2415 -10880 2430 -10880 {}
L 4 2430 -10890 2430 -10880 {}
L 4 2415 -10840 2430 -10840 {}
L 4 2430 -10840 2430 -10830 {}
L 4 2405 -10875 2405 -10845 {}
L 4 2405 -10860 2405 -10855 {}
L 4 2390 -10860 2397.5 -10860 {}
L 4 2390 -10860 2405 -10860 {}
L 4 2420 -10860 2430 -10860 {}
L 4 2415 -10865 2420 -10860 {}
L 4 2415 -10855 2420 -10860 {}
L 4 2430 -10930 2430 -10920 {}
L 4 2430 -10930 2437.5 -10932.5 {}
L 4 2422.5 -10937.5 2437.5 -10932.5 {}
L 4 2422.5 -10937.5 2437.5 -10942.5 {}
L 4 2422.5 -10947.5 2437.5 -10942.5 {}
L 4 2422.5 -10947.5 2437.5 -10952.5 {}
L 4 2422.5 -10957.5 2437.5 -10952.5 {}
L 4 2422.5 -10957.5 2437.5 -10962.5 {}
L 4 2422.5 -10967.5 2437.5 -10962.5 {}
L 4 2422.5 -10967.5 2430 -10970 {}
L 4 2430 -10980 2430 -10970 {}
L 4 2432.5 -10972.5 2437.5 -10972.5 {}
L 4 2435 -10975 2435 -10970 {}
L 4 2520 -10855 2520 -10830 {}
L 4 2520 -10890 2520 -10865 {}
L 4 2510 -10865 2530 -10865 {}
L 4 2510 -10855 2530 -10855 {}
L 4 2522.5 -10882.5 2527.5 -10882.5 {}
L 4 2525 -10885 2525 -10880 {}
L 4 2192.5 -10822.5 2197.5 -10822.5 {}
L 4 2195 -10825 2195 -10820 {}
L 4 2190 -10830 2190 -10770 {}
L 4 2300 -10750 2300 -10737.5 {}
L 4 2295 -10737.5 2305 -10737.5 {}
L 4 2300 -10732.5 2305 -10737.5 {}
L 4 2295 -10737.5 2300 -10732.5 {}
L 4 2300 -11030 2300 -11010 {}
L 4 2290 -11030 2310 -11030 {}
L 4 820 -5910 820 -5900 {}
L 4 820 -5910 827.5 -5912.5 {}
L 4 812.5 -5917.5 827.5 -5912.5 {}
L 4 812.5 -5917.5 827.5 -5922.5 {}
L 4 812.5 -5927.5 827.5 -5922.5 {}
L 4 812.5 -5927.5 827.5 -5932.5 {}
L 4 812.5 -5937.5 827.5 -5932.5 {}
L 4 812.5 -5937.5 827.5 -5942.5 {}
L 4 812.5 -5947.5 827.5 -5942.5 {}
L 4 812.5 -5947.5 820 -5950 {}
L 4 820 -5960 820 -5950 {}
L 4 822.5 -5952.5 827.5 -5952.5 {}
L 4 825 -5955 825 -5950 {}
L 4 820 -5850 820 -5840 {}
L 4 820 -5850 827.5 -5852.5 {}
L 4 812.5 -5857.5 827.5 -5852.5 {}
L 4 812.5 -5857.5 827.5 -5862.5 {}
L 4 812.5 -5867.5 827.5 -5862.5 {}
L 4 812.5 -5867.5 827.5 -5872.5 {}
L 4 812.5 -5877.5 827.5 -5872.5 {}
L 4 812.5 -5877.5 827.5 -5882.5 {}
L 4 812.5 -5887.5 827.5 -5882.5 {}
L 4 812.5 -5887.5 820 -5890 {}
L 4 820 -5900 820 -5890 {}
L 4 822.5 -5892.5 827.5 -5892.5 {}
L 4 825 -5895 825 -5890 {}
L 4 1360 -5850 1360 -5840 {}
L 4 1360 -5850 1367.5 -5852.5 {}
L 4 1352.5 -5857.5 1367.5 -5852.5 {}
L 4 1352.5 -5857.5 1367.5 -5862.5 {}
L 4 1352.5 -5867.5 1367.5 -5862.5 {}
L 4 1352.5 -5867.5 1367.5 -5872.5 {}
L 4 1352.5 -5877.5 1367.5 -5872.5 {}
L 4 1352.5 -5877.5 1367.5 -5882.5 {}
L 4 1352.5 -5887.5 1367.5 -5882.5 {}
L 4 1352.5 -5887.5 1360 -5890 {}
L 4 1360 -5900 1360 -5890 {}
L 4 1362.5 -5892.5 1367.5 -5892.5 {}
L 4 1365 -5895 1365 -5890 {}
L 4 1900 -5950 1900 -5940 {}
L 4 1900 -5950 1907.5 -5952.5 {}
L 4 1892.5 -5957.5 1907.5 -5952.5 {}
L 4 1892.5 -5957.5 1907.5 -5962.5 {}
L 4 1892.5 -5967.5 1907.5 -5962.5 {}
L 4 1892.5 -5967.5 1907.5 -5972.5 {}
L 4 1892.5 -5977.5 1907.5 -5972.5 {}
L 4 1892.5 -5977.5 1907.5 -5982.5 {}
L 4 1892.5 -5987.5 1907.5 -5982.5 {}
L 4 1892.5 -5987.5 1900 -5990 {}
L 4 1900 -6000 1900 -5990 {}
L 4 1902.5 -5992.5 1907.5 -5992.5 {}
L 4 1905 -5995 1905 -5990 {}
L 4 1900 -5850 1900 -5840 {}
L 4 1900 -5850 1907.5 -5852.5 {}
L 4 1892.5 -5857.5 1907.5 -5852.5 {}
L 4 1892.5 -5857.5 1907.5 -5862.5 {}
L 4 1892.5 -5867.5 1907.5 -5862.5 {}
L 4 1892.5 -5867.5 1907.5 -5872.5 {}
L 4 1892.5 -5877.5 1907.5 -5872.5 {}
L 4 1892.5 -5877.5 1907.5 -5882.5 {}
L 4 1892.5 -5887.5 1907.5 -5882.5 {}
L 4 1892.5 -5887.5 1900 -5890 {}
L 4 1900 -5900 1900 -5890 {}
L 4 1902.5 -5892.5 1907.5 -5892.5 {}
L 4 1905 -5895 1905 -5890 {}
L 4 710 -5080 710 -5070 {}
L 4 710 -5080 717.5 -5082.5 {}
L 4 702.5 -5087.5 717.5 -5082.5 {}
L 4 702.5 -5087.5 717.5 -5092.5 {}
L 4 702.5 -5097.5 717.5 -5092.5 {}
L 4 702.5 -5097.5 717.5 -5102.5 {}
L 4 702.5 -5107.5 717.5 -5102.5 {}
L 4 702.5 -5107.5 717.5 -5112.5 {}
L 4 702.5 -5117.5 717.5 -5112.5 {}
L 4 702.5 -5117.5 710 -5120 {}
L 4 710 -5130 710 -5120 {}
L 4 712.5 -5122.5 717.5 -5122.5 {}
L 4 715 -5125 715 -5120 {}
L 4 820 -5080 820 -5070 {}
L 4 820 -5080 827.5 -5082.5 {}
L 4 812.5 -5087.5 827.5 -5082.5 {}
L 4 812.5 -5087.5 827.5 -5092.5 {}
L 4 812.5 -5097.5 827.5 -5092.5 {}
L 4 812.5 -5097.5 827.5 -5102.5 {}
L 4 812.5 -5107.5 827.5 -5102.5 {}
L 4 812.5 -5107.5 827.5 -5112.5 {}
L 4 812.5 -5117.5 827.5 -5112.5 {}
L 4 812.5 -5117.5 820 -5120 {}
L 4 820 -5130 820 -5120 {}
L 4 822.5 -5122.5 827.5 -5122.5 {}
L 4 825 -5125 825 -5120 {}
L 4 930 -5080 930 -5070 {}
L 4 930 -5080 937.5 -5082.5 {}
L 4 922.5 -5087.5 937.5 -5082.5 {}
L 4 922.5 -5087.5 937.5 -5092.5 {}
L 4 922.5 -5097.5 937.5 -5092.5 {}
L 4 922.5 -5097.5 937.5 -5102.5 {}
L 4 922.5 -5107.5 937.5 -5102.5 {}
L 4 922.5 -5107.5 937.5 -5112.5 {}
L 4 922.5 -5117.5 937.5 -5112.5 {}
L 4 922.5 -5117.5 930 -5120 {}
L 4 930 -5130 930 -5120 {}
L 4 932.5 -5122.5 937.5 -5122.5 {}
L 4 935 -5125 935 -5120 {}
L 4 1250 -5080 1250 -5070 {}
L 4 1250 -5080 1257.5 -5082.5 {}
L 4 1242.5 -5087.5 1257.5 -5082.5 {}
L 4 1242.5 -5087.5 1257.5 -5092.5 {}
L 4 1242.5 -5097.5 1257.5 -5092.5 {}
L 4 1242.5 -5097.5 1257.5 -5102.5 {}
L 4 1242.5 -5107.5 1257.5 -5102.5 {}
L 4 1242.5 -5107.5 1257.5 -5112.5 {}
L 4 1242.5 -5117.5 1257.5 -5112.5 {}
L 4 1242.5 -5117.5 1250 -5120 {}
L 4 1250 -5130 1250 -5120 {}
L 4 1252.5 -5122.5 1257.5 -5122.5 {}
L 4 1255 -5125 1255 -5120 {}
L 4 1360 -5080 1360 -5070 {}
L 4 1360 -5080 1367.5 -5082.5 {}
L 4 1352.5 -5087.5 1367.5 -5082.5 {}
L 4 1352.5 -5087.5 1367.5 -5092.5 {}
L 4 1352.5 -5097.5 1367.5 -5092.5 {}
L 4 1352.5 -5097.5 1367.5 -5102.5 {}
L 4 1352.5 -5107.5 1367.5 -5102.5 {}
L 4 1352.5 -5107.5 1367.5 -5112.5 {}
L 4 1352.5 -5117.5 1367.5 -5112.5 {}
L 4 1352.5 -5117.5 1360 -5120 {}
L 4 1360 -5130 1360 -5120 {}
L 4 1362.5 -5122.5 1367.5 -5122.5 {}
L 4 1365 -5125 1365 -5120 {}
L 4 1470 -5080 1470 -5070 {}
L 4 1470 -5080 1477.5 -5082.5 {}
L 4 1462.5 -5087.5 1477.5 -5082.5 {}
L 4 1462.5 -5087.5 1477.5 -5092.5 {}
L 4 1462.5 -5097.5 1477.5 -5092.5 {}
L 4 1462.5 -5097.5 1477.5 -5102.5 {}
L 4 1462.5 -5107.5 1477.5 -5102.5 {}
L 4 1462.5 -5107.5 1477.5 -5112.5 {}
L 4 1462.5 -5117.5 1477.5 -5112.5 {}
L 4 1462.5 -5117.5 1470 -5120 {}
L 4 1470 -5130 1470 -5120 {}
L 4 1472.5 -5122.5 1477.5 -5122.5 {}
L 4 1475 -5125 1475 -5120 {}
L 4 1790 -5080 1790 -5070 {}
L 4 1790 -5080 1797.5 -5082.5 {}
L 4 1782.5 -5087.5 1797.5 -5082.5 {}
L 4 1782.5 -5087.5 1797.5 -5092.5 {}
L 4 1782.5 -5097.5 1797.5 -5092.5 {}
L 4 1782.5 -5097.5 1797.5 -5102.5 {}
L 4 1782.5 -5107.5 1797.5 -5102.5 {}
L 4 1782.5 -5107.5 1797.5 -5112.5 {}
L 4 1782.5 -5117.5 1797.5 -5112.5 {}
L 4 1782.5 -5117.5 1790 -5120 {}
L 4 1790 -5130 1790 -5120 {}
L 4 1792.5 -5122.5 1797.5 -5122.5 {}
L 4 1795 -5125 1795 -5120 {}
L 4 1900 -5080 1900 -5070 {}
L 4 1900 -5080 1907.5 -5082.5 {}
L 4 1892.5 -5087.5 1907.5 -5082.5 {}
L 4 1892.5 -5087.5 1907.5 -5092.5 {}
L 4 1892.5 -5097.5 1907.5 -5092.5 {}
L 4 1892.5 -5097.5 1907.5 -5102.5 {}
L 4 1892.5 -5107.5 1907.5 -5102.5 {}
L 4 1892.5 -5107.5 1907.5 -5112.5 {}
L 4 1892.5 -5117.5 1907.5 -5112.5 {}
L 4 1892.5 -5117.5 1900 -5120 {}
L 4 1900 -5130 1900 -5120 {}
L 4 1902.5 -5122.5 1907.5 -5122.5 {}
L 4 1905 -5125 1905 -5120 {}
L 4 2010 -5080 2010 -5070 {}
L 4 2010 -5080 2017.5 -5082.5 {}
L 4 2002.5 -5087.5 2017.5 -5082.5 {}
L 4 2002.5 -5087.5 2017.5 -5092.5 {}
L 4 2002.5 -5097.5 2017.5 -5092.5 {}
L 4 2002.5 -5097.5 2017.5 -5102.5 {}
L 4 2002.5 -5107.5 2017.5 -5102.5 {}
L 4 2002.5 -5107.5 2017.5 -5112.5 {}
L 4 2002.5 -5117.5 2017.5 -5112.5 {}
L 4 2002.5 -5117.5 2010 -5120 {}
L 4 2010 -5130 2010 -5120 {}
L 4 2012.5 -5122.5 2017.5 -5122.5 {}
L 4 2015 -5125 2015 -5120 {}
L 4 2320 -5080 2320 -5070 {}
L 4 2320 -5080 2327.5 -5082.5 {}
L 4 2312.5 -5087.5 2327.5 -5082.5 {}
L 4 2312.5 -5087.5 2327.5 -5092.5 {}
L 4 2312.5 -5097.5 2327.5 -5092.5 {}
L 4 2312.5 -5097.5 2327.5 -5102.5 {}
L 4 2312.5 -5107.5 2327.5 -5102.5 {}
L 4 2312.5 -5107.5 2327.5 -5112.5 {}
L 4 2312.5 -5117.5 2327.5 -5112.5 {}
L 4 2312.5 -5117.5 2320 -5120 {}
L 4 2320 -5130 2320 -5120 {}
L 4 2322.5 -5122.5 2327.5 -5122.5 {}
L 4 2325 -5125 2325 -5120 {}
L 4 2430 -5080 2430 -5070 {}
L 4 2430 -5080 2437.5 -5082.5 {}
L 4 2422.5 -5087.5 2437.5 -5082.5 {}
L 4 2422.5 -5087.5 2437.5 -5092.5 {}
L 4 2422.5 -5097.5 2437.5 -5092.5 {}
L 4 2422.5 -5097.5 2437.5 -5102.5 {}
L 4 2422.5 -5107.5 2437.5 -5102.5 {}
L 4 2422.5 -5107.5 2437.5 -5112.5 {}
L 4 2422.5 -5117.5 2437.5 -5112.5 {}
L 4 2422.5 -5117.5 2430 -5120 {}
L 4 2430 -5130 2430 -5120 {}
L 4 2432.5 -5122.5 2437.5 -5122.5 {}
L 4 2435 -5125 2435 -5120 {}
L 4 2540 -5080 2540 -5070 {}
L 4 2540 -5080 2547.5 -5082.5 {}
L 4 2532.5 -5087.5 2547.5 -5082.5 {}
L 4 2532.5 -5087.5 2547.5 -5092.5 {}
L 4 2532.5 -5097.5 2547.5 -5092.5 {}
L 4 2532.5 -5097.5 2547.5 -5102.5 {}
L 4 2532.5 -5107.5 2547.5 -5102.5 {}
L 4 2532.5 -5107.5 2547.5 -5112.5 {}
L 4 2532.5 -5117.5 2547.5 -5112.5 {}
L 4 2532.5 -5117.5 2540 -5120 {}
L 4 2540 -5130 2540 -5120 {}
L 4 2542.5 -5122.5 2547.5 -5122.5 {}
L 4 2545 -5125 2545 -5120 {}
L 4 710 -3150 710 -3140 {}
L 4 710 -3150 717.5 -3152.5 {}
L 4 702.5 -3157.5 717.5 -3152.5 {}
L 4 702.5 -3157.5 717.5 -3162.5 {}
L 4 702.5 -3167.5 717.5 -3162.5 {}
L 4 702.5 -3167.5 717.5 -3172.5 {}
L 4 702.5 -3177.5 717.5 -3172.5 {}
L 4 702.5 -3177.5 717.5 -3182.5 {}
L 4 702.5 -3187.5 717.5 -3182.5 {}
L 4 702.5 -3187.5 710 -3190 {}
L 4 710 -3200 710 -3190 {}
L 4 712.5 -3192.5 717.5 -3192.5 {}
L 4 715 -3195 715 -3190 {}
L 4 820 -3150 820 -3140 {}
L 4 820 -3150 827.5 -3152.5 {}
L 4 812.5 -3157.5 827.5 -3152.5 {}
L 4 812.5 -3157.5 827.5 -3162.5 {}
L 4 812.5 -3167.5 827.5 -3162.5 {}
L 4 812.5 -3167.5 827.5 -3172.5 {}
L 4 812.5 -3177.5 827.5 -3172.5 {}
L 4 812.5 -3177.5 827.5 -3182.5 {}
L 4 812.5 -3187.5 827.5 -3182.5 {}
L 4 812.5 -3187.5 820 -3190 {}
L 4 820 -3200 820 -3190 {}
L 4 822.5 -3192.5 827.5 -3192.5 {}
L 4 825 -3195 825 -3190 {}
L 4 930 -3150 930 -3140 {}
L 4 930 -3150 937.5 -3152.5 {}
L 4 922.5 -3157.5 937.5 -3152.5 {}
L 4 922.5 -3157.5 937.5 -3162.5 {}
L 4 922.5 -3167.5 937.5 -3162.5 {}
L 4 922.5 -3167.5 937.5 -3172.5 {}
L 4 922.5 -3177.5 937.5 -3172.5 {}
L 4 922.5 -3177.5 937.5 -3182.5 {}
L 4 922.5 -3187.5 937.5 -3182.5 {}
L 4 922.5 -3187.5 930 -3190 {}
L 4 930 -3200 930 -3190 {}
L 4 932.5 -3192.5 937.5 -3192.5 {}
L 4 935 -3195 935 -3190 {}
L 4 710 -3060 710 -3050 {}
L 4 710 -3060 717.5 -3062.5 {}
L 4 702.5 -3067.5 717.5 -3062.5 {}
L 4 702.5 -3067.5 717.5 -3072.5 {}
L 4 702.5 -3077.5 717.5 -3072.5 {}
L 4 702.5 -3077.5 717.5 -3082.5 {}
L 4 702.5 -3087.5 717.5 -3082.5 {}
L 4 702.5 -3087.5 717.5 -3092.5 {}
L 4 702.5 -3097.5 717.5 -3092.5 {}
L 4 702.5 -3097.5 710 -3100 {}
L 4 710 -3110 710 -3100 {}
L 4 712.5 -3102.5 717.5 -3102.5 {}
L 4 715 -3105 715 -3100 {}
L 4 820 -3060 820 -3050 {}
L 4 820 -3060 827.5 -3062.5 {}
L 4 812.5 -3067.5 827.5 -3062.5 {}
L 4 812.5 -3067.5 827.5 -3072.5 {}
L 4 812.5 -3077.5 827.5 -3072.5 {}
L 4 812.5 -3077.5 827.5 -3082.5 {}
L 4 812.5 -3087.5 827.5 -3082.5 {}
L 4 812.5 -3087.5 827.5 -3092.5 {}
L 4 812.5 -3097.5 827.5 -3092.5 {}
L 4 812.5 -3097.5 820 -3100 {}
L 4 820 -3110 820 -3100 {}
L 4 822.5 -3102.5 827.5 -3102.5 {}
L 4 825 -3105 825 -3100 {}
L 4 930 -3060 930 -3050 {}
L 4 930 -3060 937.5 -3062.5 {}
L 4 922.5 -3067.5 937.5 -3062.5 {}
L 4 922.5 -3067.5 937.5 -3072.5 {}
L 4 922.5 -3077.5 937.5 -3072.5 {}
L 4 922.5 -3077.5 937.5 -3082.5 {}
L 4 922.5 -3087.5 937.5 -3082.5 {}
L 4 922.5 -3087.5 937.5 -3092.5 {}
L 4 922.5 -3097.5 937.5 -3092.5 {}
L 4 922.5 -3097.5 930 -3100 {}
L 4 930 -3110 930 -3100 {}
L 4 932.5 -3102.5 937.5 -3102.5 {}
L 4 935 -3105 935 -3100 {}
L 4 1250 -3060 1250 -3050 {}
L 4 1250 -3060 1257.5 -3062.5 {}
L 4 1242.5 -3067.5 1257.5 -3062.5 {}
L 4 1242.5 -3067.5 1257.5 -3072.5 {}
L 4 1242.5 -3077.5 1257.5 -3072.5 {}
L 4 1242.5 -3077.5 1257.5 -3082.5 {}
L 4 1242.5 -3087.5 1257.5 -3082.5 {}
L 4 1242.5 -3087.5 1257.5 -3092.5 {}
L 4 1242.5 -3097.5 1257.5 -3092.5 {}
L 4 1242.5 -3097.5 1250 -3100 {}
L 4 1250 -3110 1250 -3100 {}
L 4 1252.5 -3102.5 1257.5 -3102.5 {}
L 4 1255 -3105 1255 -3100 {}
L 4 1360 -3060 1360 -3050 {}
L 4 1360 -3060 1367.5 -3062.5 {}
L 4 1352.5 -3067.5 1367.5 -3062.5 {}
L 4 1352.5 -3067.5 1367.5 -3072.5 {}
L 4 1352.5 -3077.5 1367.5 -3072.5 {}
L 4 1352.5 -3077.5 1367.5 -3082.5 {}
L 4 1352.5 -3087.5 1367.5 -3082.5 {}
L 4 1352.5 -3087.5 1367.5 -3092.5 {}
L 4 1352.5 -3097.5 1367.5 -3092.5 {}
L 4 1352.5 -3097.5 1360 -3100 {}
L 4 1360 -3110 1360 -3100 {}
L 4 1362.5 -3102.5 1367.5 -3102.5 {}
L 4 1365 -3105 1365 -3100 {}
L 4 1470 -3060 1470 -3050 {}
L 4 1470 -3060 1477.5 -3062.5 {}
L 4 1462.5 -3067.5 1477.5 -3062.5 {}
L 4 1462.5 -3067.5 1477.5 -3072.5 {}
L 4 1462.5 -3077.5 1477.5 -3072.5 {}
L 4 1462.5 -3077.5 1477.5 -3082.5 {}
L 4 1462.5 -3087.5 1477.5 -3082.5 {}
L 4 1462.5 -3087.5 1477.5 -3092.5 {}
L 4 1462.5 -3097.5 1477.5 -3092.5 {}
L 4 1462.5 -3097.5 1470 -3100 {}
L 4 1470 -3110 1470 -3100 {}
L 4 1472.5 -3102.5 1477.5 -3102.5 {}
L 4 1475 -3105 1475 -3100 {}
L 4 1790 -3060 1790 -3050 {}
L 4 1790 -3060 1797.5 -3062.5 {}
L 4 1782.5 -3067.5 1797.5 -3062.5 {}
L 4 1782.5 -3067.5 1797.5 -3072.5 {}
L 4 1782.5 -3077.5 1797.5 -3072.5 {}
L 4 1782.5 -3077.5 1797.5 -3082.5 {}
L 4 1782.5 -3087.5 1797.5 -3082.5 {}
L 4 1782.5 -3087.5 1797.5 -3092.5 {}
L 4 1782.5 -3097.5 1797.5 -3092.5 {}
L 4 1782.5 -3097.5 1790 -3100 {}
L 4 1790 -3110 1790 -3100 {}
L 4 1792.5 -3102.5 1797.5 -3102.5 {}
L 4 1795 -3105 1795 -3100 {}
L 4 1900 -3060 1900 -3050 {}
L 4 1900 -3060 1907.5 -3062.5 {}
L 4 1892.5 -3067.5 1907.5 -3062.5 {}
L 4 1892.5 -3067.5 1907.5 -3072.5 {}
L 4 1892.5 -3077.5 1907.5 -3072.5 {}
L 4 1892.5 -3077.5 1907.5 -3082.5 {}
L 4 1892.5 -3087.5 1907.5 -3082.5 {}
L 4 1892.5 -3087.5 1907.5 -3092.5 {}
L 4 1892.5 -3097.5 1907.5 -3092.5 {}
L 4 1892.5 -3097.5 1900 -3100 {}
L 4 1900 -3110 1900 -3100 {}
L 4 1902.5 -3102.5 1907.5 -3102.5 {}
L 4 1905 -3105 1905 -3100 {}
L 4 2010 -3060 2010 -3050 {}
L 4 2010 -3060 2017.5 -3062.5 {}
L 4 2002.5 -3067.5 2017.5 -3062.5 {}
L 4 2002.5 -3067.5 2017.5 -3072.5 {}
L 4 2002.5 -3077.5 2017.5 -3072.5 {}
L 4 2002.5 -3077.5 2017.5 -3082.5 {}
L 4 2002.5 -3087.5 2017.5 -3082.5 {}
L 4 2002.5 -3087.5 2017.5 -3092.5 {}
L 4 2002.5 -3097.5 2017.5 -3092.5 {}
L 4 2002.5 -3097.5 2010 -3100 {}
L 4 2010 -3110 2010 -3100 {}
L 4 2012.5 -3102.5 2017.5 -3102.5 {}
L 4 2015 -3105 2015 -3100 {}
L 4 1865 -4870 1865 -4810 {}
L 4 1865 -4860 1880 -4860 {}
L 4 1880 -4870 1880 -4860 {}
L 4 1865 -4820 1880 -4820 {}
L 4 1880 -4820 1880 -4810 {}
L 4 1855 -4855 1855 -4825 {}
L 4 1855 -4840 1855 -4835 {}
L 4 1840 -4840 1847.5 -4840 {}
L 4 1840 -4840 1855 -4840 {}
L 4 1870 -4840 1880 -4840 {}
L 4 1865 -4845 1870 -4840 {}
L 4 1865 -4835 1870 -4840 {}
L 4 1140 -12890 1140 -12877.5 {}
L 4 1135 -12877.5 1145 -12877.5 {}
L 4 1140 -12872.5 1145 -12877.5 {}
L 4 1135 -12877.5 1140 -12872.5 {}
L 4 1140 -13170 1140 -13150 {}
L 4 1130 -13170 1150 -13170 {}
L 4 1032.5 -12962.5 1037.5 -12962.5 {}
L 4 1035 -12965 1035 -12960 {}
L 4 1030 -12970 1030 -12910 {}
L 4 710 -2770 710 -2760 {}
L 4 710 -2770 717.5 -2772.5 {}
L 4 702.5 -2777.5 717.5 -2772.5 {}
L 4 702.5 -2777.5 717.5 -2782.5 {}
L 4 702.5 -2787.5 717.5 -2782.5 {}
L 4 702.5 -2787.5 717.5 -2792.5 {}
L 4 702.5 -2797.5 717.5 -2792.5 {}
L 4 702.5 -2797.5 717.5 -2802.5 {}
L 4 702.5 -2807.5 717.5 -2802.5 {}
L 4 702.5 -2807.5 710 -2810 {}
L 4 710 -2820 710 -2810 {}
L 4 712.5 -2812.5 717.5 -2812.5 {}
L 4 715 -2815 715 -2810 {}
L 4 820 -2770 820 -2760 {}
L 4 820 -2770 827.5 -2772.5 {}
L 4 812.5 -2777.5 827.5 -2772.5 {}
L 4 812.5 -2777.5 827.5 -2782.5 {}
L 4 812.5 -2787.5 827.5 -2782.5 {}
L 4 812.5 -2787.5 827.5 -2792.5 {}
L 4 812.5 -2797.5 827.5 -2792.5 {}
L 4 812.5 -2797.5 827.5 -2802.5 {}
L 4 812.5 -2807.5 827.5 -2802.5 {}
L 4 812.5 -2807.5 820 -2810 {}
L 4 820 -2820 820 -2810 {}
L 4 822.5 -2812.5 827.5 -2812.5 {}
L 4 825 -2815 825 -2810 {}
L 4 930 -2770 930 -2760 {}
L 4 930 -2770 937.5 -2772.5 {}
L 4 922.5 -2777.5 937.5 -2772.5 {}
L 4 922.5 -2777.5 937.5 -2782.5 {}
L 4 922.5 -2787.5 937.5 -2782.5 {}
L 4 922.5 -2787.5 937.5 -2792.5 {}
L 4 922.5 -2797.5 937.5 -2792.5 {}
L 4 922.5 -2797.5 937.5 -2802.5 {}
L 4 922.5 -2807.5 937.5 -2802.5 {}
L 4 922.5 -2807.5 930 -2810 {}
L 4 930 -2820 930 -2810 {}
L 4 932.5 -2812.5 937.5 -2812.5 {}
L 4 935 -2815 935 -2810 {}
L 4 710 -2710 710 -2700 {}
L 4 710 -2710 717.5 -2712.5 {}
L 4 702.5 -2717.5 717.5 -2712.5 {}
L 4 702.5 -2717.5 717.5 -2722.5 {}
L 4 702.5 -2727.5 717.5 -2722.5 {}
L 4 702.5 -2727.5 717.5 -2732.5 {}
L 4 702.5 -2737.5 717.5 -2732.5 {}
L 4 702.5 -2737.5 717.5 -2742.5 {}
L 4 702.5 -2747.5 717.5 -2742.5 {}
L 4 702.5 -2747.5 710 -2750 {}
L 4 710 -2760 710 -2750 {}
L 4 712.5 -2752.5 717.5 -2752.5 {}
L 4 715 -2755 715 -2750 {}
L 4 820 -2710 820 -2700 {}
L 4 820 -2710 827.5 -2712.5 {}
L 4 812.5 -2717.5 827.5 -2712.5 {}
L 4 812.5 -2717.5 827.5 -2722.5 {}
L 4 812.5 -2727.5 827.5 -2722.5 {}
L 4 812.5 -2727.5 827.5 -2732.5 {}
L 4 812.5 -2737.5 827.5 -2732.5 {}
L 4 812.5 -2737.5 827.5 -2742.5 {}
L 4 812.5 -2747.5 827.5 -2742.5 {}
L 4 812.5 -2747.5 820 -2750 {}
L 4 820 -2760 820 -2750 {}
L 4 822.5 -2752.5 827.5 -2752.5 {}
L 4 825 -2755 825 -2750 {}
L 4 930 -2710 930 -2700 {}
L 4 930 -2710 937.5 -2712.5 {}
L 4 922.5 -2717.5 937.5 -2712.5 {}
L 4 922.5 -2717.5 937.5 -2722.5 {}
L 4 922.5 -2727.5 937.5 -2722.5 {}
L 4 922.5 -2727.5 937.5 -2732.5 {}
L 4 922.5 -2737.5 937.5 -2732.5 {}
L 4 922.5 -2737.5 937.5 -2742.5 {}
L 4 922.5 -2747.5 937.5 -2742.5 {}
L 4 922.5 -2747.5 930 -2750 {}
L 4 930 -2760 930 -2750 {}
L 4 932.5 -2752.5 937.5 -2752.5 {}
L 4 935 -2755 935 -2750 {}
L 4 1250 -2710 1250 -2700 {}
L 4 1250 -2710 1257.5 -2712.5 {}
L 4 1242.5 -2717.5 1257.5 -2712.5 {}
L 4 1242.5 -2717.5 1257.5 -2722.5 {}
L 4 1242.5 -2727.5 1257.5 -2722.5 {}
L 4 1242.5 -2727.5 1257.5 -2732.5 {}
L 4 1242.5 -2737.5 1257.5 -2732.5 {}
L 4 1242.5 -2737.5 1257.5 -2742.5 {}
L 4 1242.5 -2747.5 1257.5 -2742.5 {}
L 4 1242.5 -2747.5 1250 -2750 {}
L 4 1250 -2760 1250 -2750 {}
L 4 1252.5 -2752.5 1257.5 -2752.5 {}
L 4 1255 -2755 1255 -2750 {}
L 4 1360 -2710 1360 -2700 {}
L 4 1360 -2710 1367.5 -2712.5 {}
L 4 1352.5 -2717.5 1367.5 -2712.5 {}
L 4 1352.5 -2717.5 1367.5 -2722.5 {}
L 4 1352.5 -2727.5 1367.5 -2722.5 {}
L 4 1352.5 -2727.5 1367.5 -2732.5 {}
L 4 1352.5 -2737.5 1367.5 -2732.5 {}
L 4 1352.5 -2737.5 1367.5 -2742.5 {}
L 4 1352.5 -2747.5 1367.5 -2742.5 {}
L 4 1352.5 -2747.5 1360 -2750 {}
L 4 1360 -2760 1360 -2750 {}
L 4 1362.5 -2752.5 1367.5 -2752.5 {}
L 4 1365 -2755 1365 -2750 {}
L 4 1470 -2710 1470 -2700 {}
L 4 1470 -2710 1477.5 -2712.5 {}
L 4 1462.5 -2717.5 1477.5 -2712.5 {}
L 4 1462.5 -2717.5 1477.5 -2722.5 {}
L 4 1462.5 -2727.5 1477.5 -2722.5 {}
L 4 1462.5 -2727.5 1477.5 -2732.5 {}
L 4 1462.5 -2737.5 1477.5 -2732.5 {}
L 4 1462.5 -2737.5 1477.5 -2742.5 {}
L 4 1462.5 -2747.5 1477.5 -2742.5 {}
L 4 1462.5 -2747.5 1470 -2750 {}
L 4 1470 -2760 1470 -2750 {}
L 4 1472.5 -2752.5 1477.5 -2752.5 {}
L 4 1475 -2755 1475 -2750 {}
L 4 1790 -2680 1790 -2670 {}
L 4 1790 -2680 1797.5 -2682.5 {}
L 4 1782.5 -2687.5 1797.5 -2682.5 {}
L 4 1782.5 -2687.5 1797.5 -2692.5 {}
L 4 1782.5 -2697.5 1797.5 -2692.5 {}
L 4 1782.5 -2697.5 1797.5 -2702.5 {}
L 4 1782.5 -2707.5 1797.5 -2702.5 {}
L 4 1782.5 -2707.5 1797.5 -2712.5 {}
L 4 1782.5 -2717.5 1797.5 -2712.5 {}
L 4 1782.5 -2717.5 1790 -2720 {}
L 4 1790 -2730 1790 -2720 {}
L 4 1792.5 -2722.5 1797.5 -2722.5 {}
L 4 1795 -2725 1795 -2720 {}
L 4 1900 -2680 1900 -2670 {}
L 4 1900 -2680 1907.5 -2682.5 {}
L 4 1892.5 -2687.5 1907.5 -2682.5 {}
L 4 1892.5 -2687.5 1907.5 -2692.5 {}
L 4 1892.5 -2697.5 1907.5 -2692.5 {}
L 4 1892.5 -2697.5 1907.5 -2702.5 {}
L 4 1892.5 -2707.5 1907.5 -2702.5 {}
L 4 1892.5 -2707.5 1907.5 -2712.5 {}
L 4 1892.5 -2717.5 1907.5 -2712.5 {}
L 4 1892.5 -2717.5 1900 -2720 {}
L 4 1900 -2730 1900 -2720 {}
L 4 1902.5 -2722.5 1907.5 -2722.5 {}
L 4 1905 -2725 1905 -2720 {}
L 4 2010 -2680 2010 -2670 {}
L 4 2010 -2680 2017.5 -2682.5 {}
L 4 2002.5 -2687.5 2017.5 -2682.5 {}
L 4 2002.5 -2687.5 2017.5 -2692.5 {}
L 4 2002.5 -2697.5 2017.5 -2692.5 {}
L 4 2002.5 -2697.5 2017.5 -2702.5 {}
L 4 2002.5 -2707.5 2017.5 -2702.5 {}
L 4 2002.5 -2707.5 2017.5 -2712.5 {}
L 4 2002.5 -2717.5 2017.5 -2712.5 {}
L 4 2002.5 -2717.5 2010 -2720 {}
L 4 2010 -2730 2010 -2720 {}
L 4 2012.5 -2722.5 2017.5 -2722.5 {}
L 4 2015 -2725 2015 -2720 {}
L 4 1760 -3460 1760 -3450 {}
L 4 1760 -3460 1767.5 -3462.5 {}
L 4 1752.5 -3467.5 1767.5 -3462.5 {}
L 4 1752.5 -3467.5 1767.5 -3472.5 {}
L 4 1752.5 -3477.5 1767.5 -3472.5 {}
L 4 1752.5 -3477.5 1767.5 -3482.5 {}
L 4 1752.5 -3487.5 1767.5 -3482.5 {}
L 4 1752.5 -3487.5 1767.5 -3492.5 {}
L 4 1752.5 -3497.5 1767.5 -3492.5 {}
L 4 1752.5 -3497.5 1760 -3500 {}
L 4 1760 -3510 1760 -3500 {}
L 4 1762.5 -3502.5 1767.5 -3502.5 {}
L 4 1765 -3505 1765 -3500 {}
L 4 1880 -3460 1880 -3450 {}
L 4 1880 -3460 1887.5 -3462.5 {}
L 4 1872.5 -3467.5 1887.5 -3462.5 {}
L 4 1872.5 -3467.5 1887.5 -3472.5 {}
L 4 1872.5 -3477.5 1887.5 -3472.5 {}
L 4 1872.5 -3477.5 1887.5 -3482.5 {}
L 4 1872.5 -3487.5 1887.5 -3482.5 {}
L 4 1872.5 -3487.5 1887.5 -3492.5 {}
L 4 1872.5 -3497.5 1887.5 -3492.5 {}
L 4 1872.5 -3497.5 1880 -3500 {}
L 4 1880 -3510 1880 -3500 {}
L 4 1882.5 -3502.5 1887.5 -3502.5 {}
L 4 1885 -3505 1885 -3500 {}
L 4 805 -2360 805 -2300 {}
L 4 805 -2350 820 -2350 {}
L 4 820 -2360 820 -2350 {}
L 4 805 -2310 820 -2310 {}
L 4 820 -2310 820 -2300 {}
L 4 795 -2345 795 -2315 {}
L 4 795 -2330 795 -2325 {}
L 4 780 -2330 787.5 -2330 {}
L 4 780 -2330 795 -2330 {}
L 4 810 -2330 820 -2330 {}
L 4 805 -2335 810 -2330 {}
L 4 805 -2325 810 -2330 {}
L 4 820 -2400 820 -2390 {}
L 4 820 -2400 827.5 -2402.5 {}
L 4 812.5 -2407.5 827.5 -2402.5 {}
L 4 812.5 -2407.5 827.5 -2412.5 {}
L 4 812.5 -2417.5 827.5 -2412.5 {}
L 4 812.5 -2417.5 827.5 -2422.5 {}
L 4 812.5 -2427.5 827.5 -2422.5 {}
L 4 812.5 -2427.5 827.5 -2432.5 {}
L 4 812.5 -2437.5 827.5 -2432.5 {}
L 4 812.5 -2437.5 820 -2440 {}
L 4 820 -2450 820 -2440 {}
L 4 822.5 -2442.5 827.5 -2442.5 {}
L 4 825 -2445 825 -2440 {}
L 4 910 -2325 910 -2300 {}
L 4 910 -2360 910 -2335 {}
L 4 900 -2335 920 -2335 {}
L 4 900 -2325 920 -2325 {}
L 4 912.5 -2352.5 917.5 -2352.5 {}
L 4 915 -2355 915 -2350 {}
L 4 582.5 -2292.5 587.5 -2292.5 {}
L 4 585 -2295 585 -2290 {}
L 4 580 -2300 580 -2240 {}
L 4 690 -2220 690 -2207.5 {}
L 4 685 -2207.5 695 -2207.5 {}
L 4 690 -2202.5 695 -2207.5 {}
L 4 685 -2207.5 690 -2202.5 {}
L 4 690 -2500 690 -2480 {}
L 4 680 -2500 700 -2500 {}
L 4 1405 -2360 1405 -2300 {}
L 4 1405 -2350 1420 -2350 {}
L 4 1420 -2360 1420 -2350 {}
L 4 1405 -2310 1420 -2310 {}
L 4 1420 -2310 1420 -2300 {}
L 4 1395 -2345 1395 -2315 {}
L 4 1395 -2330 1395 -2325 {}
L 4 1380 -2330 1387.5 -2330 {}
L 4 1380 -2330 1395 -2330 {}
L 4 1410 -2330 1420 -2330 {}
L 4 1405 -2335 1410 -2330 {}
L 4 1405 -2325 1410 -2330 {}
L 4 1420 -2400 1420 -2390 {}
L 4 1420 -2400 1427.5 -2402.5 {}
L 4 1412.5 -2407.5 1427.5 -2402.5 {}
L 4 1412.5 -2407.5 1427.5 -2412.5 {}
L 4 1412.5 -2417.5 1427.5 -2412.5 {}
L 4 1412.5 -2417.5 1427.5 -2422.5 {}
L 4 1412.5 -2427.5 1427.5 -2422.5 {}
L 4 1412.5 -2427.5 1427.5 -2432.5 {}
L 4 1412.5 -2437.5 1427.5 -2432.5 {}
L 4 1412.5 -2437.5 1420 -2440 {}
L 4 1420 -2450 1420 -2440 {}
L 4 1422.5 -2442.5 1427.5 -2442.5 {}
L 4 1425 -2445 1425 -2440 {}
L 4 1182.5 -2292.5 1187.5 -2292.5 {}
L 4 1185 -2295 1185 -2290 {}
L 4 1180 -2300 1180 -2240 {}
L 4 1290 -2220 1290 -2207.5 {}
L 4 1285 -2207.5 1295 -2207.5 {}
L 4 1290 -2202.5 1295 -2207.5 {}
L 4 1285 -2207.5 1290 -2202.5 {}
L 4 1290 -2500 1290 -2480 {}
L 4 1280 -2500 1300 -2500 {}
L 4 2015 -2360 2015 -2300 {}
L 4 2015 -2350 2030 -2350 {}
L 4 2030 -2360 2030 -2350 {}
L 4 2015 -2310 2030 -2310 {}
L 4 2030 -2310 2030 -2300 {}
L 4 2005 -2345 2005 -2315 {}
L 4 2005 -2330 2005 -2325 {}
L 4 1990 -2330 1997.5 -2330 {}
L 4 1990 -2330 2005 -2330 {}
L 4 2020 -2330 2030 -2330 {}
L 4 2015 -2335 2020 -2330 {}
L 4 2015 -2325 2020 -2330 {}
L 4 2030 -2400 2030 -2390 {}
L 4 2030 -2400 2037.5 -2402.5 {}
L 4 2022.5 -2407.5 2037.5 -2402.5 {}
L 4 2022.5 -2407.5 2037.5 -2412.5 {}
L 4 2022.5 -2417.5 2037.5 -2412.5 {}
L 4 2022.5 -2417.5 2037.5 -2422.5 {}
L 4 2022.5 -2427.5 2037.5 -2422.5 {}
L 4 2022.5 -2427.5 2037.5 -2432.5 {}
L 4 2022.5 -2437.5 2037.5 -2432.5 {}
L 4 2022.5 -2437.5 2030 -2440 {}
L 4 2030 -2450 2030 -2440 {}
L 4 2032.5 -2442.5 2037.5 -2442.5 {}
L 4 2035 -2445 2035 -2440 {}
L 4 1792.5 -2292.5 1797.5 -2292.5 {}
L 4 1795 -2295 1795 -2290 {}
L 4 1790 -2300 1790 -2240 {}
L 4 1900 -2220 1900 -2207.5 {}
L 4 1895 -2207.5 1905 -2207.5 {}
L 4 1900 -2202.5 1905 -2207.5 {}
L 4 1895 -2207.5 1900 -2202.5 {}
L 4 1900 -2500 1900 -2480 {}
L 4 1890 -2500 1910 -2500 {}
L 4 360 -9610 360 -9600 {}
L 4 360 -9610 367.5 -9612.5 {}
L 4 352.5 -9617.5 367.5 -9612.5 {}
L 4 352.5 -9617.5 367.5 -9622.5 {}
L 4 352.5 -9627.5 367.5 -9622.5 {}
L 4 352.5 -9627.5 367.5 -9632.5 {}
L 4 352.5 -9637.5 367.5 -9632.5 {}
L 4 352.5 -9637.5 367.5 -9642.5 {}
L 4 352.5 -9647.5 367.5 -9642.5 {}
L 4 352.5 -9647.5 360 -9650 {}
L 4 360 -9660 360 -9650 {}
L 4 362.5 -9652.5 367.5 -9652.5 {}
L 4 365 -9655 365 -9650 {}
L 4 560 -9610 560 -9600 {}
L 4 560 -9610 567.5 -9612.5 {}
L 4 552.5 -9617.5 567.5 -9612.5 {}
L 4 552.5 -9617.5 567.5 -9622.5 {}
L 4 552.5 -9627.5 567.5 -9622.5 {}
L 4 552.5 -9627.5 567.5 -9632.5 {}
L 4 552.5 -9637.5 567.5 -9632.5 {}
L 4 552.5 -9637.5 567.5 -9642.5 {}
L 4 552.5 -9647.5 567.5 -9642.5 {}
L 4 552.5 -9647.5 560 -9650 {}
L 4 560 -9660 560 -9650 {}
L 4 562.5 -9652.5 567.5 -9652.5 {}
L 4 565 -9655 565 -9650 {}
L 4 800 -9610 800 -9600 {}
L 4 800 -9610 807.5 -9612.5 {}
L 4 792.5 -9617.5 807.5 -9612.5 {}
L 4 792.5 -9617.5 807.5 -9622.5 {}
L 4 792.5 -9627.5 807.5 -9622.5 {}
L 4 792.5 -9627.5 807.5 -9632.5 {}
L 4 792.5 -9637.5 807.5 -9632.5 {}
L 4 792.5 -9637.5 807.5 -9642.5 {}
L 4 792.5 -9647.5 807.5 -9642.5 {}
L 4 792.5 -9647.5 800 -9650 {}
L 4 800 -9660 800 -9650 {}
L 4 802.5 -9652.5 807.5 -9652.5 {}
L 4 805 -9655 805 -9650 {}
L 4 1090 -9610 1090 -9600 {}
L 4 1090 -9610 1097.5 -9612.5 {}
L 4 1082.5 -9617.5 1097.5 -9612.5 {}
L 4 1082.5 -9617.5 1097.5 -9622.5 {}
L 4 1082.5 -9627.5 1097.5 -9622.5 {}
L 4 1082.5 -9627.5 1097.5 -9632.5 {}
L 4 1082.5 -9637.5 1097.5 -9632.5 {}
L 4 1082.5 -9637.5 1097.5 -9642.5 {}
L 4 1082.5 -9647.5 1097.5 -9642.5 {}
L 4 1082.5 -9647.5 1090 -9650 {}
L 4 1090 -9660 1090 -9650 {}
L 4 1092.5 -9652.5 1097.5 -9652.5 {}
L 4 1095 -9655 1095 -9650 {}
L 4 1320 -9610 1320 -9600 {}
L 4 1320 -9610 1327.5 -9612.5 {}
L 4 1312.5 -9617.5 1327.5 -9612.5 {}
L 4 1312.5 -9617.5 1327.5 -9622.5 {}
L 4 1312.5 -9627.5 1327.5 -9622.5 {}
L 4 1312.5 -9627.5 1327.5 -9632.5 {}
L 4 1312.5 -9637.5 1327.5 -9632.5 {}
L 4 1312.5 -9637.5 1327.5 -9642.5 {}
L 4 1312.5 -9647.5 1327.5 -9642.5 {}
L 4 1312.5 -9647.5 1320 -9650 {}
L 4 1320 -9660 1320 -9650 {}
L 4 1322.5 -9652.5 1327.5 -9652.5 {}
L 4 1325 -9655 1325 -9650 {}
L 4 1610 -9610 1610 -9600 {}
L 4 1610 -9610 1617.5 -9612.5 {}
L 4 1602.5 -9617.5 1617.5 -9612.5 {}
L 4 1602.5 -9617.5 1617.5 -9622.5 {}
L 4 1602.5 -9627.5 1617.5 -9622.5 {}
L 4 1602.5 -9627.5 1617.5 -9632.5 {}
L 4 1602.5 -9637.5 1617.5 -9632.5 {}
L 4 1602.5 -9637.5 1617.5 -9642.5 {}
L 4 1602.5 -9647.5 1617.5 -9642.5 {}
L 4 1602.5 -9647.5 1610 -9650 {}
L 4 1610 -9660 1610 -9650 {}
L 4 1612.5 -9652.5 1617.5 -9652.5 {}
L 4 1615 -9655 1615 -9650 {}
L 4 1850 -9610 1850 -9600 {}
L 4 1850 -9610 1857.5 -9612.5 {}
L 4 1842.5 -9617.5 1857.5 -9612.5 {}
L 4 1842.5 -9617.5 1857.5 -9622.5 {}
L 4 1842.5 -9627.5 1857.5 -9622.5 {}
L 4 1842.5 -9627.5 1857.5 -9632.5 {}
L 4 1842.5 -9637.5 1857.5 -9632.5 {}
L 4 1842.5 -9637.5 1857.5 -9642.5 {}
L 4 1842.5 -9647.5 1857.5 -9642.5 {}
L 4 1842.5 -9647.5 1850 -9650 {}
L 4 1850 -9660 1850 -9650 {}
L 4 1852.5 -9652.5 1857.5 -9652.5 {}
L 4 1855 -9655 1855 -9650 {}
L 4 2150 -9610 2150 -9600 {}
L 4 2150 -9610 2157.5 -9612.5 {}
L 4 2142.5 -9617.5 2157.5 -9612.5 {}
L 4 2142.5 -9617.5 2157.5 -9622.5 {}
L 4 2142.5 -9627.5 2157.5 -9622.5 {}
L 4 2142.5 -9627.5 2157.5 -9632.5 {}
L 4 2142.5 -9637.5 2157.5 -9632.5 {}
L 4 2142.5 -9637.5 2157.5 -9642.5 {}
L 4 2142.5 -9647.5 2157.5 -9642.5 {}
L 4 2142.5 -9647.5 2150 -9650 {}
L 4 2150 -9660 2150 -9650 {}
L 4 2152.5 -9652.5 2157.5 -9652.5 {}
L 4 2155 -9655 2155 -9650 {}
L 4 745 -6420 745 -6360 {}
L 4 745 -6410 760 -6410 {}
L 4 760 -6420 760 -6410 {}
L 4 745 -6370 760 -6370 {}
L 4 760 -6370 760 -6360 {}
L 4 735 -6405 735 -6375 {}
L 4 735 -6390 735 -6385 {}
L 4 720 -6390 727.5 -6390 {}
L 4 720 -6390 735 -6390 {}
L 4 750 -6390 760 -6390 {}
L 4 745 -6395 750 -6390 {}
L 4 745 -6385 750 -6390 {}
L 4 760 -6460 760 -6450 {}
L 4 760 -6460 767.5 -6462.5 {}
L 4 752.5 -6467.5 767.5 -6462.5 {}
L 4 752.5 -6467.5 767.5 -6472.5 {}
L 4 752.5 -6477.5 767.5 -6472.5 {}
L 4 752.5 -6477.5 767.5 -6482.5 {}
L 4 752.5 -6487.5 767.5 -6482.5 {}
L 4 752.5 -6487.5 767.5 -6492.5 {}
L 4 752.5 -6497.5 767.5 -6492.5 {}
L 4 752.5 -6497.5 760 -6500 {}
L 4 760 -6510 760 -6500 {}
L 4 762.5 -6502.5 767.5 -6502.5 {}
L 4 765 -6505 765 -6500 {}
L 4 522.5 -6352.5 527.5 -6352.5 {}
L 4 525 -6355 525 -6350 {}
L 4 520 -6360 520 -6300 {}
L 4 630 -6280 630 -6267.5 {}
L 4 625 -6267.5 635 -6267.5 {}
L 4 630 -6262.5 635 -6267.5 {}
L 4 625 -6267.5 630 -6262.5 {}
L 4 630 -6560 630 -6540 {}
L 4 620 -6560 640 -6560 {}
L 4 1305 -6420 1305 -6360 {}
L 4 1305 -6410 1320 -6410 {}
L 4 1320 -6420 1320 -6410 {}
L 4 1305 -6370 1320 -6370 {}
L 4 1320 -6370 1320 -6360 {}
L 4 1295 -6405 1295 -6375 {}
L 4 1295 -6390 1295 -6385 {}
L 4 1280 -6390 1287.5 -6390 {}
L 4 1280 -6390 1295 -6390 {}
L 4 1310 -6390 1320 -6390 {}
L 4 1305 -6395 1310 -6390 {}
L 4 1305 -6385 1310 -6390 {}
L 4 1320 -6460 1320 -6450 {}
L 4 1320 -6460 1327.5 -6462.5 {}
L 4 1312.5 -6467.5 1327.5 -6462.5 {}
L 4 1312.5 -6467.5 1327.5 -6472.5 {}
L 4 1312.5 -6477.5 1327.5 -6472.5 {}
L 4 1312.5 -6477.5 1327.5 -6482.5 {}
L 4 1312.5 -6487.5 1327.5 -6482.5 {}
L 4 1312.5 -6487.5 1327.5 -6492.5 {}
L 4 1312.5 -6497.5 1327.5 -6492.5 {}
L 4 1312.5 -6497.5 1320 -6500 {}
L 4 1320 -6510 1320 -6500 {}
L 4 1322.5 -6502.5 1327.5 -6502.5 {}
L 4 1325 -6505 1325 -6500 {}
L 4 1082.5 -6352.5 1087.5 -6352.5 {}
L 4 1085 -6355 1085 -6350 {}
L 4 1080 -6360 1080 -6300 {}
L 4 1190 -6280 1190 -6267.5 {}
L 4 1185 -6267.5 1195 -6267.5 {}
L 4 1190 -6262.5 1195 -6267.5 {}
L 4 1185 -6267.5 1190 -6262.5 {}
L 4 1190 -6560 1190 -6540 {}
L 4 1180 -6560 1200 -6560 {}
L 4 690 -11310 690 -11250 {}
L 4 690 -11300 705 -11300 {}
L 4 705 -11310 705 -11300 {}
L 4 690 -11260 705 -11260 {}
L 4 705 -11260 705 -11250 {}
L 4 680 -11295 680 -11265 {}
L 4 680 -11280 680 -11275 {}
L 4 665 -11280 672.5 -11280 {}
L 4 665 -11280 680 -11280 {}
L 4 695 -11280 705 -11280 {}
L 4 690 -11285 695 -11280 {}
L 4 690 -11275 695 -11280 {}
L 4 705 -11350 705 -11340 {}
L 4 705 -11350 712.5 -11352.5 {}
L 4 697.5 -11357.5 712.5 -11352.5 {}
L 4 697.5 -11357.5 712.5 -11362.5 {}
L 4 697.5 -11367.5 712.5 -11362.5 {}
L 4 697.5 -11367.5 712.5 -11372.5 {}
L 4 697.5 -11377.5 712.5 -11372.5 {}
L 4 697.5 -11377.5 712.5 -11382.5 {}
L 4 697.5 -11387.5 712.5 -11382.5 {}
L 4 697.5 -11387.5 705 -11390 {}
L 4 705 -11400 705 -11390 {}
L 4 707.5 -11392.5 712.5 -11392.5 {}
L 4 710 -11395 710 -11390 {}
L 4 795 -11275 795 -11250 {}
L 4 795 -11310 795 -11285 {}
L 4 785 -11285 805 -11285 {}
L 4 785 -11275 805 -11275 {}
L 4 797.5 -11302.5 802.5 -11302.5 {}
L 4 800 -11305 800 -11300 {}
L 4 467.5 -11242.5 472.5 -11242.5 {}
L 4 470 -11245 470 -11240 {}
L 4 465 -11250 465 -11190 {}
L 4 575 -11170 575 -11157.5 {}
L 4 570 -11157.5 580 -11157.5 {}
L 4 575 -11152.5 580 -11157.5 {}
L 4 570 -11157.5 575 -11152.5 {}
L 4 575 -11450 575 -11430 {}
L 4 565 -11450 585 -11450 {}
L 4 1255 -11310 1255 -11250 {}
L 4 1255 -11300 1270 -11300 {}
L 4 1270 -11310 1270 -11300 {}
L 4 1255 -11260 1270 -11260 {}
L 4 1270 -11260 1270 -11250 {}
L 4 1245 -11295 1245 -11265 {}
L 4 1245 -11280 1245 -11275 {}
L 4 1230 -11280 1237.5 -11280 {}
L 4 1230 -11280 1245 -11280 {}
L 4 1260 -11280 1270 -11280 {}
L 4 1255 -11285 1260 -11280 {}
L 4 1255 -11275 1260 -11280 {}
L 4 1270 -11350 1270 -11340 {}
L 4 1270 -11350 1277.5 -11352.5 {}
L 4 1262.5 -11357.5 1277.5 -11352.5 {}
L 4 1262.5 -11357.5 1277.5 -11362.5 {}
L 4 1262.5 -11367.5 1277.5 -11362.5 {}
L 4 1262.5 -11367.5 1277.5 -11372.5 {}
L 4 1262.5 -11377.5 1277.5 -11372.5 {}
L 4 1262.5 -11377.5 1277.5 -11382.5 {}
L 4 1262.5 -11387.5 1277.5 -11382.5 {}
L 4 1262.5 -11387.5 1270 -11390 {}
L 4 1270 -11400 1270 -11390 {}
L 4 1272.5 -11392.5 1277.5 -11392.5 {}
L 4 1275 -11395 1275 -11390 {}
L 4 1360 -11275 1360 -11250 {}
L 4 1360 -11310 1360 -11285 {}
L 4 1350 -11285 1370 -11285 {}
L 4 1350 -11275 1370 -11275 {}
L 4 1362.5 -11302.5 1367.5 -11302.5 {}
L 4 1365 -11305 1365 -11300 {}
L 4 1032.5 -11242.5 1037.5 -11242.5 {}
L 4 1035 -11245 1035 -11240 {}
L 4 1030 -11250 1030 -11190 {}
L 4 1140 -11170 1140 -11157.5 {}
L 4 1135 -11157.5 1145 -11157.5 {}
L 4 1140 -11152.5 1145 -11157.5 {}
L 4 1135 -11157.5 1140 -11152.5 {}
L 4 1140 -11450 1140 -11430 {}
L 4 1130 -11450 1150 -11450 {}
L 4 1755 -11310 1755 -11250 {}
L 4 1755 -11300 1770 -11300 {}
L 4 1770 -11310 1770 -11300 {}
L 4 1755 -11260 1770 -11260 {}
L 4 1770 -11260 1770 -11250 {}
L 4 1745 -11295 1745 -11265 {}
L 4 1745 -11280 1745 -11275 {}
L 4 1730 -11280 1737.5 -11280 {}
L 4 1730 -11280 1745 -11280 {}
L 4 1760 -11280 1770 -11280 {}
L 4 1755 -11285 1760 -11280 {}
L 4 1755 -11275 1760 -11280 {}
L 4 1770 -11350 1770 -11340 {}
L 4 1770 -11350 1777.5 -11352.5 {}
L 4 1762.5 -11357.5 1777.5 -11352.5 {}
L 4 1762.5 -11357.5 1777.5 -11362.5 {}
L 4 1762.5 -11367.5 1777.5 -11362.5 {}
L 4 1762.5 -11367.5 1777.5 -11372.5 {}
L 4 1762.5 -11377.5 1777.5 -11372.5 {}
L 4 1762.5 -11377.5 1777.5 -11382.5 {}
L 4 1762.5 -11387.5 1777.5 -11382.5 {}
L 4 1762.5 -11387.5 1770 -11390 {}
L 4 1770 -11400 1770 -11390 {}
L 4 1772.5 -11392.5 1777.5 -11392.5 {}
L 4 1775 -11395 1775 -11390 {}
L 4 1860 -11275 1860 -11250 {}
L 4 1860 -11310 1860 -11285 {}
L 4 1850 -11285 1870 -11285 {}
L 4 1850 -11275 1870 -11275 {}
L 4 1862.5 -11302.5 1867.5 -11302.5 {}
L 4 1865 -11305 1865 -11300 {}
L 4 1532.5 -11242.5 1537.5 -11242.5 {}
L 4 1535 -11245 1535 -11240 {}
L 4 1530 -11250 1530 -11190 {}
L 4 1640 -11170 1640 -11157.5 {}
L 4 1635 -11157.5 1645 -11157.5 {}
L 4 1640 -11152.5 1645 -11157.5 {}
L 4 1635 -11157.5 1640 -11152.5 {}
L 4 1640 -11450 1640 -11430 {}
L 4 1630 -11450 1650 -11450 {}
L 4 2245 -11310 2245 -11250 {}
L 4 2245 -11300 2260 -11300 {}
L 4 2260 -11310 2260 -11300 {}
L 4 2245 -11260 2260 -11260 {}
L 4 2260 -11260 2260 -11250 {}
L 4 2235 -11295 2235 -11265 {}
L 4 2235 -11280 2235 -11275 {}
L 4 2220 -11280 2227.5 -11280 {}
L 4 2220 -11280 2235 -11280 {}
L 4 2250 -11280 2260 -11280 {}
L 4 2245 -11285 2250 -11280 {}
L 4 2245 -11275 2250 -11280 {}
L 4 2260 -11350 2260 -11340 {}
L 4 2260 -11350 2267.5 -11352.5 {}
L 4 2252.5 -11357.5 2267.5 -11352.5 {}
L 4 2252.5 -11357.5 2267.5 -11362.5 {}
L 4 2252.5 -11367.5 2267.5 -11362.5 {}
L 4 2252.5 -11367.5 2267.5 -11372.5 {}
L 4 2252.5 -11377.5 2267.5 -11372.5 {}
L 4 2252.5 -11377.5 2267.5 -11382.5 {}
L 4 2252.5 -11387.5 2267.5 -11382.5 {}
L 4 2252.5 -11387.5 2260 -11390 {}
L 4 2260 -11400 2260 -11390 {}
L 4 2262.5 -11392.5 2267.5 -11392.5 {}
L 4 2265 -11395 2265 -11390 {}
L 4 2350 -11275 2350 -11250 {}
L 4 2350 -11310 2350 -11285 {}
L 4 2340 -11285 2360 -11285 {}
L 4 2340 -11275 2360 -11275 {}
L 4 2352.5 -11302.5 2357.5 -11302.5 {}
L 4 2355 -11305 2355 -11300 {}
L 4 2022.5 -11242.5 2027.5 -11242.5 {}
L 4 2025 -11245 2025 -11240 {}
L 4 2020 -11250 2020 -11190 {}
L 4 2130 -11170 2130 -11157.5 {}
L 4 2125 -11157.5 2135 -11157.5 {}
L 4 2130 -11152.5 2135 -11157.5 {}
L 4 2125 -11157.5 2130 -11152.5 {}
L 4 2130 -11450 2130 -11430 {}
L 4 2120 -11450 2140 -11450 {}
L 4 420 -9625 420 -9600 {}
L 4 420 -9660 420 -9635 {}
L 4 410 -9635 430 -9635 {}
L 4 410 -9625 430 -9625 {}
L 4 422.5 -9652.5 427.5 -9652.5 {}
L 4 425 -9655 425 -9650 {}
L 4 620 -9625 620 -9600 {}
L 4 620 -9660 620 -9635 {}
L 4 610 -9635 630 -9635 {}
L 4 610 -9625 630 -9625 {}
L 4 622.5 -9652.5 627.5 -9652.5 {}
L 4 625 -9655 625 -9650 {}
L 4 860 -9625 860 -9600 {}
L 4 860 -9660 860 -9635 {}
L 4 850 -9635 870 -9635 {}
L 4 850 -9625 870 -9625 {}
L 4 862.5 -9652.5 867.5 -9652.5 {}
L 4 865 -9655 865 -9650 {}
L 4 1150 -9625 1150 -9600 {}
L 4 1150 -9660 1150 -9635 {}
L 4 1140 -9635 1160 -9635 {}
L 4 1140 -9625 1160 -9625 {}
L 4 1152.5 -9652.5 1157.5 -9652.5 {}
L 4 1155 -9655 1155 -9650 {}
L 4 1380 -9625 1380 -9600 {}
L 4 1380 -9660 1380 -9635 {}
L 4 1370 -9635 1390 -9635 {}
L 4 1370 -9625 1390 -9625 {}
L 4 1382.5 -9652.5 1387.5 -9652.5 {}
L 4 1385 -9655 1385 -9650 {}
L 4 1670 -9625 1670 -9600 {}
L 4 1670 -9660 1670 -9635 {}
L 4 1660 -9635 1680 -9635 {}
L 4 1660 -9625 1680 -9625 {}
L 4 1672.5 -9652.5 1677.5 -9652.5 {}
L 4 1675 -9655 1675 -9650 {}
L 4 1910 -9625 1910 -9600 {}
L 4 1910 -9660 1910 -9635 {}
L 4 1900 -9635 1920 -9635 {}
L 4 1900 -9625 1920 -9625 {}
L 4 1912.5 -9652.5 1917.5 -9652.5 {}
L 4 1915 -9655 1915 -9650 {}
L 4 2210 -9625 2210 -9600 {}
L 4 2210 -9660 2210 -9635 {}
L 4 2200 -9635 2220 -9635 {}
L 4 2200 -9625 2220 -9625 {}
L 4 2212.5 -9652.5 2217.5 -9652.5 {}
L 4 2215 -9655 2215 -9650 {}
L 4 2360 -9610 2360 -9600 {}
L 4 2360 -9610 2367.5 -9612.5 {}
L 4 2352.5 -9617.5 2367.5 -9612.5 {}
L 4 2352.5 -9617.5 2367.5 -9622.5 {}
L 4 2352.5 -9627.5 2367.5 -9622.5 {}
L 4 2352.5 -9627.5 2367.5 -9632.5 {}
L 4 2352.5 -9637.5 2367.5 -9632.5 {}
L 4 2352.5 -9637.5 2367.5 -9642.5 {}
L 4 2352.5 -9647.5 2367.5 -9642.5 {}
L 4 2352.5 -9647.5 2360 -9650 {}
L 4 2360 -9660 2360 -9650 {}
L 4 2362.5 -9652.5 2367.5 -9652.5 {}
L 4 2365 -9655 2365 -9650 {}
L 4 2420 -9625 2420 -9600 {}
L 4 2420 -9660 2420 -9635 {}
L 4 2410 -9635 2430 -9635 {}
L 4 2410 -9625 2430 -9625 {}
L 4 2422.5 -9652.5 2427.5 -9652.5 {}
L 4 2425 -9655 2425 -9650 {}
L 4 1120 -8550 1120 -8490 {}
L 4 1530 -1700 1650 -1700 {}
L 4 1530 -1620 1650 -1620 {}
L 4 1530 -1700 1530 -1620 {}
L 4 1650 -1700 1650 -1620 {}
L 4 1650 -1690 1670 -1690 {}
L 4 1510 -1690 1530 -1690 {}
L 4 1510 -1670 1530 -1670 {}
L 4 1510 -1650 1530 -1650 {}
L 4 1510 -1630 1530 -1630 {}
L 4 2060 -1700 2180 -1700 {}
L 4 2060 -1620 2180 -1620 {}
L 4 2060 -1700 2060 -1620 {}
L 4 2180 -1700 2180 -1620 {}
L 4 2180 -1690 2200 -1690 {}
L 4 2040 -1690 2060 -1690 {}
L 4 2040 -1670 2060 -1670 {}
L 4 2040 -1650 2060 -1650 {}
L 4 2040 -1630 2060 -1630 {}
L 4 2670 -13580 2670 -13560 {}
L 4 2650 -13580 2670 -13580 {}
L 4 525 -1050 525 -990 {}
L 4 525 -1000 540 -1000 {}
L 4 540 -1000 540 -990 {}
L 4 525 -1040 540 -1040 {}
L 4 540 -1050 540 -1040 {}
L 4 515 -1035 515 -1005 {}
L 4 515 -1025 515 -1020 {}
L 4 512.5 -1025 515 -1022.5 {}
L 4 510 -1025 512.5 -1025 {}
L 4 507.5 -1022.5 510 -1025 {}
L 4 507.5 -1022.5 507.5 -1017.5 {}
L 4 507.5 -1017.5 510 -1015 {}
L 4 510 -1015 512.5 -1015 {}
L 4 512.5 -1015 515 -1017.5 {}
L 4 500 -1020 507.5 -1020 {}
L 4 530 -1020 540 -1020 {}
L 4 525 -1025 530 -1020 {}
L 4 525 -1015 530 -1020 {}
L 4 655 -1050 655 -990 {}
L 4 655 -1000 670 -1000 {}
L 4 670 -1000 670 -990 {}
L 4 655 -1040 670 -1040 {}
L 4 670 -1050 670 -1040 {}
L 4 645 -1035 645 -1005 {}
L 4 645 -1025 645 -1020 {}
L 4 642.5 -1025 645 -1022.5 {}
L 4 640 -1025 642.5 -1025 {}
L 4 637.5 -1022.5 640 -1025 {}
L 4 637.5 -1022.5 637.5 -1017.5 {}
L 4 637.5 -1017.5 640 -1015 {}
L 4 640 -1015 642.5 -1015 {}
L 4 642.5 -1015 645 -1017.5 {}
L 4 630 -1020 637.5 -1020 {}
L 4 660 -1020 670 -1020 {}
L 4 655 -1025 660 -1020 {}
L 4 655 -1015 660 -1020 {}
L 4 525 -850 525 -790 {}
L 4 525 -840 540 -840 {}
L 4 540 -850 540 -840 {}
L 4 525 -800 540 -800 {}
L 4 540 -800 540 -790 {}
L 4 515 -835 515 -805 {}
L 4 515 -820 515 -815 {}
L 4 500 -820 507.5 -820 {}
L 4 500 -820 515 -820 {}
L 4 530 -820 540 -820 {}
L 4 525 -825 530 -820 {}
L 4 525 -815 530 -820 {}
L 4 525 -770 525 -710 {}
L 4 525 -760 540 -760 {}
L 4 540 -770 540 -760 {}
L 4 525 -720 540 -720 {}
L 4 540 -720 540 -710 {}
L 4 515 -755 515 -725 {}
L 4 515 -740 515 -735 {}
L 4 500 -740 507.5 -740 {}
L 4 500 -740 515 -740 {}
L 4 530 -740 540 -740 {}
L 4 525 -745 530 -740 {}
L 4 525 -735 530 -740 {}
L 4 2225 -1050 2225 -990 {}
L 4 2225 -1000 2240 -1000 {}
L 4 2240 -1000 2240 -990 {}
L 4 2225 -1040 2240 -1040 {}
L 4 2240 -1050 2240 -1040 {}
L 4 2215 -1035 2215 -1005 {}
L 4 2215 -1025 2215 -1020 {}
L 4 2212.5 -1025 2215 -1022.5 {}
L 4 2210 -1025 2212.5 -1025 {}
L 4 2207.5 -1022.5 2210 -1025 {}
L 4 2207.5 -1022.5 2207.5 -1017.5 {}
L 4 2207.5 -1017.5 2210 -1015 {}
L 4 2210 -1015 2212.5 -1015 {}
L 4 2212.5 -1015 2215 -1017.5 {}
L 4 2200 -1020 2207.5 -1020 {}
L 4 2230 -1020 2240 -1020 {}
L 4 2225 -1025 2230 -1020 {}
L 4 2225 -1015 2230 -1020 {}
L 4 2355 -1050 2355 -990 {}
L 4 2355 -1000 2370 -1000 {}
L 4 2370 -1000 2370 -990 {}
L 4 2355 -1040 2370 -1040 {}
L 4 2370 -1050 2370 -1040 {}
L 4 2345 -1035 2345 -1005 {}
L 4 2345 -1025 2345 -1020 {}
L 4 2342.5 -1025 2345 -1022.5 {}
L 4 2340 -1025 2342.5 -1025 {}
L 4 2337.5 -1022.5 2340 -1025 {}
L 4 2337.5 -1022.5 2337.5 -1017.5 {}
L 4 2337.5 -1017.5 2340 -1015 {}
L 4 2340 -1015 2342.5 -1015 {}
L 4 2342.5 -1015 2345 -1017.5 {}
L 4 2330 -1020 2337.5 -1020 {}
L 4 2360 -1020 2370 -1020 {}
L 4 2355 -1025 2360 -1020 {}
L 4 2355 -1015 2360 -1020 {}
L 4 2225 -850 2225 -790 {}
L 4 2225 -840 2240 -840 {}
L 4 2240 -850 2240 -840 {}
L 4 2225 -800 2240 -800 {}
L 4 2240 -800 2240 -790 {}
L 4 2215 -835 2215 -805 {}
L 4 2215 -820 2215 -815 {}
L 4 2200 -820 2207.5 -820 {}
L 4 2200 -820 2215 -820 {}
L 4 2230 -820 2240 -820 {}
L 4 2225 -825 2230 -820 {}
L 4 2225 -815 2230 -820 {}
L 4 2225 -770 2225 -710 {}
L 4 2225 -760 2240 -760 {}
L 4 2240 -770 2240 -760 {}
L 4 2225 -720 2240 -720 {}
L 4 2240 -720 2240 -710 {}
L 4 2215 -755 2215 -725 {}
L 4 2215 -740 2215 -735 {}
L 4 2200 -740 2207.5 -740 {}
L 4 2200 -740 2215 -740 {}
L 4 2230 -740 2240 -740 {}
L 4 2225 -745 2230 -740 {}
L 4 2225 -735 2230 -740 {}
L 4 800 -540 900 -600 {}
L 4 1060 -540 1160 -600 {}
L 4 1160 -600 1190 -480 {}
L 4 1370 -540 1470 -600 {}
L 4 1470 -600 1500 -480 {}
L 4 1370 -540 1500 -480 {}
L 5 1105 -12530 1110 -12530 {}
L 5 1410 -12560 1418.75 -12560 {}
L 5 1645 -12530 1650 -12530 {}
L 5 1950 -12560 1958.75 -12560 {}
L 5 575 -12530 580 -12530 {}
L 5 880 -12560 888.75 -12560 {}
L 5 575 -12070 580 -12070 {}
L 5 880 -12100 888.75 -12100 {}
L 5 1115 -12070 1120 -12070 {}
L 5 1420 -12100 1428.75 -12100 {}
L 5 575 -7640 580 -7640 {}
L 5 880 -7670 888.75 -7670 {}
L 5 1115 -7640 1120 -7640 {}
L 5 1420 -7670 1428.75 -7670 {}
L 5 575 -7240 580 -7240 {}
L 5 880 -7270 888.75 -7270 {}
L 5 1115 -7240 1120 -7240 {}
L 5 1420 -7270 1428.75 -7270 {}
L 5 575 -6800 580 -6800 {}
L 5 1765 -6800 1770 -6800 {}
L 5 1135 -6800 1140 -6800 {}
L 5 1105 -11700 1110 -11700 {}
L 5 1410 -11730 1418.75 -11730 {}
L 5 575 -11700 580 -11700 {}
L 5 880 -11730 888.75 -11730 {}
L 5 1605 -11700 1610 -11700 {}
L 5 1910 -11730 1918.75 -11730 {}
L 5 1645 -13000 1650 -13000 {}
L 5 1950 -13030 1958.75 -13030 {}
L 5 520 -13000 525 -13000 {}
L 5 825 -13030 833.75 -13030 {}
L 5 2105 -13000 2110 -13000 {}
L 5 2410 -13030 2418.75 -13030 {}
L 5 595 -10860 600 -10860 {}
L 5 900 -10890 908.75 -10890 {}
L 5 1135 -10860 1140 -10860 {}
L 5 1440 -10890 1448.75 -10890 {}
L 5 2265 -10860 2270 -10860 {}
L 5 2570 -10890 2578.75 -10890 {}
L 5 1105 -13000 1110 -13000 {}
L 5 1410 -13030 1418.75 -13030 {}
L 5 655 -2330 660 -2330 {}
L 5 960 -2360 968.75 -2360 {}
L 5 1255 -2330 1260 -2330 {}
L 5 1560 -2360 1568.75 -2360 {}
L 5 1865 -2330 1870 -2330 {}
L 5 2170 -2360 2178.75 -2360 {}
L 5 595 -6390 600 -6390 {}
L 5 900 -6420 908.75 -6420 {}
L 5 1155 -6390 1160 -6390 {}
L 5 1460 -6420 1468.75 -6420 {}
L 5 540 -11280 545 -11280 {}
L 5 845 -11310 853.75 -11310 {}
L 5 1105 -11280 1110 -11280 {}
L 5 1410 -11310 1418.75 -11310 {}
L 5 1605 -11280 1610 -11280 {}
L 5 1910 -11310 1918.75 -11310 {}
L 5 2095 -11280 2100 -11280 {}
L 5 2400 -11310 2408.75 -11310 {}
L 7 600 -8190 620 -8190 {dash=3}
L 7 610 -8200 610 -8180 {dash=3}
L 7 600 -8060 620 -8060 {dash=3}
L 7 610 -8070 610 -8050 {dash=3}
L 7 600 -7950 620 -7950 {dash=3}
L 7 610 -7960 610 -7940 {dash=3}
L 7 920 -8190 940 -8190 {dash=3}
L 7 930 -8200 930 -8180 {dash=3}
L 7 920 -8060 940 -8060 {dash=3}
L 7 930 -8070 930 -8050 {dash=3}
L 7 920 -7950 940 -7950 {dash=3}
L 7 930 -7960 930 -7940 {dash=3}
L 7 1510 -2100 1510 -1780 {dash=3}
L 7 1260 -1950 1780 -1950 {dash=3}
L 9 0 -7090 2670 -7090 {dash=4}
L 9 0 -7480 2670 -7480 {dash=4}
L 9 0 -11480 2670 -11480 {dash=4}
L 9 0 -12310 2670 -12310 {dash=4}
L 9 0 -11920 2670 -11920 {dash=4}
L 9 0 -12760 2670 -12760 {dash=4}
L 9 0 -5800 2670 -5800 {dash=4}
L 9 0 -6180 2670 -6180 {dash=4}
L 9 0 -6610 2670 -6610 {dash=4}
L 9 0 -5380 2670 -5380 {dash=4}
L 9 0 -5000 2670 -5000 {dash=4}
L 9 0 -2970 2670 -2970 {dash=4}
L 9 0 -4680 2670 -4680 {dash=4}
L 9 0 -3740 2670 -3740 {dash=4}
L 9 0 -3370 2670 -3370 {dash=4}
L 9 0 -2570 2670 -2570 {dash=4}
L 9 0 -2140 2670 -2140 {dash=4}
L 9 0 -4450 2670 -4450 {dash=4}
L 9 0 -4080 2670 -4080 {dash=4}
L 9 0 -9860 2670 -9860 {dash=4}
L 9 0 -11130 2670 -11130 {dash=4}
L 9 0 -9470 2670 -9470 {dash=4}
L 9 0 -9080 2670 -9080 {dash=4}
L 9 0 -8660 2670 -8660 {dash=4}
L 9 0 -8270 2670 -8270 {dash=4}
L 9 0 -7870 2670 -7870 {dash=4}
L 9 490 -9790 490 -9540 {dash=4}
L 9 710 -9790 710 -9540 {dash=4}
L 9 1000 -9790 1000 -9540 {dash=4}
L 9 1240 -9790 1240 -9540 {dash=4}
L 9 1520 -9790 1520 -9540 {dash=4}
L 9 1760 -9790 1760 -9540 {dash=4}
L 9 2070 -9790 2070 -9540 {dash=4}
L 9 2310 -9790 2310 -9540 {dash=4}
L 9 980 -11425 980 -11175 {dash=4}
L 9 1490 -11425 1490 -11175 {dash=4}
L 9 1965 -11425 1965 -11175 {dash=4}
L 9 975 -11835 975 -11585 {dash=4}
L 9 1460 -11835 1460 -11585 {dash=4}
L 9 930 -13125 930 -12875 {dash=4}
L 9 1475 -13125 1475 -12875 {dash=4}
L 9 1990 -13125 1990 -12875 {dash=4}
L 9 975 -12675 975 -12425 {dash=4}
L 9 1480 -12675 1480 -12425 {dash=4}
L 9 960 -12235 960 -11985 {dash=4}
L 9 970 -11015 970 -10765 {dash=4}
L 9 1545 -11015 1545 -10765 {dash=4}
L 9 2070 -11015 2070 -10765 {dash=4}
L 9 920 -9010 920 -8760 {dash=4}
L 9 1435 -9010 1435 -8760 {dash=4}
L 9 920 -8595 920 -8345 {dash=4}
L 9 1435 -8595 1435 -8345 {dash=4}
L 9 765 -8200 765 -7950 {dash=4}
L 9 960 -7800 960 -7550 {dash=4}
L 9 955 -7420 955 -7170 {dash=4}
L 9 1000 -6980 1000 -6730 {dash=4}
L 9 1610 -6980 1610 -6730 {dash=4}
L 9 990 -6540 990 -6290 {dash=4}
L 9 1080 -6090 1080 -5840 {dash=4}
L 9 1650 -6090 1650 -5840 {dash=4}
L 9 1080 -5700 1080 -5450 {dash=4}
L 9 1650 -5700 1650 -5450 {dash=4}
L 9 2230 -5700 2230 -5450 {dash=4}
L 9 1080 -5320 1080 -5070 {dash=4}
L 9 1680 -5320 1680 -5070 {dash=4}
L 9 2230 -5320 2230 -5070 {dash=4}
L 9 960 -4970 960 -4720 {dash=4}
L 9 1480 -4960 1480 -4710 {dash=4}
L 9 970 -4610 970 -4500 {dash=4}
L 9 1610 -4610 1610 -4500 {dash=4}
L 9 2130 -4610 2130 -4500 {dash=4}
L 9 1000 -4370 1000 -4120 {dash=4}
L 9 1620 -4370 1620 -4120 {dash=4}
L 9 2160 -4370 2160 -4120 {dash=4}
L 9 990 -4010 990 -3760 {dash=4}
L 9 1580 -4010 1580 -3760 {dash=4}
L 9 2210 -4010 2210 -3760 {dash=4}
L 9 1000 -3690 1000 -3440 {dash=4}
L 9 1570 -3690 1570 -3440 {dash=4}
L 9 1070 -3280 1070 -3030 {dash=4}
L 9 1680 -3280 1680 -3030 {dash=4}
L 9 1060 -2890 1060 -2640 {dash=4}
L 9 1660 -2890 1660 -2640 {dash=4}
L 9 1060 -2510 1060 -2260 {dash=4}
L 9 1720 -2500 1720 -2250 {dash=4}
L 9 0 -1740 2670 -1740 {dash=4}
L 9 1030 -2070 1030 -1820 {dash=4}
L 9 1970 -2070 1970 -1820 {dash=4}
L 9 1260 -1700 1260 -1450 {dash=4}
L 9 1830 -1700 1830 -1450 {dash=4}
L 9 0 -1430 2670 -1430 {dash=4}
L 9 0 -1100 2670 -1100 {dash=4}
L 9 790 -1390 790 -1140 {dash=4}
L 9 1150 -1390 1150 -1140 {dash=4}
L 9 1500 -1390 1500 -1140 {dash=4}
L 9 1810 -1390 1810 -1140 {dash=4}
L 9 790 -1700 790 -1450 {dash=4}
L 9 750 -1030 750 -780 {dash=4}
L 9 1270 -1030 1270 -780 {dash=4}
L 9 2090 -1030 2090 -780 {dash=4}
L 9 0 -660 2670 -660 {dash=4}
L 9 0 -330 2670 -330 {dash=4}
L 9 0 0 2670 0 {dash=4}
L 9 740 -630 740 -380 {dash=4}
L 9 1020 -630 1020 -380 {dash=4}
L 9 1310 -630 1310 -380 {dash=4}
L 9 1550 -630 1550 -380 {dash=4}
L 9 1780 -630 1780 -380 {dash=4}
L 9 2140 -630 2140 -380 {dash=4}
L 9 940 -300 940 -50 {dash=4}
L 9 1300 -300 1300 -50 {dash=4}
L 9 1550 -300 1550 -50 {dash=4}
L 9 1880 -300 1880 -50 {dash=4}
L 9 0 -10710 2670 -10710 {dash=4}
L 9 880 -10605 880 -10355 {dash=4}
L 9 1370 -10615 1370 -10365 {dash=4}
L 9 1860 -10615 1860 -10365 {dash=4}
L 9 0 -10300 2670 -10300 {dash=4}
L 9 880 -10195 880 -9945 {dash=4}
L 9 1530 -10205 1530 -9955 {dash=4}
L 9 1860 -10205 1860 -9955 {dash=4}
B 1 1790 -10920 1820 -10770 {}
B 2 660 -12700 860 -12380 {}
B 2 1267.5 -12562.5 1272.5 -12557.5 {name=d dir=inout}
B 2 1227.5 -12532.5 1232.5 -12527.5 {name=g dir=in}
B 2 1267.5 -12502.5 1272.5 -12497.5 {name=s dir=inout}
B 2 1267.5 -12532.5 1272.5 -12527.5 {name=b dir=in}
B 2 1267.5 -12652.5 1272.5 -12647.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -12592.5 1272.5 -12587.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -12562.5 1362.5 -12557.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -12502.5 1362.5 -12497.5 {name=m dir=inout pinnumber=2}
B 2 2047.5 -12572.5 2052.5 -12567.5 {name=d dir=inout}
B 2 2007.5 -12542.5 2012.5 -12537.5 {name=g dir=in}
B 2 2047.5 -12512.5 2052.5 -12507.5 {name=s dir=inout}
B 2 2047.5 -12542.5 2052.5 -12537.5 {name=b dir=in}
B 2 2047.5 -12662.5 2052.5 -12657.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2047.5 -12602.5 2052.5 -12597.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2137.5 -12572.5 2142.5 -12567.5 {name=p dir=inout pinnumber=1}
B 2 2137.5 -12512.5 2142.5 -12507.5 {name=m dir=inout pinnumber=2}
B 2 1357.5 -12192.5 1362.5 -12187.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -12132.5 1362.5 -12127.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -7762.5 1362.5 -7757.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -7702.5 1362.5 -7697.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -7362.5 1362.5 -7357.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -7302.5 1362.5 -7297.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 660 -6980 900 -6660 {}
B 2 737.5 -12562.5 742.5 -12557.5 {name=d dir=inout}
B 2 737.5 -12502.5 742.5 -12497.5 {name=s dir=inout}
B 2 737.5 -12532.5 742.5 -12527.5 {name=b dir=in}
B 2 737.5 -12652.5 742.5 -12647.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -12592.5 742.5 -12587.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -12562.5 832.5 -12557.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -12502.5 832.5 -12497.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -6832.5 742.5 -6827.5 {name=d dir=inout}
B 2 737.5 -6772.5 742.5 -6767.5 {name=s dir=inout}
B 2 737.5 -6802.5 742.5 -6797.5 {name=b dir=in}
B 2 737.5 -6922.5 742.5 -6917.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -6862.5 742.5 -6857.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -6832.5 832.5 -6827.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -6772.5 832.5 -6767.5 {name=m dir=inout pinnumber=2}
B 2 878.75 -6831.25 881.25 -6828.75 {name=p dir=in}
B 2 1297.5 -6832.5 1302.5 -6827.5 {name=d dir=inout}
B 2 1257.5 -6802.5 1262.5 -6797.5 {name=g dir=in}
B 2 1297.5 -6772.5 1302.5 -6767.5 {name=s dir=inout}
B 2 1297.5 -6802.5 1302.5 -6797.5 {name=b dir=in}
B 2 1297.5 -6922.5 1302.5 -6917.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1297.5 -6862.5 1302.5 -6857.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1387.5 -6832.5 1392.5 -6827.5 {name=p dir=inout pinnumber=1}
B 2 1387.5 -6772.5 1392.5 -6767.5 {name=m dir=inout pinnumber=2}
B 2 1438.75 -6831.25 1441.25 -6828.75 {name=p dir=in}
B 2 2117.5 -6832.5 2122.5 -6827.5 {name=d dir=inout}
B 2 2077.5 -6802.5 2082.5 -6797.5 {name=g dir=in}
B 2 2117.5 -6772.5 2122.5 -6767.5 {name=s dir=inout}
B 2 2117.5 -6802.5 2122.5 -6797.5 {name=b dir=in}
B 2 2117.5 -6922.5 2122.5 -6917.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2117.5 -6862.5 2122.5 -6857.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2207.5 -6832.5 2212.5 -6827.5 {name=p dir=inout pinnumber=1}
B 2 2207.5 -6772.5 2212.5 -6767.5 {name=m dir=inout pinnumber=2}
B 2 2258.75 -6831.25 2261.25 -6828.75 {name=p dir=in}
B 2 660 -11870 860 -11550 {}
B 2 1267.5 -11732.5 1272.5 -11727.5 {name=d dir=inout}
B 2 1227.5 -11702.5 1232.5 -11697.5 {name=g dir=in}
B 2 1267.5 -11672.5 1272.5 -11667.5 {name=s dir=inout}
B 2 1267.5 -11702.5 1272.5 -11697.5 {name=b dir=in}
B 2 1267.5 -11822.5 1272.5 -11817.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -11762.5 1272.5 -11757.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -11732.5 1362.5 -11727.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -11672.5 1362.5 -11667.5 {name=m dir=inout pinnumber=2}
B 2 2047.5 -11742.5 2052.5 -11737.5 {name=d dir=inout}
B 2 2007.5 -11712.5 2012.5 -11707.5 {name=g dir=in}
B 2 2047.5 -11682.5 2052.5 -11677.5 {name=s dir=inout}
B 2 2047.5 -11712.5 2052.5 -11707.5 {name=b dir=in}
B 2 2047.5 -11832.5 2052.5 -11827.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2047.5 -11772.5 2052.5 -11767.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2137.5 -11742.5 2142.5 -11737.5 {name=p dir=inout pinnumber=1}
B 2 2137.5 -11682.5 2142.5 -11677.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -11732.5 742.5 -11727.5 {name=d dir=inout}
B 2 737.5 -11672.5 742.5 -11667.5 {name=s dir=inout}
B 2 737.5 -11702.5 742.5 -11697.5 {name=b dir=in}
B 2 737.5 -11822.5 742.5 -11817.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -11762.5 742.5 -11757.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -11732.5 832.5 -11727.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -11672.5 832.5 -11667.5 {name=m dir=inout pinnumber=2}
B 2 605 -13170 805 -12850 {}
B 2 1807.5 -13032.5 1812.5 -13027.5 {name=d dir=inout}
B 2 1767.5 -13002.5 1772.5 -12997.5 {name=g dir=in}
B 2 1807.5 -12972.5 1812.5 -12967.5 {name=s dir=inout}
B 2 1807.5 -13002.5 1812.5 -12997.5 {name=b dir=in}
B 2 1807.5 -13122.5 1812.5 -13117.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1807.5 -13062.5 1812.5 -13057.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -13032.5 1902.5 -13027.5 {name=p dir=inout pinnumber=1}
B 2 1897.5 -12972.5 1902.5 -12967.5 {name=m dir=inout pinnumber=2}
B 2 682.5 -13032.5 687.5 -13027.5 {name=d dir=inout}
B 2 682.5 -12972.5 687.5 -12967.5 {name=s dir=inout}
B 2 682.5 -13002.5 687.5 -12997.5 {name=b dir=in}
B 2 682.5 -13122.5 687.5 -13117.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 682.5 -13062.5 687.5 -13057.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 772.5 -13032.5 777.5 -13027.5 {name=p dir=inout pinnumber=1}
B 2 772.5 -12972.5 777.5 -12967.5 {name=m dir=inout pinnumber=2}
B 2 1530 -13160 1610 -12880 {}
B 2 1567.5 -12972.5 1572.5 -12967.5 {name=p dir=inout}
B 2 1567.5 -12912.5 1572.5 -12907.5 {name=m dir=inout}
B 2 2267.5 -13032.5 2272.5 -13027.5 {name=d dir=inout}
B 2 2227.5 -13002.5 2232.5 -12997.5 {name=g dir=in}
B 2 2267.5 -12972.5 2272.5 -12967.5 {name=s dir=inout}
B 2 2267.5 -13002.5 2272.5 -12997.5 {name=b dir=in}
B 2 2267.5 -13122.5 2272.5 -13117.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2267.5 -13062.5 2272.5 -13057.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2027.5 -12972.5 2032.5 -12967.5 {name=p dir=inout}
B 2 2027.5 -12912.5 2032.5 -12907.5 {name=m dir=inout}
B 2 2320 -13050 2390 -12870 {}
B 2 1670 -10950 1820 -10920 {}
B 2 1357.5 -5962.5 1362.5 -5957.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -5902.5 1362.5 -5897.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1210 -5290 1500 -5220 {}
B 2 1210 -3210 1500 -3130 {}
B 2 1247.5 -3202.5 1252.5 -3197.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1247.5 -3142.5 1252.5 -3137.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -3202.5 1362.5 -3197.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -3142.5 1362.5 -3137.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1467.5 -3202.5 1472.5 -3197.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1467.5 -3142.5 1472.5 -3137.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1787.5 -3252.5 1792.5 -3247.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1787.5 -3192.5 1792.5 -3187.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -3252.5 1902.5 -3247.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1897.5 -3192.5 1902.5 -3187.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2007.5 -3252.5 2012.5 -3247.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2007.5 -3192.5 2012.5 -3187.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 647.5 -4872.5 652.5 -4867.5 {name=d dir=inout}
B 2 607.5 -4842.5 612.5 -4837.5 {name=g dir=in}
B 2 647.5 -4812.5 652.5 -4807.5 {name=s dir=inout}
B 2 647.5 -4842.5 652.5 -4837.5 {name=b dir=in}
B 2 1227.5 -4872.5 1232.5 -4867.5 {name=d dir=inout}
B 2 1187.5 -4842.5 1192.5 -4837.5 {name=g dir=in}
B 2 1227.5 -4812.5 1232.5 -4807.5 {name=s dir=inout}
B 2 1227.5 -4842.5 1232.5 -4837.5 {name=b dir=in}
B 2 1267.5 -13032.5 1272.5 -13027.5 {name=d dir=inout}
B 2 1227.5 -13002.5 1232.5 -12997.5 {name=g dir=in}
B 2 1267.5 -12972.5 1272.5 -12967.5 {name=s dir=inout}
B 2 1267.5 -13002.5 1272.5 -12997.5 {name=b dir=in}
B 2 1267.5 -13122.5 1272.5 -13117.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -13062.5 1272.5 -13057.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -13032.5 1362.5 -13027.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -12972.5 1362.5 -12967.5 {name=m dir=inout pinnumber=2}
B 2 1210 -2830 1500 -2750 {}
B 2 1247.5 -2822.5 1252.5 -2817.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1247.5 -2762.5 1252.5 -2757.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -2822.5 1362.5 -2817.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -2762.5 1362.5 -2757.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1467.5 -2822.5 1472.5 -2817.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1467.5 -2762.5 1472.5 -2757.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1787.5 -2872.5 1792.5 -2867.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1787.5 -2812.5 1792.5 -2807.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -2872.5 1902.5 -2867.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1897.5 -2812.5 1902.5 -2807.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2007.5 -2872.5 2012.5 -2867.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2007.5 -2812.5 2012.5 -2807.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 677.5 -3642.5 682.5 -3637.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 677.5 -3582.5 682.5 -3577.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 797.5 -3642.5 802.5 -3637.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1217.5 -3642.5 1222.5 -3637.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1217.5 -3582.5 1222.5 -3577.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1337.5 -3642.5 1342.5 -3637.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1337.5 -3582.5 1342.5 -3577.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1507.5 -2362.5 1512.5 -2357.5 {name=p dir=inout pinnumber=1}
B 2 1507.5 -2302.5 1512.5 -2297.5 {name=m dir=inout pinnumber=2}
B 2 2427.5 -2542.5 2432.5 -2537.5 {name=p dir=inout pinnumber=1}
B 2 2427.5 -2482.5 2432.5 -2477.5 {name=m dir=inout pinnumber=2}
B 2 820 -6440 870 -6260 {}
B 2 847.5 -6422.5 852.5 -6417.5 {name=p dir=inout pinnumber=1}
B 2 847.5 -6362.5 852.5 -6357.5 {name=m dir=inout pinnumber=2}
B 2 1707.5 -6422.5 1712.5 -6417.5 {name=p dir=inout pinnumber=1}
B 2 1707.5 -6362.5 1712.5 -6357.5 {name=m dir=inout pinnumber=2}
B 2 2467.5 -6422.5 2472.5 -6417.5 {name=p dir=inout pinnumber=1}
B 2 2467.5 -6362.5 2472.5 -6357.5 {name=m dir=inout pinnumber=2}
B 2 527.5 -9412.5 532.5 -9407.5 {name=d dir=inout}
B 2 487.5 -9382.5 492.5 -9377.5 {name=g dir=in}
B 2 527.5 -9352.5 532.5 -9347.5 {name=s dir=inout}
B 2 527.5 -9382.5 532.5 -9377.5 {name=b dir=in}
B 2 458.75 -9381.25 461.25 -9378.75 {name=p dir=out}
B 2 847.5 -9312.5 852.5 -9307.5 {name=d dir=inout}
B 2 817.5 -9352.5 822.5 -9347.5 {name=g dir=in}
B 2 787.5 -9312.5 792.5 -9307.5 {name=s dir=inout}
B 2 817.5 -9312.5 822.5 -9307.5 {name=b dir=in}
B 2 818.75 -9381.25 821.25 -9378.75 {name=p dir=out}
B 2 1097.5 -9282.5 1102.5 -9277.5 {name=d dir=inout}
B 2 1137.5 -9312.5 1142.5 -9307.5 {name=g dir=in}
B 2 1097.5 -9342.5 1102.5 -9337.5 {name=s dir=inout}
B 2 1097.5 -9312.5 1102.5 -9307.5 {name=b dir=in}
B 2 1168.75 -9311.25 1171.25 -9308.75 {name=p dir=out}
B 2 1377.5 -9392.5 1382.5 -9387.5 {name=d dir=inout}
B 2 1407.5 -9352.5 1412.5 -9347.5 {name=g dir=in}
B 2 1437.5 -9392.5 1442.5 -9387.5 {name=s dir=inout}
B 2 1407.5 -9392.5 1412.5 -9387.5 {name=b dir=in}
B 2 1408.75 -9321.25 1411.25 -9318.75 {name=p dir=out}
B 2 1777.5 -9392.5 1782.5 -9387.5 {name=d dir=inout}
B 2 1747.5 -9352.5 1752.5 -9347.5 {name=g dir=in}
B 2 1717.5 -9392.5 1722.5 -9387.5 {name=s dir=inout}
B 2 1747.5 -9392.5 1752.5 -9387.5 {name=b dir=in}
B 2 1748.75 -9321.25 1751.25 -9318.75 {name=p dir=out}
B 2 2107.5 -9322.5 2112.5 -9317.5 {name=d dir=inout}
B 2 2077.5 -9362.5 2082.5 -9357.5 {name=g dir=in}
B 2 2047.5 -9322.5 2052.5 -9317.5 {name=s dir=inout}
B 2 2077.5 -9322.5 2082.5 -9317.5 {name=b dir=in}
B 2 2078.75 -9391.25 2081.25 -9388.75 {name=p dir=out}
B 2 767.5 -8912.5 772.5 -8907.5 {name=d dir=inout}
B 2 727.5 -8882.5 732.5 -8877.5 {name=g dir=in}
B 2 767.5 -8852.5 772.5 -8847.5 {name=s dir=inout}
B 2 767.5 -8882.5 772.5 -8877.5 {name=b dir=in}
B 2 767.5 -9002.5 772.5 -8997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 767.5 -8942.5 772.5 -8937.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 857.5 -8912.5 862.5 -8907.5 {name=p dir=inout pinnumber=1}
B 2 857.5 -8852.5 862.5 -8847.5 {name=m dir=inout pinnumber=2}
B 2 527.5 -8852.5 532.5 -8847.5 {name=p dir=inout}
B 2 527.5 -8792.5 532.5 -8787.5 {name=m dir=inout}
B 2 608.75 -8881.25 611.25 -8878.75 {name=p dir=out}
B 2 637.5 -8772.5 642.5 -8767.5 {name=p dir=inout goto=0}
B 2 637.5 -9032.5 642.5 -9027.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1242.5 -8912.5 1247.5 -8907.5 {name=d dir=inout}
B 2 1202.5 -8882.5 1207.5 -8877.5 {name=g dir=in}
B 2 1242.5 -8852.5 1247.5 -8847.5 {name=s dir=inout}
B 2 1242.5 -8882.5 1247.5 -8877.5 {name=b dir=in}
B 2 1242.5 -9002.5 1247.5 -8997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1242.5 -8942.5 1247.5 -8937.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1332.5 -8912.5 1337.5 -8907.5 {name=p dir=inout pinnumber=1}
B 2 1332.5 -8852.5 1337.5 -8847.5 {name=m dir=inout pinnumber=2}
B 2 1002.5 -8852.5 1007.5 -8847.5 {name=p dir=inout}
B 2 1002.5 -8792.5 1007.5 -8787.5 {name=m dir=inout}
B 2 1083.75 -8881.25 1086.25 -8878.75 {name=p dir=out}
B 2 1112.5 -8772.5 1117.5 -8767.5 {name=p dir=inout goto=0}
B 2 1112.5 -9032.5 1117.5 -9027.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1727.5 -8792.5 1732.5 -8787.5 {name=d dir=inout}
B 2 1697.5 -8832.5 1702.5 -8827.5 {name=g dir=in}
B 2 1667.5 -8792.5 1672.5 -8787.5 {name=s dir=inout}
B 2 1697.5 -8792.5 1702.5 -8787.5 {name=b dir=in}
B 2 1817.5 -8792.5 1822.5 -8787.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1757.5 -8792.5 1762.5 -8787.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1727.5 -8702.5 1732.5 -8697.5 {name=p dir=inout pinnumber=1}
B 2 1667.5 -8702.5 1672.5 -8697.5 {name=m dir=inout pinnumber=2}
B 2 1667.5 -9032.5 1672.5 -9027.5 {name=p dir=inout}
B 2 1607.5 -9032.5 1612.5 -9027.5 {name=m dir=inout}
B 2 1698.75 -8951.25 1701.25 -8948.75 {name=p dir=out}
B 2 1587.5 -8922.5 1592.5 -8917.5 {name=p dir=inout goto=0}
B 2 1847.5 -8922.5 1852.5 -8917.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 767.5 -8482.5 772.5 -8477.5 {name=d dir=inout}
B 2 727.5 -8452.5 732.5 -8447.5 {name=g dir=in}
B 2 767.5 -8422.5 772.5 -8417.5 {name=s dir=inout}
B 2 767.5 -8452.5 772.5 -8447.5 {name=b dir=in}
B 2 767.5 -8572.5 772.5 -8567.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 767.5 -8512.5 772.5 -8507.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 857.5 -8482.5 862.5 -8477.5 {name=p dir=inout pinnumber=1}
B 2 857.5 -8422.5 862.5 -8417.5 {name=m dir=inout pinnumber=2}
B 2 527.5 -8422.5 532.5 -8417.5 {name=p dir=inout}
B 2 527.5 -8362.5 532.5 -8357.5 {name=m dir=inout}
B 2 608.75 -8451.25 611.25 -8448.75 {name=p dir=out}
B 2 637.5 -8342.5 642.5 -8337.5 {name=p dir=inout goto=0}
B 2 637.5 -8602.5 642.5 -8597.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1217.5 -8482.5 1222.5 -8477.5 {name=d dir=inout}
B 2 1177.5 -8452.5 1182.5 -8447.5 {name=g dir=in}
B 2 1217.5 -8422.5 1222.5 -8417.5 {name=s dir=inout}
B 2 1217.5 -8452.5 1222.5 -8447.5 {name=b dir=in}
B 2 1217.5 -8572.5 1222.5 -8567.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1217.5 -8512.5 1222.5 -8507.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1307.5 -8482.5 1312.5 -8477.5 {name=p dir=inout pinnumber=1}
B 2 1307.5 -8422.5 1312.5 -8417.5 {name=m dir=inout pinnumber=2}
B 2 977.5 -8422.5 982.5 -8417.5 {name=p dir=inout}
B 2 977.5 -8362.5 982.5 -8357.5 {name=m dir=inout}
B 2 1058.75 -8451.25 1061.25 -8448.75 {name=p dir=out}
B 2 1087.5 -8342.5 1092.5 -8337.5 {name=p dir=inout goto=0}
B 2 1087.5 -8602.5 1092.5 -8597.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1597.5 -8482.5 1602.5 -8477.5 {name=d dir=inout}
B 2 1637.5 -8452.5 1642.5 -8447.5 {name=g dir=in}
B 2 1597.5 -8422.5 1602.5 -8417.5 {name=s dir=inout}
B 2 1597.5 -8452.5 1602.5 -8447.5 {name=b dir=in}
B 2 1597.5 -8572.5 1602.5 -8567.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1597.5 -8512.5 1602.5 -8507.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1507.5 -8482.5 1512.5 -8477.5 {name=p dir=inout pinnumber=1}
B 2 1507.5 -8422.5 1512.5 -8417.5 {name=m dir=inout pinnumber=2}
B 2 1837.5 -8422.5 1842.5 -8417.5 {name=p dir=inout}
B 2 1837.5 -8362.5 1842.5 -8357.5 {name=m dir=inout}
B 2 1758.75 -8451.25 1761.25 -8448.75 {name=p dir=out}
B 2 1727.5 -8342.5 1732.5 -8337.5 {name=p dir=inout goto=0}
B 2 1727.5 -8602.5 1732.5 -8597.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 607.5 -8222.5 612.5 -8217.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 607.5 -8162.5 612.5 -8157.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 607.5 -8092.5 612.5 -8087.5 {name=p dir=inout pinnumber=1}
B 2 607.5 -8032.5 612.5 -8027.5 {name=m dir=inout pinnumber=2}
B 2 607.5 -7982.5 612.5 -7977.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 607.5 -7922.5 612.5 -7917.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 957.5 -8192.5 962.5 -8187.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 897.5 -8192.5 902.5 -8187.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 957.5 -8062.5 962.5 -8057.5 {name=p dir=inout pinnumber=1}
B 2 897.5 -8062.5 902.5 -8057.5 {name=m dir=inout pinnumber=2}
B 2 957.5 -7952.5 962.5 -7947.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 897.5 -7952.5 902.5 -7947.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1507.5 -1692.5 1512.5 -1687.5 {name=SIG_IN dir=in }
B 2 1507.5 -1672.5 1512.5 -1667.5 {name=VREF dir=in }
B 2 1507.5 -1652.5 1512.5 -1647.5 {name=CK dir=in }
B 2 1507.5 -1632.5 1512.5 -1627.5 {name=RST dir=in }
B 2 1438.75 -1691.25 1441.25 -1688.75 {name=p dir=in}
B 2 1438.75 -1671.25 1441.25 -1668.75 {name=p dir=in}
B 2 1438.75 -1651.25 1441.25 -1648.75 {name=p dir=in}
B 2 1438.75 -1631.25 1441.25 -1628.75 {name=p dir=in}
B 2 2037.5 -1692.5 2042.5 -1687.5 {name=SIG_IN dir=in }
B 2 2037.5 -1672.5 2042.5 -1667.5 {name=VREF dir=in }
B 2 2037.5 -1652.5 2042.5 -1647.5 {name=CK dir=in }
B 2 2037.5 -1632.5 2042.5 -1627.5 {name=RST dir=in }
B 2 2288.75 -1691.25 2291.25 -1688.75 {name=p dir=in}
B 2 1097.5 -1692.5 1102.5 -1687.5 {name=CODE[5:0] dir=out }
B 2 937.5 -1692.5 942.5 -1687.5 {name=SIG_IN dir=in }
B 2 937.5 -1672.5 942.5 -1667.5 {name=VREF dir=in }
B 2 937.5 -1652.5 942.5 -1647.5 {name=CK dir=in }
B 2 937.5 -1632.5 942.5 -1627.5 {name=RST dir=in }
B 2 677.5 -1692.5 682.5 -1687.5 {name=CODE[5:0] dir=out }
B 2 517.5 -1692.5 522.5 -1687.5 {name=SIG_IN dir=in }
B 2 517.5 -1672.5 522.5 -1667.5 {name=VREF dir=in }
B 2 517.5 -1652.5 522.5 -1647.5 {name=CK dir=in }
B 2 517.5 -1632.5 522.5 -1627.5 {name=RST dir=in }
B 2 968.75 -1321.25 971.25 -1318.75 {name=p dir=in}
B 2 1278.75 -1321.25 1281.25 -1318.75 {name=p dir=in}
B 2 1608.75 -1321.25 1611.25 -1318.75 {name=p dir=in}
B 2 1928.75 -1321.25 1931.25 -1318.75 {name=p dir=in}
B 2 907.5 -992.5 912.5 -987.5 {name=d dir=inout}
B 2 867.5 -1022.5 872.5 -1017.5 {name=g dir=in}
B 2 907.5 -1052.5 912.5 -1047.5 {name=s dir=inout}
B 2 907.5 -1022.5 912.5 -1017.5 {name=b dir=in}
B 2 1037.5 -992.5 1042.5 -987.5 {name=d dir=inout}
B 2 997.5 -1022.5 1002.5 -1017.5 {name=g dir=in}
B 2 1037.5 -1052.5 1042.5 -1047.5 {name=s dir=inout}
B 2 1037.5 -1022.5 1042.5 -1017.5 {name=b dir=in}
B 2 907.5 -852.5 912.5 -847.5 {name=d dir=inout}
B 2 867.5 -822.5 872.5 -817.5 {name=g dir=in}
B 2 907.5 -792.5 912.5 -787.5 {name=s dir=inout}
B 2 907.5 -822.5 912.5 -817.5 {name=b dir=in}
B 2 907.5 -772.5 912.5 -767.5 {name=d dir=inout}
B 2 867.5 -742.5 872.5 -737.5 {name=g dir=in}
B 2 907.5 -712.5 912.5 -707.5 {name=s dir=inout}
B 2 907.5 -742.5 912.5 -737.5 {name=b dir=in}
B 2 1290 -890 2043 -715 {flags=image
alpha=0.8
image=/home/schippes/x/1.png
image_data=iVBORw0KGgoAAAANSUhEUgAAAqEAAACRCAIAAAB8JfaNAAAABmJLR0QA/wD/AP+gvaeTAAAgAElEQVR4nO3deTxU+/848PeMPTslESIiW5bEKC1ESLYWukkllbLciqSNpLRqUwmVlNuGQly3om433YpuKW4qVxKhhcjOmPn9cX7f85k7yzFkv6/nHx4z73mf9/t13uc9533O+xxzSPPmzUMAAAAAGHZ4jYyMBjoGAAAAAPSyvLw88kDHAAAAAIA+wTvQAQAAAABDlbu7O/eZL1y40M9L9dUYHxgYKCAgwJjy6dOnmJgYxhRjY2MFBYWsrCxfX9+wsDCEkIeHx6NHj4qKijgV1dbW9vHjx1u3bn39+rWPImcMQ0JCAo8NAAAAYFVeXs5NtoiICAMDg35e6v+P8TuCgxk/Dtu1i3WZHcHBbNM5SUlJKS4uxt/SaDS22Zqbm9PS0rgsSkRExNLScsGCBadPn+Y+kh7jJjYAAACgZ8zMzDh99ODBgx8v//+P8WG7djEO86zDeXcHeIRQe3t7a2srU6KysrKlpaW0tHR1dXV1dTVCSFBQ0N7e/sWLF46OjrKysra2tiNGjPjrr7/YFtXa2vro0aOlS5fy8fGNHDnSwcEhNzd39uzZ58+fHzFixOzZs0eOHFlXV/fHH3+8evVqzJgxDg4OL168MDU1pdPpRUVFd+7coVKpY8aMsba2lpGR+f79+4MHDwoLC7GcWFEfPnzAwyguLsZiQwixLoUQmjZtmqGh4YgRIz59+pSRkfHp06duNREAAADQXdiRAeNBAGsK5n9z9QTDfA8GeLbExcVdXV2zsrIKCwuVlJScnZ3fvn2Lf5qSkiIlJcU6V/+vcHl5tbW1GxoaOjo6sALV1NSuXr3a0dHh6uqamZlZVFSkpKQ0f/78uro6Op0uLS2tqKgYExMjJCTk5OQ0Y8aMx48fu7m53blz59WrVwoKCgsWLPjy5QtjURUVFcuWLcPCEBMTw+oVFhZmXUpISMjExOT8+fN1dXWWlpaWlpYJCQk/3koAAAD+O9ierxOc32OLmJmZmZmZYctyGuAR0/V4tsN8jwd4Jycnxvn5ly9f1tfXf/z4MS8vDyH0+vXrgoICpmv2XRbFz8/f0NBw48YNLJ2fnz81NbW1tdXExKSiogI74S4uLi4oKJg0aVJ+fj6ZTM7IyGhsbGxoaMjKynJwcGhoaKisrMzPz0cIlZSUvHz5UkdH5++//8aLYhuAlpYW61L//PMPmUyWkJD49u3bb7/9RibDPykAAADoD/gwj79lm435njvGYf5HBniE0O3bt9+9e4e/bWtrMzMzq6mpwVNqa2vHjBnTraKoVGpjYyOe3traio3KYmJitbW1jCUrKioihDo6OvD8NTU1wsLCUlJSY8eO9fPzwxJ5eHhKSkoYi2JLQkKCdan379/funVr6tSp8+fPr6qqysnJYVxfAAAAoO9gwzwivHLP5r56fGjHBvseD/NNTU11dXWMKd+/f1dTU8PfSklJ9bgoDJ1Ox0seP348ni4pKdnQ0IAQ4uPjExERwYZ5aWnplpaW+vr6kpKSpKQkLKe4uDiNRhMREcGLYquhoYF1KQkJicrKyhcvXvDw8Ojo6Li4uERERLS3t3O5UgAAAECP4Sfx+KQ9KzbTy4wDPJ7Sg+r5+fkF/+3Vq1djx46dPHmyoKCgurq6lpYW26V6UFdRUZGioqKuri4/P7+qqqquri42b48QsrGxERERGTVq1OzZs1+8ePHq1avx48dramry8fHJycl5eHjIyMh0GQbbpZSUlJYsWSItLY0QolKpdDq9s7OzB8EDAAAA3YKfwTNekmfFfB6Pn7V3ead9lxwdHZlSDh48eOXKFez2tOrq6j/++ENOTo4xw/v3721tbfn5+bFr9tyrr6+/cuWKhYWFra1tXV1dWlrax48fx4wZ09LSUlVVtWbNGoRQUVHRvXv3qFQqFoO9vX1jY+P9+/dLSkqYLhngYbx584axfKalSCTSmDFjli1bJiAg8OXLl2vXrsEYDwAA/1lsB9pe+Rc4thXhJTPdgseItIth5Gb7L3OMb3vl7vp+M2bMmCVLlhw6dGigAwEAADA8ubu7479LQzzGM/6aDb5Ul/8fz3apLmFL5eXl/e88nu2Z+o+fzQMAAAD/BT04Ze+Ls3xG//r/eLY5YFAHAAAAhqLh/EyaqqoqmKgHAADQpyIiIgbtUv+6Hg8AAACA4QGeHw8AAAAMW6SPHz/2c5Xh4eH9XCMAAPTY1q1bBzoEAHrCy8trYK7HW1tbD0i9AADQLdbW1p8/fx7oKADoIZirBwAAAIYnGOMBAACA4anXxng7O7u4uLgfKSEgICA9Pb234uk7nOLcvn07/tDboWWotPxA6bf26c8NwdhdGV8Pns7g6uqKPc25u4buNxGAXve/Md7Dw0NeXl5eXn78+PGWlpY3b94kXtLR0fH06dM/HkFQUNAff/zx4+UMeO0GBgbYA237x8C22yCEN0hgYGB/7uKHwYbo567LpNcbcGBXB4BB5V/n8dbW1vfv309JSTExMVm3bl3PDqK7pbGx8e3bt/r6+n1dUT/U7uzsbGho2CtFdWlg2+3HUanU3i2QywYZqHoHue52Xe6bscucfdGA/flNBGCQ+9d99aKioqqqqgghbW3tjIyM7OxsPT29pKSk2NjYd+/eiYuLz507d8uWLYKCgr6+vnl5eXl5eWFhYZKSkoWFhQih5uZmPz+/zMxMGRmZ0NDQ2bNnd1n9s2fP1NTUREVFsbetra2HDx9+9OiRpKTkqlWrjIyMsMSYmJhHjx51dHTo6emtXbsWe5xrQECAsbFxaWnpkydPZGRk1q9fLyAgEBkZ+eHDBx0dnY0bN4qIiCCEOjs7f/nll+zs7Obm5vHjx69atQp/0jxj7Q8fPvzll1+qq6tHjBgxadKkTZs2YcteuXIlKyurvr5+9OjRy5cvNzY25hTn9u3bDQ0NnZycsNh0dHTevXv3zz//CAkJrVy5kkKhEKRzCpJtVIyR19bWent7e3h4WFpaIoTS09OvXr168uRJMTGxH18jTlFx2fJMAgICJk2aVFpaWlBQMH/+fFdXV4Ly2bYSp57A2CARERFFRUVFRUXnzp0TFRW9dOkSa72rV69etmzZ1KlTsWUXLlwYHByso6MTEBBgYGBQWlr68uVLcXFxvB0YJSQk3Lt3b8+ePbKyskN0Q7Bi7LoIoaampr179z59+lRSUpKx6zI1471791JSUiorK0VERExNTZctW4Y9kZkpp4iISHp6Oj7nR6VS3d3dvb29sfZn/A42NTVFRkbm5eVJSkp6eHjg4bFd/dTU1Fu3bp06dQrP4+7u7uXlZWZmxrg6bNu5u183AIYu9tfjSSSSoKBge3s7QohKpQYFBWVlZZ08eTInJycyMhIhFBkZaWRktGPHjo8fP2IDPELo9OnTurq6N2/etLGx8fHxaWxsRAjFxsZqaGhwqj4vL49xN3rjxg1VVdVDhw5RKJSIiIiWlhashMLCwm3bth04cKCpqWnfvn14/pSUFG1t7YiICGVl5YiIiNOnT//000/h4eFVVVWJiYlYnl9++eX58+ebNm06fvy4gYHBjh07GhoamGpvaGg4dOjQwoULY2Njd+/era2tjWVISEi4ffv2qlWrTp065enpSSaTCeJkcvPmzfnz5//yyy+rVq06ePDgp0+fCNLZBskpKsbIpaSk1qxZc+bMmc+fP1dVVcXHx/v4+IiJifXKGhE0HTctz7ZNbG1tr127hj13mKB8tq1E0BPwBvH39584caKHh8fNmzcvXbrEtl4CN2/etLe3v3LlysKFC1m37NmzZ//44499+/ZhA/zQ3RDErl+/rq2tfeLECSsrqwMHDjB2XcZmxEbryMjIgICAly9fMlbHmHPGjBmfP3/GH9P89OlTOp0+ZcoUpgZECMXGxn748GHfvn1BQUHJycltbW1YOtvVNzMzq6ioeP/+PZbn5cuX7e3teLE4tu3c3a8bAEMXmzG+vb09ISGhrKwMO7FwdXWdNWuWkpKSsbHx5s2bMzIyOJVlbm7u6empoaERFBTU0dHx6tUrhNDo0aP19PTY5qfRaH/99RfjGG9oaGhvb6+kpLR06dKOjo7S0tKmpqbs7Ow1a9Zoa2urqKhs2LDhzZs3+P7CyMjI1tZ23Lhxixcvrqqqsra2NjQ0VFNTs7W1xY482traUlNT169fr62tPWbMmEWLFsnKyubm5jLV/u3bNzqdbmhoKC0tPW7cOBsbG4RQa2trSkrK2rVrTU1NZWVlDQ0N8VBZ42RdOwqFoqurixAyNjbW1tb+7bffOKVzCpJtVKztNnPmTD09vWPHjh05csTU1BTbaj++RgRNx03Ls2Vqajp58mTsCJK4fNZWIugJrB2JoF5OeTDTp0/X0dEhkUizZ8/u7OzEtyydTo+KisrLy9u3b9+oUaOG+oYgpqOjM2/ePKwuNTU1vOsyNaOlpaWhoaGsrKyWlpabm9vDhw/ZNrioqKixsfHdu3exj+7evTt9+nQ+Pj6mBmxqavr999+9vLzU1NRUVVVXrVqFzfNzWn0pKSktLS3G52dPmTJFQECAcUXYtnN3v24ADGn/mqtPSkq6fv06jUbj4+PbsGGDubk5Qig/Pz88PLywsLC+vh4hJCwszKks/MiXl5dXWlr669evCCF7e3t7e3u2+d+8eSMkJKSkpISn4LPovLy84uLidXV1/Pz8nZ2dEydOxNJlZGSkpaU/fvyorq6OEFJWVsbSJSUlEULjxo3D32LRVlZWtre3+/j4MNaLnZcw1q6goKCtrb169erJkycbGhpOnTqVn5+/srKSSqXq6OiwRs4aJ2sexvUaN25cRUUFp3ROQZqbm7NGxbbd1q1bt2bNGgEBgZCQECzlx9eIoOkQFy2fk5Nz8OBBLDEyMhK7B4oxZuLyWVupqqqKU09gbRAmBB8xkZeXx16QSCQxMTF8yyYnJ5NIpKNHj4qLi+OZh8SG6IEJEyYwvmbbdRFCxcXF58+ff/fuHTZjx3j8xJTTwsLi8OHDq1atam1txY6TsHTGBqysrOzs7MTn/CZMmEAikRBhPzEzM0tJSVm6dCmVSn306NH69euZVoRtO3f36wbAkPavMd7KyiowMFBISEheXp6Xlxch1NHR4e7uvmTJkhMnTkhLS//555/u7u4cy+L9X2kkEolOpxPXnZubO3nyZMYUHh6ebpWA58d2B3gA+LKtra0IoUuXLuGX/NnWTiKRwsLC/v7776dPn16+fPnatWtHjhwhqJ2bODs7O/HXjHcesaYTBMkalaCgIGu7ffjwobW1tbOz8/v379hB2I+vEUFUiIuWNzQ0PHnyJJaIz2xjZ28Y4vI5tR5brA3ChLFePGYcjUbDX+Nz5hi8xbS0tHJzc58+fWphYUFQ7yDcED3A1D44xmakUqmhoaFz5swJCAgQFxd/+fIl49OtmBrcwMCAj4/v6dOntbW1o0ePxg7QEUsDkkgkxtXBXhOs/rRp02JiYkpKSmpra+l0uoGBAVMGti3Q3a8b26YAYKj41x5NTExMQ0NDSUkJ31OUlZXV1NT4+vrKyMjw8PBg0+8YPj4+xh1xDzx9+pT1+hmTMWPG8PDwFBUVYW8/f/5cU1MzduxYLqtQUFDg4eF5+vRpl7WTSCRtbe3ly5dHRkZ++vTp7du32IFOQUEBl3UxwS8oYK/xmFnTCYJkjYo18tbW1qNHjy5evNjY2Jhx/PjBNSKIihtCQkJj/w/jwR+X5bO2EkFPYGqQLnumuLg4fj27pqYGu++E2MSJE7du3RoVFZWTk4MnDokN0QOMjf/27Vu2X7fq6ur6+vqFCxdKSkqSyWS2l6twZDLZ3Nz83r179+7dw2YHMYwNKCcnRyKRysvLsbfYKTgiXH0xMTFdXd0HDx48ePDAxMSE6cACIcS2nbv7dQNgSOvi9+plZWWFhITu3bs3d+7ct2/fnjlzBv9IQUEhLy+vurpaUFBQQkKCUwnp6elXrlxJSEhgSv/y5UtVVRXb6UpGwsLCs2fPjo6O9vPzGzFiRGxsrLq6OuNcIjERERFbW9szZ86QSCQNDY36+vpHjx5Nnz5dVFSUsfbi4uIXL14YGhqKiYk9f/6cTqfLysoKCgo6ODhERUXRaLTx48djc8Xc/0/O33//nZaWNmXKlPv375eUlOD36LKmcwqys7OTNSrWdjt79qy4uPiCBQtaWlq8vb1TUlKcnJx+fI04RaWiosJlCxAjLp+1lTj1BNYGkZGRKSoqqqmp4efnZ3vuq6Wldffu3VmzZiGEzp07x+m0lYm+vn5AQMDBgwcFBASMjIyGzYZgVVBQcPPmTSMjoz/++OPt27cbN25kzSMtLS0gIPDXX39NnTq1vLw8LS2NuEwLCwtfX9/Ozs7AwEAshakBhYWFZ8yYER8fv2XLFhKJFB8fj20X4tWfPn36pUuXmpqaNm/ezFopp3bm/uv2I80IwGDQxRgvIiISGRkZFhYWEhIiKyvr7e0dGhqKfeTl5fXzzz9TKBRhYWGCu3uqqqrYHjLn5eVNmjSJmytenp6eMTExu3fvplKpenp6Xl5eXS7CtLi4uPjFixdra2slJCS0tbUlJCQeP37MWPuIESNevHhx48aN1tZWOTm5wMBAGRkZhJCbmxuZTI6Ojm5oaJCVlV22bBn39To7O798+TI+Pl5CQiIwMBDfX7BNZxtkS0sLa1S//vorY+TPnz+/e/fu0aNHeXh4REREfHx89u3bN3ny5F5ZI7ZRdavxiRGUz6mVWHsCa0dydnbGrv4KCgrit9YzWrBgQWVl5YoVK0RERNzc3PD717pkYmLi6+u7f//+4ODgioqKYbMhmDg7O7948eL8+fNMXZeRkJCQv79/XFzcmTNnpKWlFyxYcPbsWYIyx44dq6KiIigoiN+xyLrh1qxZc/z4cXd3dzExMUdHx5cvX2LpBKtPoVBOnTolJCQ0adIktvWybWfuv27dbzwABpeBebastbV1aGiosbHxQD2Arq9rDwgImDlzpp2dHZfp3BvYdusf3WqlgWqQ/8KG6EV0Ot3T03PJkiX4XP1QaUB47hwYugbs2bIIIW1tbRMTk/9m7T9i6EbeRwaqQWBDcO/79+/Z2dktLS3Tpk3DE6EBAegHAzbGz58/f6CqHvDaf8TQjbyPDFSDDIkN8fnz55UrVzIlKisrHz9+vD/DWL16NS8vr4+PD+PM/JBoQACGugGbq+/nSgEAoAdgrh4MXV5eXvD8eAAAAGB4Gpi5ejiPBwAAAPraAMzVAwAGGzk5uYEO4f+rrKxkTRw84fWWob6aQyL+IRFkr2Nc64G8rx4AMKiw3SH2s4SEBDc3N7YfDYbwestQX80hEf+QCLLXsa41XI8HAAAAhicY4wEAAIDhaWjP1bP+DD4AgBinCUwAwPAztMd4BDssALpDTk5uGF+MBAAwgbl6AAAAYHiCMR4AAAAYnvpvjLezs4uLi+M+v4uLy+nTp/suHgAA6C3DYH+loaHx4MGDgY6CyDBo5P7HZoz//Pnz+vXrDQwMVFRUKBSKr6/vt2/f+j+ywc/Hx0deXj45OXmgAwGgX5WUlHh5eWlraysrK5ubm585c4ZOp+Ofenh4rF+/Hn+7f/9+dXX13NzcfguvvLx8w4YNBgYGysrK06dPDwwMrKio6Lfa+wdTIw85Hh4e8vLy8vLyysrKU6ZMWbt2bV5e3kAHxQwPcuzYsfr6+gEBAQ0NDQMdVLexuedu5cqVHR0dERERY8aMqaysvH37dmNjo6SkZP8HN5jdvHnz48ePQkJCAx0IAP3qzZs3Dg4ORkZGsbGxUlJST548CQ8Pf/PmzcGDB1kzh4aGXr169erVq3p6ev0TXklJiYODg6KiYmhoqLKyck1NTVpaWmRk5P79+/snAMAla2vrLVu2UKnUysrKlJQUZ2fnvXv3DrZ7qLEgaTTau3fvtmzZws/PHx4ezpSHSqXy8g7eu9eZz+Pr6+ufPXu2ffv2WbNmaWhomJub79u3T0FBIS4uzszMDM/W0dGhra2dkZGBELKzs4uMjFy7du348eNnzJjx7Nmz169f29nZqampubu719fX40t9//591apV48ePp1AomZmZWGJzc3NAQICmpqaqquqKFSuqq6t7sBp2dnZ79+5dsmSJjo4OY+FcxsYphoyMjJkzZyorK+vq6q5btw6v7vPnz7t27Tp69CiJROIUEuuyvdKGAAys7du3Kyoqnj9/nkKhqKuru7u7Hz9+/NKlS48ePWLMRqfTt27dmpycnJSU1G8DPEJo69atcnJyaWlp8+bN09bWnjFjRkRExObNmxFCSUlJc+bMUVNTmzx5ckhISGtrK7aInZ1dRETEypUrNTQ0pk6dmpWVhaVTqdSDBw8aGRkpKyvPmDHj1q1bWOK+ffsMDAzU1NScnZ0LCgr6bdW6xGk/xmnFGxoaVq9ejc3XYjui/iQqKqqqqoqNMsePH1+3bl1oaCg2Zzx4GhkLcsKECdbW1vb29n///TeWbmdnt3//fnd39wkTJpw4cQJxaPxff/3VyMgIWyQxMVFeXv7u3bsIIRqNpqGhgU1usR1lerEFmMd4YWHhESNG3L9/v7OzkzHdycmpoqLi+fPn2Nvs7GwajWZpaYm9jYmJMTExycjI0NTU9PX13bp168aNGxMTE8vKyiIjI/FCoqKiKBTK3bt3Fy9e7OXl9eHDB4RQSEjIo0ePzp07l5qa+v3799WrV/dsTc6ePevt7V1QUBAaGrpu3TqscC5jYxvDt2/f1q1b5+Pj8+jRo2vXrlEoFLyujRs3ent7KykpcQqG7bK90oYADKDa2to///xz9erVPDw8eKKVlZWKikpaWhqeQqfT/f39MzMzk5OTNTU1+zO8hw8frlmzhum8SkpKCiFEpVKDgoKysrJOnjyZk5PD+LU6e/asp6dnUVGRr6+vj49PY2MjQujgwYOXL18ODQ39/fffQ0JCsDIPHTp0//79U6dOZWVlzZw5c/HixXV1df22gsQ47Us5rfiOHTuKi4uvX78eHR0dFRXV0tIycLGj1atXNzc35+TkoEHZyBUVFTk5Ofr6+njKuXPnli9f/vr161WrViEOjW9sbFxZWYldKsrNzZWUlHzy5AlCqKioqK2tTU9Pj9Mo04stwDzG8/LyHj58OCEhQUtLy83NLTo6+suXLwghCQkJKyurxMRELFtSUpKDgwM/Pz/21sLCYtmyZRoaGhs3bnz//r2bm5u5ubment6yZcseP36MF06hUDw8PJSUlPz8/PT09BISEhoaGq5du7Z7924TExMtLa1jx449f/4cHwW7xcbGxtTUFCFkZWVFoVDwn8fpMjZOMWAPjTY3N5eVldXQ0Fi6dClWYHx8fEdHx7JlywiCYbtsr7QhAAOorKwMIaSmpsaUrqqq+v79e/xtampqcnJyYmIia86+Do9Op6uqqrL91NXVddasWUpKSsbGxps3b2Y8c3V0dKRQKCQSycXFhUajvXr1qrm5OTo6Ojw83NbWVklJydzc3MLCoqWlJSYm5siRIyYmJth+TFFR8c6dO/21fkQI9qVsV/z79+83btzYs2ePnp6erq5uaGgolUodwPilpaWlpKTKy8sHVSMnJycrKytjTScpKRkUFIR/ZGtra25uTiaThYWFOTW+tLT0+PHjsR34kydPPD09sdePHz/W19fn5+dnO1L0bguwuedu3rx5+fn50dHR+vr6V69enTlz5ps3bxBCLi4uaWlpVCq1vr4+Kytr4cKF+CJaWlrYCxkZGYQQfuQuIyNTU1ODZ2M8CNLX1y8pKSktLaVSqZMnT8YSx44dO3r06JKSkh6siYaGBv564sSJeCFdxsYpBjU1NRMTk6lTp/r4+CQnJ2MTXGVlZUePHj18+DDBLD1CiO2yqDfaEIABxHhvHQE9PT0JCYlDhw4xTQcOrPz8/EWLFmlqasrLy69YsYLxt4BUVFSwFyQSSVJS8uvXr+/evevo6MBOG3ClpaVtbW0WFhby/+fFixf4lOHAItiXsl1xLL+BgQGWX09Pj0we4H+lxnrXoGpkKyurO3fuZGVlXb58uampKSAgAP9IXV0df03Q+MbGxrm5uTU1NdXV1cuXLy8sLGxtbX3y5ImxsTHiMFL0bguw36gCAgIzZszw9/e/ffu2rKxsTEwMQmjGjBn8/PxZWVmpqakKCgp450AI4TNj2MjH+JZGo+HZiMfFH8R4ENrR0dHd2FiRyeTLly+fO3duzJgxERERc+bMaW5uzs/P//LlC4VCUVRUVFRUbG5uXr9+/aJFi7hZFvVGGwIwgMaNG4cQKi4uZkovLi7GPsKzXb16NScnZ8OGDf3Ze5WUlEgkEmt4CKGOjg53d3dDQ8Pff//9w4cPV65cYdxLMF56QAjR6XS2RzNNTU0IocLCwo8M/P39e3s9ehPBipNIJHw/QyaTmRqhn339+vXbt28KCgqDqpGx6/FqamrTp0/fvn37jRs38ENDAQEBbkowNjZ+/PjxkydPDAwMJCQk1NTUnj9/npubO2XKFMRhpOjdFujiwI2Xl1dWVharkoeHZ8GCBdhNNIwnoNx79uwZ/vr58+fjx49XVlbm5eV9+vQpllhRUfHp0ydOU23E/vrrL8aKxo8fz+WCBDGQyWQKhbJt27bs7OwPHz48f/7c3Nw8Kyvr9v8RFBTcvHnzoUOHWItlXRb1RhsCMICkpKQoFEpMTAzjCfrt27dLS0vt7e0Zc2poaFy5ciUrKyswMJDLs/9eCc/U1DQ6Oppp2rm2trasrKympsbX11dGRoaHh+fVq1fERamoqPDx8f3555+MiRMmTODl5cVumxpsOO3HOK24srIymUzGj4eweYuBCR0hhFBMTMyIESPMzMwGcyMjhPBJWUYEg8iUKVNKSkp+/fVXExMThJCxsfGlS5dqamrwk37WkaJ3W4D5jv9v374tX77c1dV14sSJvLy8WVlZ9+/fP3bsGPbpokWLLCwsaDRaVFRUDyrDbkmwsLBITcVLa+MAACAASURBVE3Nz88/fvy4qKioi4vL9u3bIyIiREVFg4OD9fX1e3YXbm5u7pkzZywtLVNSUgoKCk6ePMnlgpxiyM/Pz8nJMTc3l5KSun//Po1GU1JSEhUVZbwoQCaTx4wZo6ioiL2NjY199erVkSNH2C6L5fnBNgRgYO3evdvR0XH58uXr1q2TkpLKzc0NDw9fvHgx402pGG1t7UuXLrm6urL9j6M+smfPHgcHBwcHBy8vLxUVlZqamtTUVF5e3h07dggJCd27d2/u3Llv3749c+YMcTnCwsKrVq3aunUrjUbT1tZ+//49lUo1NzdftmzZzp07SSSSoaFhTU1NZmamg4ODtrZ2/6wdo7q6Ovw2b4SQvLw82/1YY2Mj2xUXExNzcnIKDw+PjY0lk8l79+7t57n6hoaGf/75B/vfudTU1OvXr+/du1dCQgIhNHgaGQsSIVRVVRUeHj5+/HjG+SocwUCmqKgoKyublpZ29epVhBD2YwCampqioqIIIbYjhbi4eC+2APMYLywsTKFQ4uLisJtrxo0bd+DAgfnz52Ofqqqq6ujojBgxQl5evgeVrV279sGDB7t375aRkTl16hQ27O3cuTM4OHjFihUdHR1mZmY93hesXbv24cOH4eHhjIVziW0MoqKiDx8+jI6ObmpqUlFROX369NixY4nLef/+fWFhIfGyP9iGAAwsDQ2NmzdvHjx40NPTs6mpSVlZ2d/ff+XKlWwz6+np/fLLL4sXL+bn59+5c2c/hKemppaZmXnkyJHg4OC6urqxY8daWFh4e3uLiIhERkaGhYWFhITIysp6e3uHhoYSF7V582YeHp5t27bV1dUpKSlt3boVIRQSEiItLX3gwIGqqqpRo0ZRKBTsBpr+d+fOHcb7sI4cOcJ2P0aw4mFhYf7+/vr6+pKSkl5eXtg97f3mt99+++233/j4+EaNGmVoaJicnIxNX6PB1MhYkAghaWlpY2Pjbdu2cToSIhjIjI2Nf/31V+x2tClTpnR2duJrymmk6MUWIH38+JH73DQazdTUNCAgYMGCBT2rr3clJCRgv5lgZ2c3f/78FStWDHREXRtsbQj+Uzg9d26QPI8O/0YzGSTh9ZahvppDIv4hEWSvY1prLy+vbvw6T21tbWJiYkNDg52dXR/E9p8AbQgAAKDfdGOMNzU15efnP3DggKCgYN8FNLxBGwIAAOg33RjjX79+3Xdx/KD09PSBDoErg7kNAQAADDPw/HgAAABgeBq8T8vhkpyc3ECHAAAAAAxGQ3uMd3NzG8Z3SAIAAAA/AubqAQAAgOEJxngAAABgeBrac/UAgN6CP455cBrk4fWWob6aQyL+IRFkb+ne79wBAAD4Lxsq/6gMEELp6elwHg8AAKAbVq9ePdAhgK5VVVXBGA8AAAAMMW/fviXOcPXqVU9PTwT33AEAAADD1RAY4+3s7OLi4gY6ikHHxcXl9OnTAx0FGCz9U0ND48GDBwMdxX8F47evH76J+MaFbz3oLo5z9cR3HgYGBrL++IyHh8etW7eio6Pxh6oFBQV9/vz53LlzPx4ocHR0tLa29vLywt7OnDlTXV29d6vo8UZHCAkKCqqoqPj5+c2bN693owLDQA+6FkKovLz88OHD9+/f//btm4KCgomJiZ+fH/aA7eEB//rgtmzZ4uPjwyk/47eeaYfAKjk5ef369Rs2bNi4cSOeyLRUl4X8uISEhGXLlgUHB4eEhDCGISEhcf78ecacbBPBDyK6Hh8YGNjd4gQEBA4ePGhjY8PDw/MDUQ1JVCqVl7dP7m9gW/LatWv7oq4ebHRra+stW7a0tLRcu3Zt3bp1CgoKenp6jBn6qGX6rsH/U/qtGbvbtUpKShwcHBQVFUNDQ5WVlWtqatLS0iIjI/fv399HEQ4IS0vLTZs24W9Hjx5NkLlb3/rExMRVq1YlJSVt2LCBRCJ1N7Aed4zy8nIFBQX8bXx8/IYNGy5cuBAcHNyDMD5+/CgnJ9eDBQGml+fq586d++3bt+vXr7N+1NzcHBAQoKmpqaqqumLFiurqatY8VCr14MGDRkZGysrKM2bMwI9wm5ub/fz81NTUpk6dmpWVhSUmJSXNmTNHTU1t8uTJISEhra2tWLqdnV1ERMTKlSs1NDQY89fV1Xl6eqqoqFAolIyMDHz6i0ql7tu3z8DAQE1NzdnZuaCggDUwOzu7vXv3LlmyREdHh0KhZGZm4un79+93d3efMGHCiRMnCFaTUwmcamcq2dfXNy8vLywsTF5eXltbG/171o5TIRkZGTNnzlRWVtbV1V23bh2XG5EV8RdMVFRUVVVVR0dn165do0aNys7OZtsy3QqSy2aJjY2dOXMmHgmVStXR0UlLSyMogZGpqWlGRgb+Vk1N7dGjR4hzFxpU/bOhoWH16tV4frabpu/6bW91LQJbt26Vk5NLS0ubN2+etrb2jBkzIiIiNm/e3N1o4+LizMzM8GI7Ojq0tbVZW4ztxuWmF/0gCQkJLQYjR45EnDcu/q1n3SEwqaqqys/Px44ecnNzsUSmpVgLYe0Y3Kurq4uKipo8efKiRYvwxIqKitzc3F27dpFIpJycnG63DkL79u1TUVEJCwsrLy/vweKgl8d4YWFhb2/vw4cPU6lUpo9CQkIePXp07ty51NTU79+/s/3vi4MHD16+fDk0NPT3338PCQnBjyJPnz6tq6t78+ZNGxsbHx+fxsZGhBCVSg0KCsrKyjp58mROTk5kZCReztmzZz09PYuKinx9ffH827dvLy8vT0lJiY2NjY2NbWlpwTIfOnTo/v37p06dysrKmjlz5uLFi+vq6lhjO3v2rLe3d0FBQWho6Lp16z58+IClnzt3bvny5a9fv161ahXxarItgaB2xpIjIyONjIx27Njx8ePHwsJCptjYFvLt27d169b5+Pg8evTo2rVrFAqFu23IjPsjaBKJJCgo2N7ezrZluhUkl81ib29fUlKCP7H34cOHra2tlpaWxCVwg20XGlT9c8eOHcXFxdevX4+Ojo6KisLzs65Ir/fb3upaBGprax8+fLhmzRqmU0kpKanuRuvk5FRRUfH8+XMsQ3Z2No1GwzoJI7Yb9wd7UY91uXGJdwgIoaSkpNmzZwsJCTk4OCQmJrJdim0hTB0jNjZWQ0ODIFQ6nf77778vXbpUTk4uMjLSxcUlJSUF//TixYt2dnYjRoxwdXWNj4/vQVPs3bt3x44dt2/fVlZWtrGxSUpKwvcwgBu9f8/d8uXL29raLl++zJjY0NBw7dq13bt3m5iYaGlpHTt27Pnz5/i3DtPc3BwdHR0eHm5ra6ukpGRubm5hYYF9ZG5u7unpqaGhERQU1NHR8erVK4SQq6vrrFmzlJSUjI2NN2/ezHi06+joSKFQSCSSi4sLjUZ79epVfX19WlpaeHi4rq6utrb2rl27sKOQlpaWmJiYI0eOmJiYKCkp+fn5KSoq3rlzh3W9bGxsTE1NEUJWVlYUCgW/vmhra2tubk4mk4WFhYlXk7UE4toZSyZocE6FfP78GWs6WVlZDQ2NpUuXcrkFGQd17gf49vb2hISEsrIyY2Nj1vi7FST3zTJ69OgpU6akpqZiH6WlpVlaWgoJCXG/WTlh7UKDqn9+//79xo0be/bs0dPT09XVDQ0NZT2qxvRFv+1x1+JeWVkZnU5XVVVl/ai70UpISFhZWeHjXFJSkoODAz8/P2OZbDfuj/cibiQmJsozePDgAfcbl7hYBwcHhJCjo2N6ejo+jdQlpt3O6NGjmS694aqqqsLDw9XU1BwdHUeMGHH37t1Xr15t2rSJ8XJDfHy8q6srQmjx4sWJiYmcjkQJiIiIeHh4PHjwoKioSF9ff/369fLy8hs3bsS+ZaBLvX8dTkBAwM/P7+jRo4wzNqWlpVQqdfLkydjbsWPHjh49uqSkRF9fH8/z7t27jo4O7PvJBJ+M4uXllZaW/vr1K0IoPz8/PDy8sLCwvr4eIcQ4EKqoqGAvSCSSpKTk169fBQQEaDSarq4uXiB2nF5aWtrW1obvrDH4uQ4jxoPZiRMnlpSUYK8Zb3wjXk3WEohr5/KWOk6FzJ8/38TEZOrUqRYWFrNmzZo7d66goCA3BSKESCQSnU7HB3g6nU6QOSkp6fr16zQajY+Pb8OGDebm5qzxdyvIbjWLg4NDdHT05s2bqVRqZmbmkSNHCKrjcvURuy40qPon1tMMDAywFD09PTKZ/fF6X/RbNTW1HnetH9fdaBFCLi4ufn5+u3btampqysrKYr2YyHbj/ngv4gbT9fhx48b9888/XG5cTp49e/blyxfsMpa6urq8vPyvv/7q7OzMzbJM3y97e3t7e3u2Offs2XPy5ElXV9eYmBhRUVHWDI8fP/706dOcOXMQQlpaWkpKStevX1+yZEm31gWnpqYWHh4eFha2c+fOPXv2/Pnnn48fP+5ZUf8pfXKvzZIlS6Kioi5cuNCtpQgGEsb5Omz46ejocHd3X7JkyYkTJ6Slpf/88093d3c8D9Mdf3Q6nVPhTU1NCKHCwkJJSUni8BgPpTs6OvDXAgICxAsSlEBcO5clExRy+fLlJ0+e3L17NyIi4vjx45mZmSNGjOAyWi4HeISQlZVVYGCgkJCQvLw845ZijL9bQXarWezs7Hbs2FFQUPD582cajTZr1izi6hgx7To7Ozvx19x3ITQQ/fPFixckEgmvl0wmc7rLtS/6LZlM/pGuxQ0lJSUSiVRcXDxp0qRuLch2fWfMmMHPz5+VlfX582cFBQV8+MSxbX/udw4/Arsez5TI5cbl5Nq1a9+/fx8/fjz2lkajJSYmcjnGc98xAgICREVF4+Pj1dXV3dzcVqxYMXHiRMYM8fHxdXV1eMeg0Wjx8fE9HuMrKysvXrwYFxdXWVm5cuXKNWvW9Kyc/5o++f94Pj6+9evXnzhxorm5GUtRVlbm5eV9+vQp9raiouLTp09ME3EqKip8fHx//vknN1WUlZXV1NT4+vrKyMjw8PB0OW+jrKxMJpNfvnyJvS0sLMT2BRMmTODl5b17926XNf7111/462fPnuHfH6ZaCFaTtQTua0cI8fHxMQ5COIJCyGQyhULZtm1bdnb2hw8fmC6OcMK4v+tygEcIiYmJaWhoKCkpEdyF260gu9UsUlJSU6dOTUtLS0tLs7GxweZguSxBWlr627dv2Ovq6uq2tjaCzIOqf2L5i4uLsbfYaSjbkvui36Kedi3uSUlJmZqaRkdHM01T19bW9iBaHh6eBQsWJCcnJyUlLVy4kLU6thu3W/2wF3G5cTntENrb29PS0o4cOXL7/1y9ejUnJ6eqqop1KU6FcGPcuHF79+4tLy+Pjo5++/atrq6uiYlJdHQ0NnHV1tZ29erVuLi4/P+TlZWVnZ1dUVHRrVra29uTkpLmzp2rqKh48+bNzZs3V1VVxcbG4hM5gFhf/c/MwoULT548mZ6ejs0XiYqKuri4bN++PSIiQlRUNDg4WF9fn+kyj7Cw8KpVq7Zu3Uqj0bS1td+/f0+lUvGJXyaysrJCQkL37t2bO3fu27dvz5w5QxyPuLi4vb391q1bDx06RCaTsXtqSCSSuLj4smXLdu7cSSKRDA0Na2pqMjMzHRwcWG9Vzc3NPXPmjKWlZUpKSkFBwcmTJ1lrIV5N1hK4rx0hpKCgkJeXV11dLSgoKCEhwbhqbAuhUqk5OTnm5uZSUlL379+n0WhKSkrErYTDJuq5GeC51K0gu9UsCCEHB4eIiIjv37/j/2jAZQkmJiZJSUnz589HCIWFhRHPiA62/unk5BQeHh4bG0smk/fu3csp+L7ot/n5+T3uWtzbs2ePg4ODg4ODl5eXiopKTU1NamoqLy/v/v37uxUtlr5o0SILCwsajRYVFcVaF6eN261+2DN1dXV///03/lZKSmrMmDHcbFxOO4Tbt2/TaDRnZ2fGY251dfXk5GQfHx+mpTgVgktPT79y5QrBzxvw8PDMmzdv3rx5nz59io+PP3LkyIULFx4+fJiWlkaj0ZYsWcLHx4dn1tbWTkhICAoKQgjV1tbm5+fjHykqKrJNDA0NvXr1qru7++HDh3v9F0GGOrYN8ubNG8a3fTXG8/Ly+vv7M/6Yw86dO4ODg1esWNHR0WFmZhYeHs661ObNm3l4eLZt21ZXV6ekpLR161ZO5YuIiERGRoaFhYWEhMjKynp7e4eGhhKHtHv3bn9/fwcHBxkZmR07dvj6+mLnfCEhIdLS0gcOHKiqqho1ahSFQpGRkWFdfO3atQ8fPgwPD5eRkTl16hSnnRrBarItgcvaEUJeXl4///wzhUIRFhZmupOWbSENDQ0PHz6Mjo5uampSUVE5ffp0t348pBcH+B4EyX2zIIRsbW2DgoJERESmTZtGXB3Tgt7e3u/evTMyMhIXF9+0adPt27eJV2FQ9c+wsDB/f399fX1JSUkvLy9O/5jUF/2WSqX+SNfikpqaGnaDRXBwcF1d3dixYy0sLLy9vbsbLZaO/XvniBEj5OXl2VbHduN2qx/2zJ07dxjv41u6dOm+ffu42bicdgjXrl0zNzdnmlSzsbFJTEz08fFhWopgr4KpqqrCp0yIjR49OjAwMDAwEPsp9fj4eBsbG8YBHiHk5OQUHx+PjfE3b968efMm/hH2Y5GsiT///HNERAT8EgZbb968YRrmmQZ4RPBsWTk5OeLS2f4u1VDxzz//zJgx49mzZ8S/OIGzs7ObP3/+ihUrelzjj5fQD4b3Rh9Cuts/ORk8/bZ/uhZBtDQazdTUNCAgYMGCBT9e0X9Zeno6PHduwDE+kwYf5hkHeOyZNGvWrOF4cDT89ubPnj2rq6vT0tKqrq4ODg6eOnXqD+5Ah5/ht9GHkOHdPwe2a9XW1iYmJjY0NOA/sw3AsIGdzbOewWP+QxMg7e3tu3bt+vDhg7i4+PTp03fu3DnQEQHwP9A/+46pqSk/P/+BAwf683/8AOg3nAZ4RDBXDwAAADCBufrBgMvnxxPN1QMAAABgELp69SqXOWGMBwAA0A3Yv9qDAeTp6cllTtIwe1AjAAAAABBCOTk5vAghNze3gY4EAAAAAF2Tk5M7cOCApqYmY+KrV6+YUuzs7P7/GA9AH3n37t1Ah/Av+MNgAABg2LCzs+P0g9l98nv1AAAAAOg3bm5ubId5GOMRQujixYs2NjbEedTU1LAHPL9+/bp/ohoeLC0tzczMzMzMBts5PQAADAP4Lzuxvew+eMf4U6dOWVhYqKqqGhsbHz58uMcPR+otxcXF/6lRat++fVOnTlVRUTEyMtqzZw/T47+4d+fOnezsbO7z02i0EydO2Nra2tjYHD16lEajEeePiYlZvHixhYXF/Pnzo6Kiehxnd+Xn5y9btkxLS0teXh5uMwYADCD8dyRZT+UH7/X4zMzMJUuWaGlplZWVbd++nYeH5+effx7ooP5DJCQktmzZIicnV1FRsWPHDn5+/k2bNvVDvYmJienp6Tt37uTh4cGeCLJ06VKC/KKioqtXr5aRkamurj527Bg/P//KlSv7Ic7GxkZNTc1p06bBD9IBAAYK088zu7m5PXv2jDHlf+fxLi4uwcHBLi4u6urqDg4O1dXVWHpGRsbcuXPV1NQ0NTU3bNjQ2NiIELp3756ZmZmdnZ2pqWlcXJy+vv6iRYuwhxx3dnYeOHBAX19fQ0Nj+fLlnz59IoiPoJybN296eHgYGxsvWrRo4cKFjI9m6lY5LS0t/v7+Ghoa6urqP//8c1NTE7ZIbW3t0qVLlZWVra2tS0tL8aK6FT+x/Pz8BQsWqKio6Ovr79q1q2dxUqnUoKAgXV1dNTU1W1tb/BHjjo6OQUFB1tbWGhoaP/3009evXwkiMTAwuHfvHmPK48ePNTU1CR4u5+XlZWdnZ2BgYG9v7+zsjD9a28XF5cSJE9jr1NRUU1PTHrYOB+np6S4uLiYmJkZGRj/99FNaWhpx/sWLF8+aNUtLS8vCwsLKygrv3+vXr8cfiJmdne3q6kpQCMF24WTatGmbN2/u9dUHAIBuYXoYBNOp/L/m6lNSUkJDQwsKCgQFBY8ePYolfvv2beXKlbdu3bp27VpxcfGePXvwcg8dOiQvL3/hwoXk5OTS0tLc3FyEUGRk5K1bt06fPp2ZmSklJbV27VqEUFxcnDwLbKjgVA6j79+/S0pKdrmebMs5fPjww4cPExISrly58vz5c/z3AHbu3Pn169eMjAxfX9+LFy/i5bCNnxOC9aqpqXF1dVVVVc3MzIyLi2tvb+9ZnJcvX/7jjz8SEhLu3bu3du1axmsWKSkpx48fLywsFBcX37FjB0Gc+vr6BQUFjCkFBQX6+vrnz5/nFD+GTqf/888/d+/e1dHRIW7/bklOTjZjkZCQ0N7eXlZWpqWlhWXDHtDS0NDQZYF0Or2srOzx48cTJkzoWUhstwvB9gUAgIHF9hlLTFfl/zVXb2trq6GhgRCyt7e/dOkS6wKenp6HDh3CXispKWloaBgYGHz69ElFRUVdXb2qqqqzs/PUqVMXL140NjZGCIWFhamrq1dWVjo4OEyZMoUplNGjRxcUFLAthzFbaWlpZmbm+fPnideWUzlXrlzZsmXL5MmTEUL+/v4BAQGhoaHt7e2pqanx8fGampqampq3b9/Gfv6XU/ycnozJab0QQvHx8fLy8nv37iWRSAghPT29HsRJIpHKy8uVlZV1dXURQkxP6ba1tcWGtLVr19rZ2TU2NoqIiLCNU19f/8WLF1gtVCrVzc0NG+MJ4sdWYfv27TQabcGCBcTHEN01e/ZsbI0YjRw5sr6+nk6ni4uL79mzp7GxcdWqVQihuro6UVFRgtJu3LiBXbmfM2fOunXrehYS2+1C3D4AADCw2D7RkfF/5f81xuMjmYiISF1dHfb69evXu3btys/Pr6+vRwjJyMhg6QICAgghfn5+7FFO/Pz8ra2tFRUVTU1Nzs7OjMVWVFQYGRmJiYkxxcHDw8OpHDxPfX39ypUrvby8pk2bRryqbMtpbGysra2dOHEilkddXb25ufnLly9NTU1UKhV/7K66ujo2xnOKn9MYLykpyWm93rx5Y2RkhA3wPY5TRkZm3rx5Fy5csLKyMjU1xf7iRSkpKeEvOjs7KyoqsEM0Vvr6+tjEdUJCQmdnp5ub28uXLx0dHQniRwg5ODgYGRm9efNm9+7dV65cIb4u3i1iYmKshyNkMhm74tDZ2SkpKSkoKIhNWrC2IRMLCwsdHZ3S0tKoqKiMjAxHR8cehMR2uxC3DwAADBSCByUzXpX/1xhPJv9v6h6/Uuvh4TFz5szjx4+PHDkyIyNj27ZtnMrFF8nNzZWXl2f8KC4ubvv27Uz5t2zZgs/Ksi2nubl56dKlRkZGAQEBnColQHCxGYPvrPn4+BjTWePn5Pz582zXy8fHh+swu4hTR0fnyZMnd+/evXv3rqur68GDB11cXLCP8HvIu7yZfNKkSZWVlR8+fODl5RUUFCwvL3/37p2enh5x/BISEhISEpqamlQqddeuXdgYzzjidnnTOyfXr1/HLwbh1qxZs2jRIhKJVF9fj52O//XXXwghcXFx4tLExMTExMRUVVWpVOrJkyexMf7H46TT6b2yfQEAoC8cOHCA4FPsIKCL++pra2vLysr8/PxGjhyJEOryX8PHjh0rLCycl5fHNEYSzNVzKqq9vd3Dw0NOTm7v3r3ElRIQERGRlJQsKirS19dHCL1580ZISGjUqFHi4uK8vLzl5eXYtERZWRlx/Bg+Pj5eXl7GaQaCuVx1dfWMjAw6nd7laShBnNin4uLiTk5OTk5OoqKi2dnZ+BiPPzP47du3PDw8BMclIiIi48ePP3v2LIVCERQUPHPmzNixY6WkpLici6bRaK2trdi6iImJ4fcDsp0mYsXLy8vLy9vW1oancJqr5+fnV1JSKiwspFAoCKGCggJZWVnGiXrsRB/rjazodHpbWxsWp7CwcEtLC5b++fNnbuJkBXP1AIDBKT09nenHa9nqYoyXkJCQlJR8+PDh/Pnz37x5g9+ozAkPD8/atWtDQ0MFBAQ0NTVLSkouXbp05swZKSkpKSmpboSP0OrVqz99+hQUFFRUVIQQ4uXlxafWu8XFxSUyMnLChAm8vLwRERGurq4kEklAQMDJySk6OvrUqVMfP35MTU3FLnVzih8rikwm6+joXL16VVZWVlBQUEJCgmC93N3dY2Jitm3btnz58ra2ths3bgQHB3c3ToRQQkKCuLj4pEmTvn///vjxY8b5mezs7JSUFA0Njf3799vY2BBftNbX1798+fL58+eFhIRcXFysrKwQQpzi//Lly969e62srEaPHl1SUrJ//35LS0ssHm1t7fT0dD8/v6ampmvXrhE3PoZMJqupqf36668jR44UEBAQExMTFxfndHZuZ2cXFxenq6vLw8OTmJjIdD/8pk2bOjs7L1y4gL2tra2Njo6eNm2atLT0hw8fYmNjp06disWprq5+7969pUuXtrS0ZGZmchMnK4Lt29zcXFpaWlJSghB6+/ZtbW3thAkTmCaEAACgjxDM1TPqYownk8lRUVHbt28PDw+Xk5Pz9PSMjY0lXsTPz6+zs3PHjh1fv35VUFCYM2cOtyEzoFKp2D/LzZ07F0sZNWpUfn5+D4ry9/evra1dsmQJnU63srIKCgrC0kNCQvz8/PT09JSUlOzt7fGrF8Txh4eH//zzzxcvXjQxMUlKSiKod+TIkVeuXAkLC7O2thYTE3NycupZnIKCgseOHSstLRUREbG1tWWcJV68eHFMTExRUZGxsXFYWBhx+QYGBqmpqZMnT+bh4eHh4cHvAWRLUFCwpaVl27ZtNTU1I0eOtLGxweNZvnz5kydPDA0NVVRU5s2bd/36deJ68bXbvXt3amrqpEmTIiMjCXIuXLjwy5cvO3fupNPp1tbWS5YsIcgsICDQ1tZ25MiRuro6CQmJ6dOnr169GvvIyckpPz/f2dlZQUFh1qxZ54d75QAAAZVJREFUxP972QOFhYX4Nv3pp58QQg8fPhw3blzv1gIAAJwQzKQmJCQEBgYi7Nmy8Ny5ocjR0dHa2trLy2ugAyEy2H4ZEJ5JAwAY6rDnzgUGBnY5xtvb2w/e37IFAAAAwI+AMR4AAAAYngbv79UDYikpKQMdAgAAgEENxnjQh+D6NwAADCCYqwcAAACGJxjjAQAAgOEJxngAAABgeIIxHgAAABieYIwHAAAAhicY4wEAAIDhCcZ4AAAAYHiCMR4AAAAYnmCMBwAAAIYnGOMBAACA4QnGeAAAAGB4gjEeAAAAGJ5gjAcAAACGJxjjAQAAgOEJxngAAABgeIIxHgAAABieYIwHAAAAhicY4wEAAIDhCcZ4AAAAYHiCMR4AAAAYnmCMBwAAAIYnGOMBAACA4QnGeAAAAGB4gjEeAAAAGJ5gjAcAAACGJxjjAQAAgOEJxngAAABgeIIxHgAAABieYIwHAAAAhicY4wEAAIDhCcZ4AAAAYHiCMR4AAAAYnmCMBwAAAIYnGOMBAACA4QnGeAAAAGB4+n8oLlwBJTnCdAAAAABJRU5ErkJggg==}
B 2 950 -10620 1250 -10330 {fill=0}
B 2 1950 -10570 2500 -10330 {fill=0}
B 2 1950 -10620 2250 -10330 {fill=0 dash=5}
B 2 1420 -10620 1720 -10330 {fill=0}
B 2 950 -10210 1250 -9920 {fill=0}
B 2 1950 -10160 2500 -9920 {fill=0}
B 2 1950 -10210 2250 -9920 {fill=0 dash=5}
B 2 1220 -10230 1280 -10180 {}
B 4 2140 -13540 2650 -13200 {fill=0}
B 5 1027.5 -12502.5 1032.5 -12497.5 {name=p dir=inout}
B 5 1027.5 -12442.5 1032.5 -12437.5 {name=m dir=inout}
B 5 1108.75 -12531.25 1111.25 -12528.75 {name=p dir=out}
B 5 1137.5 -12422.5 1142.5 -12417.5 {name=p dir=inout goto=0}
B 5 1137.5 -12682.5 1142.5 -12677.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -12561.25 1411.25 -12558.75 {name=p dir=in}
B 5 1567.5 -12502.5 1572.5 -12497.5 {name=p dir=inout}
B 5 1567.5 -12442.5 1572.5 -12437.5 {name=m dir=inout}
B 5 1648.75 -12531.25 1651.25 -12528.75 {name=p dir=out}
B 5 1677.5 -12422.5 1682.5 -12417.5 {name=p dir=inout goto=0}
B 5 1677.5 -12682.5 1682.5 -12677.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1948.75 -12561.25 1951.25 -12558.75 {name=p dir=in}
B 5 697.5 -12532.5 702.5 -12527.5 {name=g dir=in}
B 5 497.5 -12502.5 502.5 -12497.5 {name=p dir=inout}
B 5 497.5 -12442.5 502.5 -12437.5 {name=m dir=inout}
B 5 578.75 -12531.25 581.25 -12528.75 {name=p dir=out}
B 5 607.5 -12422.5 612.5 -12417.5 {name=p dir=inout goto=0}
B 5 607.5 -12682.5 612.5 -12677.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -12561.25 881.25 -12558.75 {name=p dir=in}
B 5 737.5 -12102.5 742.5 -12097.5 {name=d dir=inout}
B 5 697.5 -12072.5 702.5 -12067.5 {name=g dir=in}
B 5 737.5 -12042.5 742.5 -12037.5 {name=s dir=inout}
B 5 737.5 -12072.5 742.5 -12067.5 {name=b dir=in}
B 5 737.5 -12192.5 742.5 -12187.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -12132.5 742.5 -12127.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -12102.5 832.5 -12097.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -12042.5 832.5 -12037.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -12042.5 502.5 -12037.5 {name=p dir=inout}
B 5 497.5 -11982.5 502.5 -11977.5 {name=m dir=inout}
B 5 578.75 -12071.25 581.25 -12068.75 {name=p dir=out}
B 5 607.5 -11962.5 612.5 -11957.5 {name=p dir=inout goto=0}
B 5 607.5 -12222.5 612.5 -12217.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -12101.25 881.25 -12098.75 {name=p dir=in}
B 5 1277.5 -12102.5 1282.5 -12097.5 {name=d dir=inout}
B 5 1237.5 -12072.5 1242.5 -12067.5 {name=g dir=in}
B 5 1277.5 -12042.5 1282.5 -12037.5 {name=s dir=inout}
B 5 1277.5 -12072.5 1282.5 -12067.5 {name=b dir=in}
B 5 1367.5 -12102.5 1372.5 -12097.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -12042.5 1372.5 -12037.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -12042.5 1042.5 -12037.5 {name=p dir=inout}
B 5 1037.5 -11982.5 1042.5 -11977.5 {name=m dir=inout}
B 5 1118.75 -12071.25 1121.25 -12068.75 {name=p dir=out}
B 5 1147.5 -11962.5 1152.5 -11957.5 {name=p dir=inout goto=0}
B 5 1147.5 -12222.5 1152.5 -12217.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -12101.25 1421.25 -12098.75 {name=p dir=in}
B 5 737.5 -7672.5 742.5 -7667.5 {name=d dir=inout}
B 5 697.5 -7642.5 702.5 -7637.5 {name=g dir=in}
B 5 737.5 -7612.5 742.5 -7607.5 {name=s dir=inout}
B 5 737.5 -7642.5 742.5 -7637.5 {name=b dir=in}
B 5 737.5 -7762.5 742.5 -7757.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -7702.5 742.5 -7697.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -7672.5 832.5 -7667.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -7612.5 832.5 -7607.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -7612.5 502.5 -7607.5 {name=p dir=inout}
B 5 497.5 -7552.5 502.5 -7547.5 {name=m dir=inout}
B 5 578.75 -7641.25 581.25 -7638.75 {name=p dir=out}
B 5 607.5 -7532.5 612.5 -7527.5 {name=p dir=inout goto=0}
B 5 607.5 -7792.5 612.5 -7787.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -7671.25 881.25 -7668.75 {name=p dir=in}
B 5 1277.5 -7672.5 1282.5 -7667.5 {name=d dir=inout}
B 5 1237.5 -7642.5 1242.5 -7637.5 {name=g dir=in}
B 5 1277.5 -7612.5 1282.5 -7607.5 {name=s dir=inout}
B 5 1277.5 -7642.5 1282.5 -7637.5 {name=b dir=in}
B 5 1367.5 -7672.5 1372.5 -7667.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -7612.5 1372.5 -7607.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -7612.5 1042.5 -7607.5 {name=p dir=inout}
B 5 1037.5 -7552.5 1042.5 -7547.5 {name=m dir=inout}
B 5 1118.75 -7641.25 1121.25 -7638.75 {name=p dir=out}
B 5 1147.5 -7532.5 1152.5 -7527.5 {name=p dir=inout goto=0}
B 5 1147.5 -7792.5 1152.5 -7787.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -7671.25 1421.25 -7668.75 {name=p dir=in}
B 5 737.5 -7272.5 742.5 -7267.5 {name=d dir=inout}
B 5 697.5 -7242.5 702.5 -7237.5 {name=g dir=in}
B 5 737.5 -7212.5 742.5 -7207.5 {name=s dir=inout}
B 5 737.5 -7242.5 742.5 -7237.5 {name=b dir=in}
B 5 737.5 -7362.5 742.5 -7357.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -7302.5 742.5 -7297.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -7272.5 832.5 -7267.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -7212.5 832.5 -7207.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -7212.5 502.5 -7207.5 {name=p dir=inout}
B 5 497.5 -7152.5 502.5 -7147.5 {name=m dir=inout}
B 5 578.75 -7241.25 581.25 -7238.75 {name=p dir=out}
B 5 607.5 -7132.5 612.5 -7127.5 {name=p dir=inout goto=0}
B 5 607.5 -7392.5 612.5 -7387.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -7271.25 881.25 -7268.75 {name=p dir=in}
B 5 1277.5 -7272.5 1282.5 -7267.5 {name=d dir=inout}
B 5 1237.5 -7242.5 1242.5 -7237.5 {name=g dir=in}
B 5 1277.5 -7212.5 1282.5 -7207.5 {name=s dir=inout}
B 5 1277.5 -7242.5 1282.5 -7237.5 {name=b dir=in}
B 5 1367.5 -7272.5 1372.5 -7267.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -7212.5 1372.5 -7207.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -7212.5 1042.5 -7207.5 {name=p dir=inout}
B 5 1037.5 -7152.5 1042.5 -7147.5 {name=m dir=inout}
B 5 1118.75 -7241.25 1121.25 -7238.75 {name=p dir=out}
B 5 1147.5 -7132.5 1152.5 -7127.5 {name=p dir=inout goto=0}
B 5 1147.5 -7392.5 1152.5 -7387.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -7271.25 1421.25 -7268.75 {name=p dir=in}
B 5 697.5 -6802.5 702.5 -6797.5 {name=g dir=in}
B 5 497.5 -6772.5 502.5 -6767.5 {name=p dir=inout}
B 5 497.5 -6712.5 502.5 -6707.5 {name=m dir=inout}
B 5 578.75 -6801.25 581.25 -6798.75 {name=p dir=out}
B 5 607.5 -6692.5 612.5 -6687.5 {name=p dir=inout goto=0}
B 5 607.5 -6952.5 612.5 -6947.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1687.5 -6772.5 1692.5 -6767.5 {name=p dir=inout}
B 5 1687.5 -6712.5 1692.5 -6707.5 {name=m dir=inout}
B 5 1768.75 -6801.25 1771.25 -6798.75 {name=p dir=out}
B 5 1797.5 -6692.5 1802.5 -6687.5 {name=p dir=inout goto=0}
B 5 1797.5 -6952.5 1802.5 -6947.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1057.5 -6772.5 1062.5 -6767.5 {name=p dir=inout}
B 5 1057.5 -6712.5 1062.5 -6707.5 {name=m dir=inout}
B 5 1138.75 -6801.25 1141.25 -6798.75 {name=p dir=out}
B 5 1167.5 -6692.5 1172.5 -6687.5 {name=p dir=inout goto=0}
B 5 1167.5 -6952.5 1172.5 -6947.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1027.5 -11672.5 1032.5 -11667.5 {name=p dir=inout}
B 5 1027.5 -11612.5 1032.5 -11607.5 {name=m dir=inout}
B 5 1108.75 -11701.25 1111.25 -11698.75 {name=p dir=out}
B 5 1137.5 -11592.5 1142.5 -11587.5 {name=p dir=inout goto=0}
B 5 1137.5 -11852.5 1142.5 -11847.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -11731.25 1411.25 -11728.75 {name=p dir=in}
B 5 697.5 -11702.5 702.5 -11697.5 {name=g dir=in}
B 5 497.5 -11672.5 502.5 -11667.5 {name=p dir=inout}
B 5 497.5 -11612.5 502.5 -11607.5 {name=m dir=inout}
B 5 578.75 -11701.25 581.25 -11698.75 {name=p dir=out}
B 5 607.5 -11592.5 612.5 -11587.5 {name=p dir=inout goto=0}
B 5 607.5 -11852.5 612.5 -11847.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -11731.25 881.25 -11728.75 {name=p dir=in}
B 5 1767.5 -11732.5 1772.5 -11727.5 {name=d dir=inout}
B 5 1727.5 -11702.5 1732.5 -11697.5 {name=g dir=in}
B 5 1767.5 -11672.5 1772.5 -11667.5 {name=s dir=inout}
B 5 1767.5 -11702.5 1772.5 -11697.5 {name=b dir=in}
B 5 1767.5 -11822.5 1772.5 -11817.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1767.5 -11762.5 1772.5 -11757.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1857.5 -11732.5 1862.5 -11727.5 {name=p dir=inout pinnumber=1}
B 5 1857.5 -11672.5 1862.5 -11667.5 {name=m dir=inout pinnumber=2}
B 5 1527.5 -11672.5 1532.5 -11667.5 {name=p dir=inout}
B 5 1527.5 -11612.5 1532.5 -11607.5 {name=m dir=inout}
B 5 1608.75 -11701.25 1611.25 -11698.75 {name=p dir=out}
B 5 1637.5 -11592.5 1642.5 -11587.5 {name=p dir=inout goto=0}
B 5 1637.5 -11852.5 1642.5 -11847.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1908.75 -11731.25 1911.25 -11728.75 {name=p dir=in}
B 5 1648.75 -13001.25 1651.25 -12998.75 {name=p dir=out}
B 5 1677.5 -12892.5 1682.5 -12887.5 {name=p dir=inout goto=0}
B 5 1677.5 -13152.5 1682.5 -13147.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1948.75 -13031.25 1951.25 -13028.75 {name=p dir=in}
B 5 642.5 -13002.5 647.5 -12997.5 {name=g dir=in}
B 5 442.5 -12972.5 447.5 -12967.5 {name=p dir=inout}
B 5 442.5 -12912.5 447.5 -12907.5 {name=m dir=inout}
B 5 523.75 -13001.25 526.25 -12998.75 {name=p dir=out}
B 5 552.5 -12892.5 557.5 -12887.5 {name=p dir=inout goto=0}
B 5 552.5 -13152.5 557.5 -13147.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 823.75 -13031.25 826.25 -13028.75 {name=p dir=in}
B 5 2108.75 -13001.25 2111.25 -12998.75 {name=p dir=out}
B 5 2137.5 -12892.5 2142.5 -12887.5 {name=p dir=inout goto=0}
B 5 2137.5 -13152.5 2142.5 -13147.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2408.75 -13031.25 2411.25 -13028.75 {name=p dir=in}
B 5 2357.5 -13032.5 2362.5 -13027.5 {name=p dir=inout pinnumber=1}
B 5 2357.5 -12972.5 2362.5 -12967.5 {name=m dir=inout pinnumber=2}
B 5 757.5 -10892.5 762.5 -10887.5 {name=d dir=inout}
B 5 717.5 -10862.5 722.5 -10857.5 {name=g dir=in}
B 5 757.5 -10832.5 762.5 -10827.5 {name=s dir=inout}
B 5 757.5 -10862.5 762.5 -10857.5 {name=b dir=in}
B 5 757.5 -10982.5 762.5 -10977.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -10922.5 762.5 -10917.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 847.5 -10892.5 852.5 -10887.5 {name=p dir=inout pinnumber=1}
B 5 847.5 -10832.5 852.5 -10827.5 {name=m dir=inout pinnumber=2}
B 5 517.5 -10832.5 522.5 -10827.5 {name=p dir=inout}
B 5 517.5 -10772.5 522.5 -10767.5 {name=m dir=inout}
B 5 598.75 -10861.25 601.25 -10858.75 {name=p dir=out}
B 5 627.5 -10752.5 632.5 -10747.5 {name=p dir=inout goto=0}
B 5 627.5 -11012.5 632.5 -11007.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 898.75 -10891.25 901.25 -10888.75 {name=p dir=in}
B 5 1297.5 -10892.5 1302.5 -10887.5 {name=d dir=inout}
B 5 1257.5 -10862.5 1262.5 -10857.5 {name=g dir=in}
B 5 1297.5 -10832.5 1302.5 -10827.5 {name=s dir=inout}
B 5 1297.5 -10862.5 1302.5 -10857.5 {name=b dir=in}
B 5 1297.5 -10982.5 1302.5 -10977.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1297.5 -10922.5 1302.5 -10917.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1387.5 -10892.5 1392.5 -10887.5 {name=p dir=inout pinnumber=1}
B 5 1387.5 -10832.5 1392.5 -10827.5 {name=m dir=inout pinnumber=2}
B 5 1057.5 -10832.5 1062.5 -10827.5 {name=p dir=inout}
B 5 1057.5 -10772.5 1062.5 -10767.5 {name=m dir=inout}
B 5 1138.75 -10861.25 1141.25 -10858.75 {name=p dir=out}
B 5 1167.5 -10752.5 1172.5 -10747.5 {name=p dir=inout goto=0}
B 5 1167.5 -11012.5 1172.5 -11007.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1438.75 -10891.25 1441.25 -10888.75 {name=p dir=in}
B 5 2427.5 -10892.5 2432.5 -10887.5 {name=d dir=inout}
B 5 2387.5 -10862.5 2392.5 -10857.5 {name=g dir=in}
B 5 2427.5 -10832.5 2432.5 -10827.5 {name=s dir=inout}
B 5 2427.5 -10862.5 2432.5 -10857.5 {name=b dir=in}
B 5 2427.5 -10982.5 2432.5 -10977.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -10922.5 2432.5 -10917.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2517.5 -10892.5 2522.5 -10887.5 {name=p dir=inout pinnumber=1}
B 5 2517.5 -10832.5 2522.5 -10827.5 {name=m dir=inout pinnumber=2}
B 5 2187.5 -10832.5 2192.5 -10827.5 {name=p dir=inout}
B 5 2187.5 -10772.5 2192.5 -10767.5 {name=m dir=inout}
B 5 2268.75 -10861.25 2271.25 -10858.75 {name=p dir=out}
B 5 2297.5 -10752.5 2302.5 -10747.5 {name=p dir=inout goto=0}
B 5 2297.5 -11012.5 2302.5 -11007.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2568.75 -10891.25 2571.25 -10888.75 {name=p dir=in}
B 5 817.5 -5962.5 822.5 -5957.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -5902.5 822.5 -5897.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -5902.5 822.5 -5897.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -5842.5 822.5 -5837.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -5842.5 1362.5 -5837.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -6002.5 1902.5 -5997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -5942.5 1902.5 -5937.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -5902.5 1902.5 -5897.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -5842.5 1902.5 -5837.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -5132.5 712.5 -5127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -5072.5 712.5 -5067.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -5132.5 822.5 -5127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -5072.5 822.5 -5067.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -5132.5 932.5 -5127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -5072.5 932.5 -5067.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -5132.5 1252.5 -5127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -5072.5 1252.5 -5067.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -5132.5 1362.5 -5127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -5072.5 1362.5 -5067.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -5132.5 1472.5 -5127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -5072.5 1472.5 -5067.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -5132.5 1792.5 -5127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -5072.5 1792.5 -5067.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -5132.5 1902.5 -5127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -5072.5 1902.5 -5067.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -5132.5 2012.5 -5127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -5072.5 2012.5 -5067.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2317.5 -5132.5 2322.5 -5127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2317.5 -5072.5 2322.5 -5067.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2427.5 -5132.5 2432.5 -5127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -5072.5 2432.5 -5067.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2537.5 -5132.5 2542.5 -5127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2537.5 -5072.5 2542.5 -5067.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -3202.5 712.5 -3197.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -3142.5 712.5 -3137.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -3202.5 822.5 -3197.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -3142.5 822.5 -3137.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -3202.5 932.5 -3197.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -3142.5 932.5 -3137.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -3112.5 712.5 -3107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -3052.5 712.5 -3047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -3112.5 822.5 -3107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -3052.5 822.5 -3047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -3112.5 932.5 -3107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -3052.5 932.5 -3047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -3112.5 1252.5 -3107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -3052.5 1252.5 -3047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -3112.5 1362.5 -3107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -3052.5 1362.5 -3047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -3112.5 1472.5 -3107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -3052.5 1472.5 -3047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -3112.5 1792.5 -3107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -3052.5 1792.5 -3047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -3112.5 1902.5 -3107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -3052.5 1902.5 -3047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -3112.5 2012.5 -3107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -3052.5 2012.5 -3047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1877.5 -4872.5 1882.5 -4867.5 {name=d dir=inout}
B 5 1837.5 -4842.5 1842.5 -4837.5 {name=g dir=in}
B 5 1877.5 -4812.5 1882.5 -4807.5 {name=s dir=inout}
B 5 1877.5 -4842.5 1882.5 -4837.5 {name=b dir=in}
B 5 1108.75 -13001.25 1111.25 -12998.75 {name=p dir=out}
B 5 1137.5 -12892.5 1142.5 -12887.5 {name=p dir=inout goto=0}
B 5 1137.5 -13152.5 1142.5 -13147.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -13031.25 1411.25 -13028.75 {name=p dir=in}
B 5 1027.5 -12972.5 1032.5 -12967.5 {name=p dir=inout}
B 5 1027.5 -12912.5 1032.5 -12907.5 {name=m dir=inout}
B 5 707.5 -2822.5 712.5 -2817.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -2762.5 712.5 -2757.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -2822.5 822.5 -2817.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -2762.5 822.5 -2757.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -2822.5 932.5 -2817.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -2762.5 932.5 -2757.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -2762.5 712.5 -2757.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -2702.5 712.5 -2697.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -2762.5 822.5 -2757.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -2702.5 822.5 -2697.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -2762.5 932.5 -2757.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -2702.5 932.5 -2697.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -2762.5 1252.5 -2757.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -2702.5 1252.5 -2697.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -2762.5 1362.5 -2757.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -2702.5 1362.5 -2697.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -2762.5 1472.5 -2757.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -2702.5 1472.5 -2697.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -2732.5 1792.5 -2727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -2672.5 1792.5 -2667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -2732.5 1902.5 -2727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -2672.5 1902.5 -2667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -2732.5 2012.5 -2727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -2672.5 2012.5 -2667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1757.5 -3512.5 1762.5 -3507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1757.5 -3452.5 1762.5 -3447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1877.5 -3512.5 1882.5 -3507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1877.5 -3452.5 1882.5 -3447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 797.5 -3582.5 802.5 -3577.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -2362.5 822.5 -2357.5 {name=d dir=inout}
B 5 777.5 -2332.5 782.5 -2327.5 {name=g dir=in}
B 5 817.5 -2302.5 822.5 -2297.5 {name=s dir=inout}
B 5 817.5 -2332.5 822.5 -2327.5 {name=b dir=in}
B 5 817.5 -2452.5 822.5 -2447.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -2392.5 822.5 -2387.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 907.5 -2362.5 912.5 -2357.5 {name=p dir=inout pinnumber=1}
B 5 907.5 -2302.5 912.5 -2297.5 {name=m dir=inout pinnumber=2}
B 5 577.5 -2302.5 582.5 -2297.5 {name=p dir=inout}
B 5 577.5 -2242.5 582.5 -2237.5 {name=m dir=inout}
B 5 658.75 -2331.25 661.25 -2328.75 {name=p dir=out}
B 5 687.5 -2222.5 692.5 -2217.5 {name=p dir=inout goto=0}
B 5 687.5 -2482.5 692.5 -2477.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 958.75 -2361.25 961.25 -2358.75 {name=p dir=in}
B 5 1417.5 -2362.5 1422.5 -2357.5 {name=d dir=inout}
B 5 1377.5 -2332.5 1382.5 -2327.5 {name=g dir=in}
B 5 1417.5 -2302.5 1422.5 -2297.5 {name=s dir=inout}
B 5 1417.5 -2332.5 1422.5 -2327.5 {name=b dir=in}
B 5 1417.5 -2452.5 1422.5 -2447.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1417.5 -2392.5 1422.5 -2387.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1177.5 -2302.5 1182.5 -2297.5 {name=p dir=inout}
B 5 1177.5 -2242.5 1182.5 -2237.5 {name=m dir=inout}
B 5 1258.75 -2331.25 1261.25 -2328.75 {name=p dir=out}
B 5 1287.5 -2222.5 1292.5 -2217.5 {name=p dir=inout goto=0}
B 5 1287.5 -2482.5 1292.5 -2477.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1558.75 -2361.25 1561.25 -2358.75 {name=p dir=in}
B 5 2027.5 -2362.5 2032.5 -2357.5 {name=d dir=inout}
B 5 1987.5 -2332.5 1992.5 -2327.5 {name=g dir=in}
B 5 2027.5 -2302.5 2032.5 -2297.5 {name=s dir=inout}
B 5 2027.5 -2332.5 2032.5 -2327.5 {name=b dir=in}
B 5 2027.5 -2452.5 2032.5 -2447.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2027.5 -2392.5 2032.5 -2387.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -2302.5 1792.5 -2297.5 {name=p dir=inout}
B 5 1787.5 -2242.5 1792.5 -2237.5 {name=m dir=inout}
B 5 1868.75 -2331.25 1871.25 -2328.75 {name=p dir=out}
B 5 1897.5 -2222.5 1902.5 -2217.5 {name=p dir=inout goto=0}
B 5 1897.5 -2482.5 1902.5 -2477.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2168.75 -2361.25 2171.25 -2358.75 {name=p dir=in}
B 5 357.5 -9662.5 362.5 -9657.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 557.5 -9662.5 562.5 -9657.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 797.5 -9662.5 802.5 -9657.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1087.5 -9662.5 1092.5 -9657.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1317.5 -9662.5 1322.5 -9657.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 357.5 -9602.5 362.5 -9597.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 557.5 -9602.5 562.5 -9597.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 797.5 -9602.5 802.5 -9597.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1087.5 -9602.5 1092.5 -9597.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1317.5 -9602.5 1322.5 -9597.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1607.5 -9662.5 1612.5 -9657.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1607.5 -9602.5 1612.5 -9597.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1847.5 -9662.5 1852.5 -9657.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1847.5 -9602.5 1852.5 -9597.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2147.5 -9662.5 2152.5 -9657.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2147.5 -9602.5 2152.5 -9597.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -6422.5 762.5 -6417.5 {name=d dir=inout}
B 5 717.5 -6392.5 722.5 -6387.5 {name=g dir=in}
B 5 757.5 -6362.5 762.5 -6357.5 {name=s dir=inout}
B 5 757.5 -6392.5 762.5 -6387.5 {name=b dir=in}
B 5 757.5 -6512.5 762.5 -6507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -6452.5 762.5 -6447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 517.5 -6362.5 522.5 -6357.5 {name=p dir=inout}
B 5 517.5 -6302.5 522.5 -6297.5 {name=m dir=inout}
B 5 598.75 -6391.25 601.25 -6388.75 {name=p dir=out}
B 5 627.5 -6282.5 632.5 -6277.5 {name=p dir=inout goto=0}
B 5 627.5 -6542.5 632.5 -6537.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 898.75 -6421.25 901.25 -6418.75 {name=p dir=in}
B 5 1317.5 -6422.5 1322.5 -6417.5 {name=d dir=inout}
B 5 1277.5 -6392.5 1282.5 -6387.5 {name=g dir=in}
B 5 1317.5 -6362.5 1322.5 -6357.5 {name=s dir=inout}
B 5 1317.5 -6392.5 1322.5 -6387.5 {name=b dir=in}
B 5 1317.5 -6512.5 1322.5 -6507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1317.5 -6452.5 1322.5 -6447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1077.5 -6362.5 1082.5 -6357.5 {name=p dir=inout}
B 5 1077.5 -6302.5 1082.5 -6297.5 {name=m dir=inout}
B 5 1158.75 -6391.25 1161.25 -6388.75 {name=p dir=out}
B 5 1187.5 -6282.5 1192.5 -6277.5 {name=p dir=inout goto=0}
B 5 1187.5 -6542.5 1192.5 -6537.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1458.75 -6421.25 1461.25 -6418.75 {name=p dir=in}
B 5 702.5 -11312.5 707.5 -11307.5 {name=d dir=inout}
B 5 662.5 -11282.5 667.5 -11277.5 {name=g dir=in}
B 5 702.5 -11252.5 707.5 -11247.5 {name=s dir=inout}
B 5 702.5 -11282.5 707.5 -11277.5 {name=b dir=in}
B 5 702.5 -11402.5 707.5 -11397.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 702.5 -11342.5 707.5 -11337.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 792.5 -11312.5 797.5 -11307.5 {name=p dir=inout pinnumber=1}
B 5 792.5 -11252.5 797.5 -11247.5 {name=m dir=inout pinnumber=2}
B 5 462.5 -11252.5 467.5 -11247.5 {name=p dir=inout}
B 5 462.5 -11192.5 467.5 -11187.5 {name=m dir=inout}
B 5 543.75 -11281.25 546.25 -11278.75 {name=p dir=out}
B 5 572.5 -11172.5 577.5 -11167.5 {name=p dir=inout goto=0}
B 5 572.5 -11432.5 577.5 -11427.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 843.75 -11311.25 846.25 -11308.75 {name=p dir=in}
B 5 1267.5 -11312.5 1272.5 -11307.5 {name=d dir=inout}
B 5 1227.5 -11282.5 1232.5 -11277.5 {name=g dir=in}
B 5 1267.5 -11252.5 1272.5 -11247.5 {name=s dir=inout}
B 5 1267.5 -11282.5 1272.5 -11277.5 {name=b dir=in}
B 5 1267.5 -11402.5 1272.5 -11397.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1267.5 -11342.5 1272.5 -11337.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -11312.5 1362.5 -11307.5 {name=p dir=inout pinnumber=1}
B 5 1357.5 -11252.5 1362.5 -11247.5 {name=m dir=inout pinnumber=2}
B 5 1027.5 -11252.5 1032.5 -11247.5 {name=p dir=inout}
B 5 1027.5 -11192.5 1032.5 -11187.5 {name=m dir=inout}
B 5 1108.75 -11281.25 1111.25 -11278.75 {name=p dir=out}
B 5 1137.5 -11172.5 1142.5 -11167.5 {name=p dir=inout goto=0}
B 5 1137.5 -11432.5 1142.5 -11427.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -11311.25 1411.25 -11308.75 {name=p dir=in}
B 5 1767.5 -11312.5 1772.5 -11307.5 {name=d dir=inout}
B 5 1727.5 -11282.5 1732.5 -11277.5 {name=g dir=in}
B 5 1767.5 -11252.5 1772.5 -11247.5 {name=s dir=inout}
B 5 1767.5 -11282.5 1772.5 -11277.5 {name=b dir=in}
B 5 1767.5 -11402.5 1772.5 -11397.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1767.5 -11342.5 1772.5 -11337.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1857.5 -11312.5 1862.5 -11307.5 {name=p dir=inout pinnumber=1}
B 5 1857.5 -11252.5 1862.5 -11247.5 {name=m dir=inout pinnumber=2}
B 5 1527.5 -11252.5 1532.5 -11247.5 {name=p dir=inout}
B 5 1527.5 -11192.5 1532.5 -11187.5 {name=m dir=inout}
B 5 1608.75 -11281.25 1611.25 -11278.75 {name=p dir=out}
B 5 1637.5 -11172.5 1642.5 -11167.5 {name=p dir=inout goto=0}
B 5 1637.5 -11432.5 1642.5 -11427.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1908.75 -11311.25 1911.25 -11308.75 {name=p dir=in}
B 5 2257.5 -11312.5 2262.5 -11307.5 {name=d dir=inout}
B 5 2217.5 -11282.5 2222.5 -11277.5 {name=g dir=in}
B 5 2257.5 -11252.5 2262.5 -11247.5 {name=s dir=inout}
B 5 2257.5 -11282.5 2262.5 -11277.5 {name=b dir=in}
B 5 2257.5 -11402.5 2262.5 -11397.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2257.5 -11342.5 2262.5 -11337.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2347.5 -11312.5 2352.5 -11307.5 {name=p dir=inout pinnumber=1}
B 5 2347.5 -11252.5 2352.5 -11247.5 {name=m dir=inout pinnumber=2}
B 5 2017.5 -11252.5 2022.5 -11247.5 {name=p dir=inout}
B 5 2017.5 -11192.5 2022.5 -11187.5 {name=m dir=inout}
B 5 2098.75 -11281.25 2101.25 -11278.75 {name=p dir=out}
B 5 2127.5 -11172.5 2132.5 -11167.5 {name=p dir=inout goto=0}
B 5 2127.5 -11432.5 2132.5 -11427.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2398.75 -11311.25 2401.25 -11308.75 {name=p dir=in}
B 5 417.5 -9662.5 422.5 -9657.5 {name=p dir=inout pinnumber=1}
B 5 417.5 -9602.5 422.5 -9597.5 {name=m dir=inout pinnumber=2}
B 5 617.5 -9662.5 622.5 -9657.5 {name=p dir=inout pinnumber=1}
B 5 617.5 -9602.5 622.5 -9597.5 {name=m dir=inout pinnumber=2}
B 5 857.5 -9662.5 862.5 -9657.5 {name=p dir=inout pinnumber=1}
B 5 857.5 -9602.5 862.5 -9597.5 {name=m dir=inout pinnumber=2}
B 5 1147.5 -9662.5 1152.5 -9657.5 {name=p dir=inout pinnumber=1}
B 5 1147.5 -9602.5 1152.5 -9597.5 {name=m dir=inout pinnumber=2}
B 5 1377.5 -9662.5 1382.5 -9657.5 {name=p dir=inout pinnumber=1}
B 5 1377.5 -9602.5 1382.5 -9597.5 {name=m dir=inout pinnumber=2}
B 5 1667.5 -9662.5 1672.5 -9657.5 {name=p dir=inout pinnumber=1}
B 5 1667.5 -9602.5 1672.5 -9597.5 {name=m dir=inout pinnumber=2}
B 5 1907.5 -9662.5 1912.5 -9657.5 {name=p dir=inout pinnumber=1}
B 5 1907.5 -9602.5 1912.5 -9597.5 {name=m dir=inout pinnumber=2}
B 5 2207.5 -9662.5 2212.5 -9657.5 {name=p dir=inout pinnumber=1}
B 5 2207.5 -9602.5 2212.5 -9597.5 {name=m dir=inout pinnumber=2}
B 5 2357.5 -9662.5 2362.5 -9657.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2357.5 -9602.5 2362.5 -9597.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2417.5 -9662.5 2422.5 -9657.5 {name=p dir=inout pinnumber=1}
B 5 2417.5 -9602.5 2422.5 -9597.5 {name=m dir=inout pinnumber=2}
B 5 1667.5 -1692.5 1672.5 -1687.5 {name=CODE[5:0] dir=out }
B 5 2197.5 -1692.5 2202.5 -1687.5 {name=CODE[5:0] dir=out }
B 5 1968.75 -1691.25 1971.25 -1688.75 {name=p dir=in}
B 5 1968.75 -1671.25 1971.25 -1668.75 {name=p dir=in}
B 5 1968.75 -1651.25 1971.25 -1648.75 {name=p dir=in}
B 5 1968.75 -1631.25 1971.25 -1628.75 {name=p dir=in}
B 5 578.75 -1321.25 581.25 -1318.75 {name=p dir=in}
B 5 537.5 -992.5 542.5 -987.5 {name=d dir=inout}
B 5 497.5 -1022.5 502.5 -1017.5 {name=g dir=in}
B 5 537.5 -1052.5 542.5 -1047.5 {name=s dir=inout}
B 5 537.5 -1022.5 542.5 -1017.5 {name=b dir=in}
B 5 667.5 -992.5 672.5 -987.5 {name=d dir=inout}
B 5 627.5 -1022.5 632.5 -1017.5 {name=g dir=in}
B 5 667.5 -1052.5 672.5 -1047.5 {name=s dir=inout}
B 5 667.5 -1022.5 672.5 -1017.5 {name=b dir=in}
B 5 537.5 -852.5 542.5 -847.5 {name=d dir=inout}
B 5 497.5 -822.5 502.5 -817.5 {name=g dir=in}
B 5 537.5 -792.5 542.5 -787.5 {name=s dir=inout}
B 5 537.5 -822.5 542.5 -817.5 {name=b dir=in}
B 5 537.5 -772.5 542.5 -767.5 {name=d dir=inout}
B 5 497.5 -742.5 502.5 -737.5 {name=g dir=in}
B 5 537.5 -712.5 542.5 -707.5 {name=s dir=inout}
B 5 537.5 -742.5 542.5 -737.5 {name=b dir=in}
B 5 2237.5 -992.5 2242.5 -987.5 {name=d dir=inout}
B 5 2197.5 -1022.5 2202.5 -1017.5 {name=g dir=in}
B 5 2237.5 -1052.5 2242.5 -1047.5 {name=s dir=inout}
B 5 2237.5 -1022.5 2242.5 -1017.5 {name=b dir=in}
B 5 2367.5 -992.5 2372.5 -987.5 {name=d dir=inout}
B 5 2327.5 -1022.5 2332.5 -1017.5 {name=g dir=in}
B 5 2367.5 -1052.5 2372.5 -1047.5 {name=s dir=inout}
B 5 2367.5 -1022.5 2372.5 -1017.5 {name=b dir=in}
B 5 2237.5 -852.5 2242.5 -847.5 {name=d dir=inout}
B 5 2197.5 -822.5 2202.5 -817.5 {name=g dir=in}
B 5 2237.5 -792.5 2242.5 -787.5 {name=s dir=inout}
B 5 2237.5 -822.5 2242.5 -817.5 {name=b dir=in}
B 5 2237.5 -772.5 2242.5 -767.5 {name=d dir=inout}
B 5 2197.5 -742.5 2202.5 -737.5 {name=g dir=in}
B 5 2237.5 -712.5 2242.5 -707.5 {name=s dir=inout}
B 5 2237.5 -742.5 2242.5 -737.5 {name=b dir=in}
B 6 530 -10620 830 -10330 {fill=0}
B 6 530 -10210 830 -9920 {fill=0}
A 1 1220 -4500 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1340 -4500 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1850 -4500 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1970 -4500 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1280 -4220 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1910 -4220 5.590169943749475 333.434948822922 360 {fill=1}
A 1 740 -3820 5.590169943749475 333.434948822922 360 {fill=1}
A 2 1570 -12940 15 270 360 {}
A 2 2030 -12940 15 270 360 {}
A 2 530 -8820 15 270 360 {}
A 2 1005 -8820 15 270 360 {}
A 2 1640 -9030 15 180 360 {}
A 2 530 -8390 15 270 360 {}
A 2 980 -8390 15 270 360 {}
A 2 1840 -8390 15 270 360 {}
A 2 1600 -540 5 0 360 {}
A 2 1700 -600 5 0 360 {}
A 2 1730 -480 5 0 360 {}
A 2 1820 -540 5 0 360 {}
A 2 1920 -600 5 0 360 {}
A 2 2040 -500 5 0 360 {}
A 2 2160 -540 5 0 360 {}
A 2 2260 -600 5 0 360 {}
A 2 2380 -500 5 0 360 {}
A 2 2300 -450 5 0 360 {}
A 2 700 -178.75 5 0 360 {}
A 2 800 -238.75 5 0 360 {}
A 2 830 -118.75 5 0 360 {}
A 2 1460 -240 5 0 360 {}
A 2 1490 -120 5 0 360 {}
A 2 1360 -180 5 0 360 {}
A 2 1780 -240 5 0 360 {}
A 2 1810 -120 5 0 360 {}
A 2 1680 -180 5 0 360 {}
A 2 2060 -230 5 0 360 {}
A 2 2090 -110 5 0 360 {}
A 2 1960 -170 5 0 360 {}
A 2 2220 -230 5 0 360 {}
A 4 1030 -12470 15 270 360 {}
A 4 1570 -12470 15 270 360 {}
A 4 500 -12470 15 270 360 {}
A 4 500 -12010 15 270 360 {}
A 4 1040 -12010 15 270 360 {}
A 4 500 -7580 15 270 360 {}
A 4 1040 -7580 15 270 360 {}
A 4 500 -7180 15 270 360 {}
A 4 1040 -7180 15 270 360 {}
A 4 500 -6740 15 270 360 {}
A 4 1690 -6740 15 270 360 {}
A 4 1060 -6740 15 270 360 {}
A 4 1030 -11640 15 270 360 {}
A 4 500 -11640 15 270 360 {}
A 4 1530 -11640 15 270 360 {}
A 4 445 -12940 15 270 360 {}
A 4 520 -10800 15 270 360 {}
A 4 1060 -10800 15 270 360 {}
A 4 2190 -10800 15 270 360 {}
A 4 1030 -12940 15 270 360 {}
A 4 580 -2270 15 270 360 {}
A 4 1180 -2270 15 270 360 {}
A 4 1790 -2270 15 270 360 {}
A 4 520 -6330 15 270 360 {}
A 4 1080 -6330 15 270 360 {}
A 4 465 -11220 15 270 360 {}
A 4 1030 -11220 15 270 360 {}
A 4 1530 -11220 15 270 360 {}
A 4 2020 -11220 15 270 360 {}
A 5 1360 -5580 5.590169943749475 333.434948822922 360 {fill=1}
P 1 14 920 -12390 942.5 -12390 947.5 -12390 947.5 -12385 947.5 -12342.5 940 -12317.5 935 -12317.5 905 -12317.5 900 -12317.5 892.5 -12342.5 892.5 -12385 892.5 -12390 897.5 -12390 920 -12390 {bezier=1}
P 1 14 935 -12387.5 940 -12387.5 945 -12387.5 945 -12382.5 945 -12362.5 945 -12357.5 940 -12357.5 930 -12357.5 925 -12357.5 925 -12362.5 925 -12382.5 925 -12387.5 930 -12387.5 935 -12387.5 {bezier=1}
P 1 5 917.5 -12385 922.5 -12385 922.5 -12360 917.5 -12360 917.5 -12385 {}
P 1 14 1350 -12390 1372.5 -12390 1377.5 -12390 1377.5 -12385 1377.5 -12342.5 1370 -12317.5 1365 -12317.5 1335 -12317.5 1330 -12317.5 1322.5 -12342.5 1322.5 -12385 1322.5 -12390 1327.5 -12390 1350 -12390 {bezier=1}
P 1 14 1365 -12387.5 1370 -12387.5 1375 -12387.5 1375 -12382.5 1375 -12362.5 1375 -12357.5 1370 -12357.5 1360 -12357.5 1355 -12357.5 1355 -12362.5 1355 -12382.5 1355 -12387.5 1360 -12387.5 1365 -12387.5 {bezier=1}
P 1 5 1347.5 -12385 1352.5 -12385 1352.5 -12360 1347.5 -12360 1347.5 -12385 {}
P 1 14 2120 -12390 2142.5 -12390 2147.5 -12390 2147.5 -12385 2147.5 -12342.5 2140 -12317.5 2135 -12317.5 2105 -12317.5 2100 -12317.5 2092.5 -12342.5 2092.5 -12385 2092.5 -12390 2097.5 -12390 2120 -12390 {bezier=1}
P 1 14 2135 -12387.5 2140 -12387.5 2145 -12387.5 2145 -12382.5 2145 -12362.5 2145 -12357.5 2140 -12357.5 2130 -12357.5 2125 -12357.5 2125 -12362.5 2125 -12382.5 2125 -12387.5 2130 -12387.5 2135 -12387.5 {bezier=1}
P 1 5 2117.5 -12385 2122.5 -12385 2122.5 -12360 2117.5 -12360 2117.5 -12385 {}
P 1 14 1420 -12200 1442.5 -12200 1447.5 -12200 1447.5 -12195 1447.5 -12152.5 1440 -12127.5 1435 -12127.5 1405 -12127.5 1400 -12127.5 1392.5 -12152.5 1392.5 -12195 1392.5 -12200 1397.5 -12200 1420 -12200 {bezier=1}
P 1 14 1435 -12197.5 1440 -12197.5 1445 -12197.5 1445 -12192.5 1445 -12172.5 1445 -12167.5 1440 -12167.5 1430 -12167.5 1425 -12167.5 1425 -12172.5 1425 -12192.5 1425 -12197.5 1430 -12197.5 1435 -12197.5 {bezier=1}
P 1 5 1417.5 -12195 1422.5 -12195 1422.5 -12170 1417.5 -12170 1417.5 -12195 {}
P 1 14 1440 -7780 1462.5 -7780 1467.5 -7780 1467.5 -7775 1467.5 -7732.5 1460 -7707.5 1455 -7707.5 1425 -7707.5 1420 -7707.5 1412.5 -7732.5 1412.5 -7775 1412.5 -7780 1417.5 -7780 1440 -7780 {bezier=1}
P 1 14 1455 -7777.5 1460 -7777.5 1465 -7777.5 1465 -7772.5 1465 -7752.5 1465 -7747.5 1460 -7747.5 1450 -7747.5 1445 -7747.5 1445 -7752.5 1445 -7772.5 1445 -7777.5 1450 -7777.5 1455 -7777.5 {bezier=1}
P 1 5 1437.5 -7775 1442.5 -7775 1442.5 -7750 1437.5 -7750 1437.5 -7775 {}
P 1 10 1520 -7735 1545 -7735 1555 -7725 1555 -7695 1545 -7685 1495 -7685 1485 -7695 1485 -7725 1495 -7735 1520 -7735 {bezier=1}
P 1 10 1520 -7740 1550 -7740 1560 -7730 1560 -7690 1550 -7680 1490 -7680 1480 -7690 1480 -7730 1490 -7740 1520 -7740 {bezier=1}
P 1 14 1440 -7380 1462.5 -7380 1467.5 -7380 1467.5 -7375 1467.5 -7332.5 1460 -7307.5 1455 -7307.5 1425 -7307.5 1420 -7307.5 1412.5 -7332.5 1412.5 -7375 1412.5 -7380 1417.5 -7380 1440 -7380 {bezier=1}
P 1 14 1455 -7377.5 1460 -7377.5 1465 -7377.5 1465 -7372.5 1465 -7352.5 1465 -7347.5 1460 -7347.5 1450 -7347.5 1445 -7347.5 1445 -7352.5 1445 -7372.5 1445 -7377.5 1450 -7377.5 1455 -7377.5 {bezier=1}
P 1 5 1437.5 -7375 1442.5 -7375 1442.5 -7350 1437.5 -7350 1437.5 -7375 {}
P 1 10 1520 -7805 1545 -7805 1555 -7795 1555 -7765 1545 -7755 1495 -7755 1485 -7765 1485 -7795 1495 -7805 1520 -7805 {bezier=1}
P 1 10 1520 -7810 1550 -7810 1560 -7800 1560 -7760 1550 -7750 1490 -7750 1480 -7760 1480 -7800 1490 -7810 1520 -7810 {bezier=1}
P 1 14 950 -6700 972.5 -6700 977.5 -6700 977.5 -6695 977.5 -6652.5 970 -6627.5 965 -6627.5 935 -6627.5 930 -6627.5 922.5 -6652.5 922.5 -6695 922.5 -6700 927.5 -6700 950 -6700 {bezier=1}
P 1 14 965 -6697.5 970 -6697.5 975 -6697.5 975 -6692.5 975 -6672.5 975 -6667.5 970 -6667.5 960 -6667.5 955 -6667.5 955 -6672.5 955 -6692.5 955 -6697.5 960 -6697.5 965 -6697.5 {bezier=1}
P 1 5 947.5 -6695 952.5 -6695 952.5 -6670 947.5 -6670 947.5 -6695 {}
P 1 14 1450 -6710 1472.5 -6710 1477.5 -6710 1477.5 -6705 1477.5 -6662.5 1470 -6637.5 1465 -6637.5 1435 -6637.5 1430 -6637.5 1422.5 -6662.5 1422.5 -6705 1422.5 -6710 1427.5 -6710 1450 -6710 {bezier=1}
P 1 14 1465 -6707.5 1470 -6707.5 1475 -6707.5 1475 -6702.5 1475 -6682.5 1475 -6677.5 1470 -6677.5 1460 -6677.5 1455 -6677.5 1455 -6682.5 1455 -6702.5 1455 -6707.5 1460 -6707.5 1465 -6707.5 {bezier=1}
P 1 5 1447.5 -6705 1452.5 -6705 1452.5 -6680 1447.5 -6680 1447.5 -6705 {}
P 1 10 1540 -6695 1565 -6695 1575 -6685 1575 -6655 1565 -6645 1515 -6645 1505 -6655 1505 -6685 1515 -6695 1540 -6695 {bezier=1}
P 1 10 1540 -6700 1570 -6700 1580 -6690 1580 -6650 1570 -6640 1510 -6640 1500 -6650 1500 -6690 1510 -6700 1540 -6700 {bezier=1}
P 1 14 920 -11560 942.5 -11560 947.5 -11560 947.5 -11555 947.5 -11512.5 940 -11487.5 935 -11487.5 905 -11487.5 900 -11487.5 892.5 -11512.5 892.5 -11555 892.5 -11560 897.5 -11560 920 -11560 {bezier=1}
P 1 14 935 -11557.5 940 -11557.5 945 -11557.5 945 -11552.5 945 -11532.5 945 -11527.5 940 -11527.5 930 -11527.5 925 -11527.5 925 -11532.5 925 -11552.5 925 -11557.5 930 -11557.5 935 -11557.5 {bezier=1}
P 1 5 917.5 -11555 922.5 -11555 922.5 -11530 917.5 -11530 917.5 -11555 {}
P 1 14 1350 -11560 1372.5 -11560 1377.5 -11560 1377.5 -11555 1377.5 -11512.5 1370 -11487.5 1365 -11487.5 1335 -11487.5 1330 -11487.5 1322.5 -11512.5 1322.5 -11555 1322.5 -11560 1327.5 -11560 1350 -11560 {bezier=1}
P 1 14 1365 -11557.5 1370 -11557.5 1375 -11557.5 1375 -11552.5 1375 -11532.5 1375 -11527.5 1370 -11527.5 1360 -11527.5 1355 -11527.5 1355 -11532.5 1355 -11552.5 1355 -11557.5 1360 -11557.5 1365 -11557.5 {bezier=1}
P 1 5 1347.5 -11555 1352.5 -11555 1352.5 -11530 1347.5 -11530 1347.5 -11555 {}
P 1 14 2120 -11560 2142.5 -11560 2147.5 -11560 2147.5 -11555 2147.5 -11512.5 2140 -11487.5 2135 -11487.5 2105 -11487.5 2100 -11487.5 2092.5 -11512.5 2092.5 -11555 2092.5 -11560 2097.5 -11560 2120 -11560 {bezier=1}
P 1 14 2135 -11557.5 2140 -11557.5 2145 -11557.5 2145 -11552.5 2145 -11532.5 2145 -11527.5 2140 -11527.5 2130 -11527.5 2125 -11527.5 2125 -11532.5 2125 -11552.5 2125 -11557.5 2130 -11557.5 2135 -11557.5 {bezier=1}
P 1 5 2117.5 -11555 2122.5 -11555 2122.5 -11530 2117.5 -11530 2117.5 -11555 {}
P 1 10 1270 -11555 1295 -11555 1305 -11545 1305 -11515 1295 -11505 1245 -11505 1235 -11515 1235 -11545 1245 -11555 1270 -11555 {bezier=1}
P 1 10 1270 -11560 1300 -11560 1310 -11550 1310 -11510 1300 -11500 1240 -11500 1230 -11510 1230 -11550 1240 -11560 1270 -11560 {bezier=1}
P 1 14 865 -12860 887.5 -12860 892.5 -12860 892.5 -12855 892.5 -12812.5 885 -12787.5 880 -12787.5 850 -12787.5 845 -12787.5 837.5 -12812.5 837.5 -12855 837.5 -12860 842.5 -12860 865 -12860 {bezier=1}
P 1 14 880 -12857.5 885 -12857.5 890 -12857.5 890 -12852.5 890 -12832.5 890 -12827.5 885 -12827.5 875 -12827.5 870 -12827.5 870 -12832.5 870 -12852.5 870 -12857.5 875 -12857.5 880 -12857.5 {bezier=1}
P 1 5 862.5 -12855 867.5 -12855 867.5 -12830 862.5 -12830 862.5 -12855 {}
P 1 14 1630 -12850 1652.5 -12850 1657.5 -12850 1657.5 -12845 1657.5 -12802.5 1650 -12777.5 1645 -12777.5 1615 -12777.5 1610 -12777.5 1602.5 -12802.5 1602.5 -12845 1602.5 -12850 1607.5 -12850 1630 -12850 {bezier=1}
P 1 14 1645 -12847.5 1650 -12847.5 1655 -12847.5 1655 -12842.5 1655 -12822.5 1655 -12817.5 1650 -12817.5 1640 -12817.5 1635 -12817.5 1635 -12822.5 1635 -12842.5 1635 -12847.5 1640 -12847.5 1645 -12847.5 {bezier=1}
P 1 5 1627.5 -12845 1632.5 -12845 1632.5 -12820 1627.5 -12820 1627.5 -12845 {}
P 1 10 1710 -12835 1735 -12835 1745 -12825 1745 -12795 1735 -12785 1685 -12785 1675 -12795 1675 -12825 1685 -12835 1710 -12835 {bezier=1}
P 1 10 1710 -12840 1740 -12840 1750 -12830 1750 -12790 1740 -12780 1680 -12780 1670 -12790 1670 -12830 1680 -12840 1710 -12840 {bezier=1}
P 1 14 2410 -12840 2432.5 -12840 2437.5 -12840 2437.5 -12835 2437.5 -12792.5 2430 -12767.5 2425 -12767.5 2395 -12767.5 2390 -12767.5 2382.5 -12792.5 2382.5 -12835 2382.5 -12840 2387.5 -12840 2410 -12840 {bezier=1}
P 1 14 2425 -12837.5 2430 -12837.5 2435 -12837.5 2435 -12832.5 2435 -12812.5 2435 -12807.5 2430 -12807.5 2420 -12807.5 2415 -12807.5 2415 -12812.5 2415 -12832.5 2415 -12837.5 2420 -12837.5 2425 -12837.5 {bezier=1}
P 1 5 2407.5 -12835 2412.5 -12835 2412.5 -12810 2407.5 -12810 2407.5 -12835 {}
P 1 10 2490 -12825 2515 -12825 2525 -12815 2525 -12785 2515 -12775 2465 -12775 2455 -12785 2455 -12815 2465 -12825 2490 -12825 {bezier=1}
P 1 10 2490 -12830 2520 -12830 2530 -12820 2530 -12780 2520 -12770 2460 -12770 2450 -12780 2450 -12820 2460 -12830 2490 -12830 {bezier=1}
P 1 14 690 -10980 712.5 -10980 717.5 -10980 717.5 -10975 717.5 -10932.5 710 -10907.5 705 -10907.5 675 -10907.5 670 -10907.5 662.5 -10932.5 662.5 -10975 662.5 -10980 667.5 -10980 690 -10980 {bezier=1}
P 1 14 705 -10977.5 710 -10977.5 715 -10977.5 715 -10972.5 715 -10952.5 715 -10947.5 710 -10947.5 700 -10947.5 695 -10947.5 695 -10952.5 695 -10972.5 695 -10977.5 700 -10977.5 705 -10977.5 {bezier=1}
P 1 5 687.5 -10975 692.5 -10975 692.5 -10950 687.5 -10950 687.5 -10975 {}
P 1 14 1350 -11000 1372.5 -11000 1377.5 -11000 1377.5 -10995 1377.5 -10952.5 1370 -10927.5 1365 -10927.5 1335 -10927.5 1330 -10927.5 1322.5 -10952.5 1322.5 -10995 1322.5 -11000 1327.5 -11000 1350 -11000 {bezier=1}
P 1 14 1365 -10997.5 1370 -10997.5 1375 -10997.5 1375 -10992.5 1375 -10972.5 1375 -10967.5 1370 -10967.5 1360 -10967.5 1355 -10967.5 1355 -10972.5 1355 -10992.5 1355 -10997.5 1360 -10997.5 1365 -10997.5 {bezier=1}
P 1 5 1347.5 -10995 1352.5 -10995 1352.5 -10970 1347.5 -10970 1347.5 -10995 {}
P 1 14 2540 -11050 2562.5 -11050 2567.5 -11050 2567.5 -11045 2567.5 -11002.5 2560 -10977.5 2555 -10977.5 2525 -10977.5 2520 -10977.5 2512.5 -11002.5 2512.5 -11045 2512.5 -11050 2517.5 -11050 2540 -11050 {bezier=1}
P 1 14 2555 -11047.5 2560 -11047.5 2565 -11047.5 2565 -11042.5 2565 -11022.5 2565 -11017.5 2560 -11017.5 2550 -11017.5 2545 -11017.5 2545 -11022.5 2545 -11042.5 2545 -11047.5 2550 -11047.5 2555 -11047.5 {bezier=1}
P 1 5 2537.5 -11045 2542.5 -11045 2542.5 -11020 2537.5 -11020 2537.5 -11045 {}
P 1 14 1430 -5920 1452.5 -5920 1457.5 -5920 1457.5 -5915 1457.5 -5872.5 1450 -5847.5 1445 -5847.5 1415 -5847.5 1410 -5847.5 1402.5 -5872.5 1402.5 -5915 1402.5 -5920 1407.5 -5920 1430 -5920 {bezier=1}
P 1 14 1445 -5917.5 1450 -5917.5 1455 -5917.5 1455 -5912.5 1455 -5892.5 1455 -5887.5 1450 -5887.5 1440 -5887.5 1435 -5887.5 1435 -5892.5 1435 -5912.5 1435 -5917.5 1440 -5917.5 1445 -5917.5 {bezier=1}
P 1 5 1427.5 -5915 1432.5 -5915 1432.5 -5890 1427.5 -5890 1427.5 -5915 {}
P 1 10 1430 -6075 1455 -6075 1465 -6065 1465 -6035 1455 -6025 1405 -6025 1395 -6035 1395 -6065 1405 -6075 1430 -6075 {bezier=1}
P 1 10 1430 -6080 1460 -6080 1470 -6070 1470 -6030 1460 -6020 1400 -6020 1390 -6030 1390 -6070 1400 -6080 1430 -6080 {bezier=1}
P 1 10 1430 -5995 1455 -5995 1465 -5985 1465 -5955 1455 -5945 1405 -5945 1395 -5955 1395 -5985 1405 -5995 1430 -5995 {bezier=1}
P 1 10 1430 -6000 1460 -6000 1470 -5990 1470 -5950 1460 -5940 1400 -5940 1390 -5950 1390 -5990 1400 -6000 1430 -6000 {bezier=1}
P 1 14 2080 -3190 2102.5 -3190 2107.5 -3190 2107.5 -3185 2107.5 -3142.5 2100 -3117.5 2095 -3117.5 2065 -3117.5 2060 -3117.5 2052.5 -3142.5 2052.5 -3185 2052.5 -3190 2057.5 -3190 2080 -3190 {bezier=1}
P 1 14 2095 -3187.5 2100 -3187.5 2105 -3187.5 2105 -3182.5 2105 -3162.5 2105 -3157.5 2100 -3157.5 2090 -3157.5 2085 -3157.5 2085 -3162.5 2085 -3182.5 2085 -3187.5 2090 -3187.5 2095 -3187.5 {bezier=1}
P 1 5 2077.5 -3185 2082.5 -3185 2082.5 -3160 2077.5 -3160 2077.5 -3185 {}
P 1 10 2080 -3255 2105 -3255 2115 -3245 2115 -3215 2105 -3205 2055 -3205 2045 -3215 2045 -3245 2055 -3255 2080 -3255 {bezier=1}
P 1 10 2080 -3260 2110 -3260 2120 -3250 2120 -3210 2110 -3200 2050 -3200 2040 -3210 2040 -3250 2050 -3260 2080 -3260 {bezier=1}
P 1 14 1570 -3160 1592.5 -3160 1597.5 -3160 1597.5 -3155 1597.5 -3112.5 1590 -3087.5 1585 -3087.5 1555 -3087.5 1550 -3087.5 1542.5 -3112.5 1542.5 -3155 1542.5 -3160 1547.5 -3160 1570 -3160 {bezier=1}
P 1 14 1585 -3157.5 1590 -3157.5 1595 -3157.5 1595 -3152.5 1595 -3132.5 1595 -3127.5 1590 -3127.5 1580 -3127.5 1575 -3127.5 1575 -3132.5 1575 -3152.5 1575 -3157.5 1580 -3157.5 1585 -3157.5 {bezier=1}
P 1 5 1567.5 -3155 1572.5 -3155 1572.5 -3130 1567.5 -3130 1567.5 -3155 {}
P 1 14 1430 -5560 1452.5 -5560 1457.5 -5560 1457.5 -5555 1457.5 -5512.5 1450 -5487.5 1445 -5487.5 1415 -5487.5 1410 -5487.5 1402.5 -5512.5 1402.5 -5555 1402.5 -5560 1407.5 -5560 1430 -5560 {bezier=1}
P 1 14 1415 -5557.5 1410 -5557.5 1405 -5557.5 1405 -5552.5 1405 -5532.5 1405 -5527.5 1410 -5527.5 1420 -5527.5 1425 -5527.5 1425 -5532.5 1425 -5552.5 1425 -5557.5 1420 -5557.5 1415 -5557.5 {bezier=1}
P 1 5 1427.5 -5555 1432.5 -5555 1432.5 -5530 1427.5 -5530 1427.5 -5555 {}
P 1 10 1430 -5625 1455 -5625 1465 -5615 1465 -5585 1455 -5575 1405 -5575 1395 -5585 1395 -5615 1405 -5625 1430 -5625 {bezier=1}
P 1 10 1430 -5630 1460 -5630 1470 -5620 1470 -5580 1460 -5570 1400 -5570 1390 -5580 1390 -5620 1400 -5630 1430 -5630 {bezier=1}
P 1 14 1960 -5670 1982.5 -5670 1987.5 -5670 1987.5 -5665 1987.5 -5622.5 1980 -5597.5 1975 -5597.5 1945 -5597.5 1940 -5597.5 1932.5 -5622.5 1932.5 -5665 1932.5 -5670 1937.5 -5670 1960 -5670 {bezier=1}
P 1 14 1975 -5667.5 1980 -5667.5 1985 -5667.5 1985 -5662.5 1985 -5642.5 1985 -5637.5 1980 -5637.5 1970 -5637.5 1965 -5637.5 1965 -5642.5 1965 -5662.5 1965 -5667.5 1970 -5667.5 1975 -5667.5 {bezier=1}
P 1 5 1957.5 -5665 1962.5 -5665 1962.5 -5640 1957.5 -5640 1957.5 -5665 {}
P 1 14 1580 -5150 1602.5 -5150 1607.5 -5150 1607.5 -5145 1607.5 -5102.5 1600 -5077.5 1595 -5077.5 1565 -5077.5 1560 -5077.5 1552.5 -5102.5 1552.5 -5145 1552.5 -5150 1557.5 -5150 1580 -5150 {bezier=1}
P 1 14 1595 -5147.5 1600 -5147.5 1605 -5147.5 1605 -5142.5 1605 -5122.5 1605 -5117.5 1600 -5117.5 1590 -5117.5 1585 -5117.5 1585 -5122.5 1585 -5142.5 1585 -5147.5 1590 -5147.5 1595 -5147.5 {bezier=1}
P 1 5 1577.5 -5145 1582.5 -5145 1582.5 -5120 1577.5 -5120 1577.5 -5145 {}
P 1 10 1580 -5215 1605 -5215 1615 -5205 1615 -5175 1605 -5165 1555 -5165 1545 -5175 1545 -5205 1555 -5215 1580 -5215 {bezier=1}
P 1 10 1580 -5220 1610 -5220 1620 -5210 1620 -5170 1610 -5160 1550 -5160 1540 -5170 1540 -5210 1550 -5220 1580 -5220 {bezier=1}
P 1 14 2070 -5210 2092.5 -5210 2097.5 -5210 2097.5 -5205 2097.5 -5162.5 2090 -5137.5 2085 -5137.5 2055 -5137.5 2050 -5137.5 2042.5 -5162.5 2042.5 -5205 2042.5 -5210 2047.5 -5210 2070 -5210 {bezier=1}
P 1 14 2085 -5207.5 2090 -5207.5 2095 -5207.5 2095 -5202.5 2095 -5182.5 2095 -5177.5 2090 -5177.5 2080 -5177.5 2075 -5177.5 2075 -5182.5 2075 -5202.5 2075 -5207.5 2080 -5207.5 2085 -5207.5 {bezier=1}
P 1 5 2067.5 -5205 2072.5 -5205 2072.5 -5180 2067.5 -5180 2067.5 -5205 {}
P 1 14 2600 -5340 2622.5 -5340 2627.5 -5340 2627.5 -5335 2627.5 -5292.5 2620 -5267.5 2615 -5267.5 2585 -5267.5 2580 -5267.5 2572.5 -5292.5 2572.5 -5335 2572.5 -5340 2577.5 -5340 2600 -5340 {bezier=1}
P 1 14 2615 -5337.5 2620 -5337.5 2625 -5337.5 2625 -5332.5 2625 -5312.5 2625 -5307.5 2620 -5307.5 2610 -5307.5 2605 -5307.5 2605 -5312.5 2605 -5332.5 2605 -5337.5 2610 -5337.5 2615 -5337.5 {bezier=1}
P 1 5 2597.5 -5335 2602.5 -5335 2602.5 -5310 2597.5 -5310 2597.5 -5335 {}
P 1 10 1960 -4915 1985 -4915 1995 -4905 1995 -4875 1985 -4865 1935 -4865 1925 -4875 1925 -4905 1935 -4915 1960 -4915 {bezier=1}
P 1 10 1960 -4920 1990 -4920 2000 -4910 2000 -4870 1990 -4860 1930 -4860 1920 -4870 1920 -4910 1930 -4920 1960 -4920 {bezier=1}
P 1 10 1960 -4835 1985 -4835 1995 -4825 1995 -4795 1985 -4785 1935 -4785 1925 -4795 1925 -4825 1935 -4835 1960 -4835 {bezier=1}
P 1 10 1960 -4840 1990 -4840 2000 -4830 2000 -4790 1990 -4780 1930 -4780 1920 -4790 1920 -4830 1930 -4840 1960 -4840 {bezier=1}
P 1 14 990 -13130 1012.5 -13130 1017.5 -13130 1017.5 -13125 1017.5 -13082.5 1010 -13057.5 1005 -13057.5 975 -13057.5 970 -13057.5 962.5 -13082.5 962.5 -13125 962.5 -13130 967.5 -13130 990 -13130 {bezier=1}
P 1 14 1005 -13127.5 1010 -13127.5 1015 -13127.5 1015 -13122.5 1015 -13102.5 1015 -13097.5 1010 -13097.5 1000 -13097.5 995 -13097.5 995 -13102.5 995 -13122.5 995 -13127.5 1000 -13127.5 1005 -13127.5 {bezier=1}
P 1 5 987.5 -13125 992.5 -13125 992.5 -13100 987.5 -13100 987.5 -13125 {}
P 1 10 1080 -13115 1105 -13115 1115 -13105 1115 -13075 1105 -13065 1055 -13065 1045 -13075 1045 -13105 1055 -13115 1080 -13115 {bezier=1}
P 1 10 1080 -13120 1110 -13120 1120 -13110 1120 -13070 1110 -13060 1050 -13060 1040 -13070 1040 -13110 1050 -13120 1080 -13120 {bezier=1}
P 1 14 1570 -2780 1592.5 -2780 1597.5 -2780 1597.5 -2775 1597.5 -2732.5 1590 -2707.5 1585 -2707.5 1555 -2707.5 1550 -2707.5 1542.5 -2732.5 1542.5 -2775 1542.5 -2780 1547.5 -2780 1570 -2780 {bezier=1}
P 1 14 1585 -2777.5 1590 -2777.5 1595 -2777.5 1595 -2772.5 1595 -2752.5 1595 -2747.5 1590 -2747.5 1580 -2747.5 1575 -2747.5 1575 -2752.5 1575 -2772.5 1575 -2777.5 1580 -2777.5 1585 -2777.5 {bezier=1}
P 1 5 1567.5 -2775 1572.5 -2775 1572.5 -2750 1567.5 -2750 1567.5 -2775 {}
P 1 14 2080 -2730 2102.5 -2730 2107.5 -2730 2107.5 -2725 2107.5 -2682.5 2100 -2657.5 2095 -2657.5 2065 -2657.5 2060 -2657.5 2052.5 -2682.5 2052.5 -2725 2052.5 -2730 2057.5 -2730 2080 -2730 {bezier=1}
P 1 14 2095 -2727.5 2100 -2727.5 2105 -2727.5 2105 -2722.5 2105 -2702.5 2105 -2697.5 2100 -2697.5 2090 -2697.5 2085 -2697.5 2085 -2702.5 2085 -2722.5 2085 -2727.5 2090 -2727.5 2095 -2727.5 {bezier=1}
P 1 5 2077.5 -2725 2082.5 -2725 2082.5 -2700 2077.5 -2700 2077.5 -2725 {}
P 1 10 2080 -2875 2105 -2875 2115 -2865 2115 -2835 2105 -2825 2055 -2825 2045 -2835 2045 -2865 2055 -2875 2080 -2875 {bezier=1}
P 1 10 2080 -2880 2110 -2880 2120 -2870 2120 -2830 2110 -2820 2050 -2820 2040 -2830 2040 -2870 2050 -2880 2080 -2880 {bezier=1}
P 1 10 2080 -2805 2105 -2805 2115 -2795 2115 -2765 2105 -2755 2055 -2755 2045 -2765 2045 -2795 2055 -2805 2080 -2805 {bezier=1}
P 1 10 2080 -2810 2110 -2810 2120 -2800 2120 -2760 2110 -2750 2050 -2750 2040 -2760 2040 -2800 2050 -2810 2080 -2810 {bezier=1}
P 1 10 1920 -4615 1945 -4615 1955 -4605 1955 -4575 1945 -4565 1895 -4565 1885 -4575 1885 -4605 1895 -4615 1920 -4615 {bezier=1}
P 1 10 1920 -4620 1950 -4620 1960 -4610 1960 -4570 1950 -4560 1890 -4560 1880 -4570 1880 -4610 1890 -4620 1920 -4620 {bezier=1}
P 1 10 1830 -4185 1855 -4185 1865 -4175 1865 -4145 1855 -4135 1805 -4135 1795 -4145 1795 -4175 1805 -4185 1830 -4185 {bezier=1}
P 1 10 1830 -4190 1860 -4190 1870 -4180 1870 -4140 1860 -4130 1800 -4130 1790 -4140 1790 -4180 1800 -4190 1830 -4190 {bezier=1}
P 1 14 2500 -5590 2522.5 -5590 2527.5 -5590 2527.5 -5585 2527.5 -5542.5 2520 -5517.5 2515 -5517.5 2485 -5517.5 2480 -5517.5 2472.5 -5542.5 2472.5 -5585 2472.5 -5590 2477.5 -5590 2500 -5590 {bezier=1}
P 1 14 2515 -5587.5 2520 -5587.5 2525 -5587.5 2525 -5582.5 2525 -5562.5 2525 -5557.5 2520 -5557.5 2510 -5557.5 2505 -5557.5 2505 -5562.5 2505 -5582.5 2505 -5587.5 2510 -5587.5 2515 -5587.5 {bezier=1}
P 1 5 2497.5 -5585 2502.5 -5585 2502.5 -5560 2497.5 -5560 2497.5 -5585 {}
P 1 10 1290 -3535 1315 -3535 1325 -3525 1325 -3495 1315 -3485 1265 -3485 1255 -3495 1255 -3525 1265 -3535 1290 -3535 {bezier=1}
P 1 10 1290 -3540 1320 -3540 1330 -3530 1330 -3490 1320 -3480 1260 -3480 1250 -3490 1250 -3530 1260 -3540 1290 -3540 {bezier=1}
P 1 14 1820 -3630 1842.5 -3630 1847.5 -3630 1847.5 -3625 1847.5 -3582.5 1840 -3557.5 1835 -3557.5 1805 -3557.5 1800 -3557.5 1792.5 -3582.5 1792.5 -3625 1792.5 -3630 1797.5 -3630 1820 -3630 {bezier=1}
P 1 14 1835 -3627.5 1840 -3627.5 1845 -3627.5 1845 -3622.5 1845 -3602.5 1845 -3597.5 1840 -3597.5 1830 -3597.5 1825 -3597.5 1825 -3602.5 1825 -3622.5 1825 -3627.5 1830 -3627.5 1835 -3627.5 {bezier=1}
P 1 5 1817.5 -3625 1822.5 -3625 1822.5 -3600 1817.5 -3600 1817.5 -3625 {}
P 1 14 670 -3560 692.5 -3560 697.5 -3560 697.5 -3555 697.5 -3512.5 690 -3487.5 685 -3487.5 655 -3487.5 650 -3487.5 642.5 -3512.5 642.5 -3555 642.5 -3560 647.5 -3560 670 -3560 {bezier=1}
P 1 14 685 -3557.5 690 -3557.5 695 -3557.5 695 -3552.5 695 -3532.5 695 -3527.5 690 -3527.5 680 -3527.5 675 -3527.5 675 -3532.5 675 -3552.5 675 -3557.5 680 -3557.5 685 -3557.5 {bezier=1}
P 1 5 667.5 -3555 672.5 -3555 672.5 -3530 667.5 -3530 667.5 -3555 {}
P 1 14 790 -3560 812.5 -3560 817.5 -3560 817.5 -3555 817.5 -3512.5 810 -3487.5 805 -3487.5 775 -3487.5 770 -3487.5 762.5 -3512.5 762.5 -3555 762.5 -3560 767.5 -3560 790 -3560 {bezier=1}
P 1 14 805 -3557.5 810 -3557.5 815 -3557.5 815 -3552.5 815 -3532.5 815 -3527.5 810 -3527.5 800 -3527.5 795 -3527.5 795 -3532.5 795 -3552.5 795 -3557.5 800 -3557.5 805 -3557.5 {bezier=1}
P 1 5 787.5 -3555 792.5 -3555 792.5 -3530 787.5 -3530 787.5 -3555 {}
P 1 10 790 -3465 815 -3465 825 -3455 825 -3425 815 -3415 765 -3415 755 -3425 755 -3455 765 -3465 790 -3465 {bezier=1}
P 1 10 790 -3470 820 -3470 830 -3460 830 -3420 820 -3410 760 -3410 750 -3420 750 -3460 760 -3470 790 -3470 {bezier=1}
P 1 14 1600 -2230 1622.5 -2230 1627.5 -2230 1627.5 -2225 1627.5 -2182.5 1620 -2157.5 1615 -2157.5 1585 -2157.5 1580 -2157.5 1572.5 -2182.5 1572.5 -2225 1572.5 -2230 1577.5 -2230 1600 -2230 {bezier=1}
P 1 14 1585 -2227.5 1580 -2227.5 1575 -2227.5 1575 -2222.5 1575 -2202.5 1575 -2197.5 1580 -2197.5 1590 -2197.5 1595 -2197.5 1595 -2202.5 1595 -2222.5 1595 -2227.5 1590 -2227.5 1585 -2227.5 {bezier=1}
P 1 5 1597.5 -2225 1602.5 -2225 1602.5 -2200 1597.5 -2200 1597.5 -2225 {}
P 1 10 1600 -2305 1625 -2305 1635 -2295 1635 -2265 1625 -2255 1575 -2255 1565 -2265 1565 -2295 1575 -2305 1600 -2305 {bezier=1}
P 1 10 1600 -2310 1630 -2310 1640 -2300 1640 -2260 1630 -2250 1570 -2250 1560 -2260 1560 -2300 1570 -2310 1600 -2310 {bezier=1}
P 1 10 1920 -4045 1945 -4045 1955 -4035 1955 -4005 1945 -3995 1895 -3995 1885 -4005 1885 -4035 1895 -4045 1920 -4045 {bezier=1}
P 1 10 1920 -4050 1950 -4050 1960 -4040 1960 -4000 1950 -3990 1890 -3990 1880 -4000 1880 -4040 1890 -4050 1920 -4050 {bezier=1}
P 1 14 2280 -6710 2302.5 -6710 2307.5 -6710 2307.5 -6705 2307.5 -6662.5 2300 -6637.5 2295 -6637.5 2265 -6637.5 2260 -6637.5 2252.5 -6662.5 2252.5 -6705 2252.5 -6710 2257.5 -6710 2280 -6710 {bezier=1}
P 1 14 2295 -6707.5 2300 -6707.5 2305 -6707.5 2305 -6702.5 2305 -6682.5 2305 -6677.5 2300 -6677.5 2290 -6677.5 2285 -6677.5 2285 -6682.5 2285 -6702.5 2285 -6707.5 2290 -6707.5 2295 -6707.5 {bezier=1}
P 1 5 2277.5 -6705 2282.5 -6705 2282.5 -6680 2277.5 -6680 2277.5 -6705 {}
P 1 10 2370 -6695 2395 -6695 2405 -6685 2405 -6655 2395 -6645 2345 -6645 2335 -6655 2335 -6685 2345 -6695 2370 -6695 {bezier=1}
P 1 10 2370 -6700 2400 -6700 2410 -6690 2410 -6650 2400 -6640 2340 -6640 2330 -6650 2330 -6690 2340 -6700 2370 -6700 {bezier=1}
P 1 14 1980 -5920 2002.5 -5920 2007.5 -5920 2007.5 -5915 2007.5 -5872.5 2000 -5847.5 1995 -5847.5 1965 -5847.5 1960 -5847.5 1952.5 -5872.5 1952.5 -5915 1952.5 -5920 1957.5 -5920 1980 -5920 {bezier=1}
P 1 14 1995 -5917.5 2000 -5917.5 2005 -5917.5 2005 -5912.5 2005 -5892.5 2005 -5887.5 2000 -5887.5 1990 -5887.5 1985 -5887.5 1985 -5892.5 1985 -5912.5 1985 -5917.5 1990 -5917.5 1995 -5917.5 {bezier=1}
P 1 5 1977.5 -5915 1982.5 -5915 1982.5 -5890 1977.5 -5890 1977.5 -5915 {}
P 1 10 1980 -6075 2005 -6075 2015 -6065 2015 -6035 2005 -6025 1955 -6025 1945 -6035 1945 -6065 1955 -6075 1980 -6075 {bezier=1}
P 1 10 1980 -6080 2010 -6080 2020 -6070 2020 -6030 2010 -6020 1950 -6020 1940 -6030 1940 -6070 1950 -6080 1980 -6080 {bezier=1}
P 1 10 1980 -5995 2005 -5995 2015 -5985 2015 -5955 2005 -5945 1955 -5945 1945 -5955 1945 -5985 1955 -5995 1980 -5995 {bezier=1}
P 1 10 1980 -6000 2010 -6000 2020 -5990 2020 -5950 2010 -5940 1950 -5940 1940 -5950 1940 -5990 1950 -6000 1980 -6000 {bezier=1}
P 1 14 2340 -4220 2362.5 -4220 2367.5 -4220 2367.5 -4215 2367.5 -4172.5 2360 -4147.5 2355 -4147.5 2325 -4147.5 2320 -4147.5 2312.5 -4172.5 2312.5 -4215 2312.5 -4220 2317.5 -4220 2340 -4220 {bezier=1}
P 1 14 2355 -4217.5 2360 -4217.5 2365 -4217.5 2365 -4212.5 2365 -4192.5 2365 -4187.5 2360 -4187.5 2350 -4187.5 2345 -4187.5 2345 -4192.5 2345 -4212.5 2345 -4217.5 2350 -4217.5 2355 -4217.5 {bezier=1}
P 1 5 2337.5 -4215 2342.5 -4215 2342.5 -4190 2337.5 -4190 2337.5 -4215 {}
P 1 14 810 -4340 832.5 -4340 837.5 -4340 837.5 -4335 837.5 -4292.5 830 -4267.5 825 -4267.5 795 -4267.5 790 -4267.5 782.5 -4292.5 782.5 -4335 782.5 -4340 787.5 -4340 810 -4340 {bezier=1}
P 1 14 825 -4337.5 830 -4337.5 835 -4337.5 835 -4332.5 835 -4312.5 835 -4307.5 830 -4307.5 820 -4307.5 815 -4307.5 815 -4312.5 815 -4332.5 815 -4337.5 820 -4337.5 825 -4337.5 {bezier=1}
P 1 5 807.5 -4335 812.5 -4335 812.5 -4310 807.5 -4310 807.5 -4335 {}
P 1 14 1350 -4320 1372.5 -4320 1377.5 -4320 1377.5 -4315 1377.5 -4272.5 1370 -4247.5 1365 -4247.5 1335 -4247.5 1330 -4247.5 1322.5 -4272.5 1322.5 -4315 1322.5 -4320 1327.5 -4320 1350 -4320 {bezier=1}
P 1 14 1365 -4317.5 1370 -4317.5 1375 -4317.5 1375 -4312.5 1375 -4292.5 1375 -4287.5 1370 -4287.5 1360 -4287.5 1355 -4287.5 1355 -4292.5 1355 -4312.5 1355 -4317.5 1360 -4317.5 1365 -4317.5 {bezier=1}
P 1 5 1347.5 -4315 1352.5 -4315 1352.5 -4290 1347.5 -4290 1347.5 -4315 {}
P 1 14 1260 -3940 1282.5 -3940 1287.5 -3940 1287.5 -3935 1287.5 -3892.5 1280 -3867.5 1275 -3867.5 1245 -3867.5 1240 -3867.5 1232.5 -3892.5 1232.5 -3935 1232.5 -3940 1237.5 -3940 1260 -3940 {bezier=1}
P 1 14 1275 -3937.5 1280 -3937.5 1285 -3937.5 1285 -3932.5 1285 -3912.5 1285 -3907.5 1280 -3907.5 1270 -3907.5 1265 -3907.5 1265 -3912.5 1265 -3932.5 1265 -3937.5 1270 -3937.5 1275 -3937.5 {bezier=1}
P 1 5 1257.5 -3935 1262.5 -3935 1262.5 -3910 1257.5 -3910 1257.5 -3935 {}
P 1 14 2520 -3890 2542.5 -3890 2547.5 -3890 2547.5 -3885 2547.5 -3842.5 2540 -3817.5 2535 -3817.5 2505 -3817.5 2500 -3817.5 2492.5 -3842.5 2492.5 -3885 2492.5 -3890 2497.5 -3890 2520 -3890 {bezier=1}
P 1 14 2535 -3887.5 2540 -3887.5 2545 -3887.5 2545 -3882.5 2545 -3862.5 2545 -3857.5 2540 -3857.5 2530 -3857.5 2525 -3857.5 2525 -3862.5 2525 -3882.5 2525 -3887.5 2530 -3887.5 2535 -3887.5 {bezier=1}
P 1 5 2517.5 -3885 2522.5 -3885 2522.5 -3860 2517.5 -3860 2517.5 -3885 {}
P 1 14 2480 -2480 2502.5 -2480 2507.5 -2480 2507.5 -2475 2507.5 -2432.5 2500 -2407.5 2495 -2407.5 2465 -2407.5 2460 -2407.5 2452.5 -2432.5 2452.5 -2475 2452.5 -2480 2457.5 -2480 2480 -2480 {bezier=1}
P 1 14 2495 -2477.5 2490 -2477.5 2485 -2477.5 2485 -2472.5 2485 -2452.5 2485 -2447.5 2490 -2447.5 2500 -2447.5 2505 -2447.5 2505 -2452.5 2505 -2472.5 2505 -2477.5 2500 -2477.5 2495 -2477.5 {bezier=1}
P 1 5 2477.5 -2475 2482.5 -2475 2482.5 -2450 2477.5 -2450 2477.5 -2475 {}
P 1 14 370 -9570 392.5 -9570 397.5 -9570 397.5 -9565 397.5 -9522.5 390 -9497.5 385 -9497.5 355 -9497.5 350 -9497.5 342.5 -9522.5 342.5 -9565 342.5 -9570 347.5 -9570 370 -9570 {bezier=1}
P 1 14 385 -9567.5 390 -9567.5 395 -9567.5 395 -9562.5 395 -9542.5 395 -9537.5 390 -9537.5 380 -9537.5 375 -9537.5 375 -9542.5 375 -9562.5 375 -9567.5 380 -9567.5 385 -9567.5 {bezier=1}
P 1 5 367.5 -9565 372.5 -9565 372.5 -9540 367.5 -9540 367.5 -9565 {}
P 1 14 900 -9740 922.5 -9740 927.5 -9740 927.5 -9735 927.5 -9692.5 920 -9667.5 915 -9667.5 885 -9667.5 880 -9667.5 872.5 -9692.5 872.5 -9735 872.5 -9740 877.5 -9740 900 -9740 {bezier=1}
P 1 14 915 -9737.5 920 -9737.5 925 -9737.5 925 -9732.5 925 -9712.5 925 -9707.5 920 -9707.5 910 -9707.5 905 -9707.5 905 -9712.5 905 -9732.5 905 -9737.5 910 -9737.5 915 -9737.5 {bezier=1}
P 1 5 897.5 -9735 902.5 -9735 902.5 -9710 897.5 -9710 897.5 -9735 {}
P 1 14 1150 -9780 1172.5 -9780 1177.5 -9780 1177.5 -9775 1177.5 -9732.5 1170 -9707.5 1165 -9707.5 1135 -9707.5 1130 -9707.5 1122.5 -9732.5 1122.5 -9775 1122.5 -9780 1127.5 -9780 1150 -9780 {bezier=1}
P 1 14 1165 -9777.5 1170 -9777.5 1175 -9777.5 1175 -9772.5 1175 -9752.5 1175 -9747.5 1170 -9747.5 1160 -9747.5 1155 -9747.5 1155 -9752.5 1155 -9772.5 1155 -9777.5 1160 -9777.5 1165 -9777.5 {bezier=1}
P 1 5 1147.5 -9775 1152.5 -9775 1152.5 -9750 1147.5 -9750 1147.5 -9775 {}
P 1 14 1440 -9780 1462.5 -9780 1467.5 -9780 1467.5 -9775 1467.5 -9732.5 1460 -9707.5 1455 -9707.5 1425 -9707.5 1420 -9707.5 1412.5 -9732.5 1412.5 -9775 1412.5 -9780 1417.5 -9780 1440 -9780 {bezier=1}
P 1 14 1455 -9777.5 1460 -9777.5 1465 -9777.5 1465 -9772.5 1465 -9752.5 1465 -9747.5 1460 -9747.5 1450 -9747.5 1445 -9747.5 1445 -9752.5 1445 -9772.5 1445 -9777.5 1450 -9777.5 1455 -9777.5 {bezier=1}
P 1 5 1437.5 -9775 1442.5 -9775 1442.5 -9750 1437.5 -9750 1437.5 -9775 {}
P 1 14 1900 -9740 1922.5 -9740 1927.5 -9740 1927.5 -9735 1927.5 -9692.5 1920 -9667.5 1915 -9667.5 1885 -9667.5 1880 -9667.5 1872.5 -9692.5 1872.5 -9735 1872.5 -9740 1877.5 -9740 1900 -9740 {bezier=1}
P 1 14 1915 -9737.5 1920 -9737.5 1925 -9737.5 1925 -9732.5 1925 -9712.5 1925 -9707.5 1920 -9707.5 1910 -9707.5 1905 -9707.5 1905 -9712.5 1905 -9732.5 1905 -9737.5 1910 -9737.5 1915 -9737.5 {bezier=1}
P 1 5 1897.5 -9735 1902.5 -9735 1902.5 -9710 1897.5 -9710 1897.5 -9735 {}
P 1 14 930 -6290 952.5 -6290 957.5 -6290 957.5 -6285 957.5 -6242.5 950 -6217.5 945 -6217.5 915 -6217.5 910 -6217.5 902.5 -6242.5 902.5 -6285 902.5 -6290 907.5 -6290 930 -6290 {bezier=1}
P 1 14 945 -6287.5 950 -6287.5 955 -6287.5 955 -6282.5 955 -6262.5 955 -6257.5 950 -6257.5 940 -6257.5 935 -6257.5 935 -6262.5 935 -6282.5 935 -6287.5 940 -6287.5 945 -6287.5 {bezier=1}
P 1 5 927.5 -6285 932.5 -6285 932.5 -6260 927.5 -6260 927.5 -6285 {}
P 1 14 1770 -6340 1792.5 -6340 1797.5 -6340 1797.5 -6335 1797.5 -6292.5 1790 -6267.5 1785 -6267.5 1755 -6267.5 1750 -6267.5 1742.5 -6292.5 1742.5 -6335 1742.5 -6340 1747.5 -6340 1770 -6340 {bezier=1}
P 1 14 1785 -6337.5 1790 -6337.5 1795 -6337.5 1795 -6332.5 1795 -6312.5 1795 -6307.5 1790 -6307.5 1780 -6307.5 1775 -6307.5 1775 -6312.5 1775 -6332.5 1775 -6337.5 1780 -6337.5 1785 -6337.5 {bezier=1}
P 1 5 1767.5 -6335 1772.5 -6335 1772.5 -6310 1767.5 -6310 1767.5 -6335 {}
P 1 14 2530 -6340 2552.5 -6340 2557.5 -6340 2557.5 -6335 2557.5 -6292.5 2550 -6267.5 2545 -6267.5 2515 -6267.5 2510 -6267.5 2502.5 -6292.5 2502.5 -6335 2502.5 -6340 2507.5 -6340 2530 -6340 {bezier=1}
P 1 14 2545 -6337.5 2550 -6337.5 2555 -6337.5 2555 -6332.5 2555 -6312.5 2555 -6307.5 2550 -6307.5 2540 -6307.5 2535 -6307.5 2535 -6312.5 2535 -6332.5 2535 -6337.5 2540 -6337.5 2545 -6337.5 {bezier=1}
P 1 5 2527.5 -6335 2532.5 -6335 2532.5 -6310 2527.5 -6310 2527.5 -6335 {}
P 1 14 905 -11400 927.5 -11400 932.5 -11400 932.5 -11395 932.5 -11352.5 925 -11327.5 920 -11327.5 890 -11327.5 885 -11327.5 877.5 -11352.5 877.5 -11395 877.5 -11400 882.5 -11400 905 -11400 {bezier=1}
P 1 14 920 -11397.5 925 -11397.5 930 -11397.5 930 -11392.5 930 -11372.5 930 -11367.5 925 -11367.5 915 -11367.5 910 -11367.5 910 -11372.5 910 -11392.5 910 -11397.5 915 -11397.5 920 -11397.5 {bezier=1}
P 1 5 902.5 -11395 907.5 -11395 907.5 -11370 902.5 -11370 902.5 -11395 {}
P 1 14 1440 -11280 1462.5 -11280 1467.5 -11280 1467.5 -11275 1467.5 -11232.5 1460 -11207.5 1455 -11207.5 1425 -11207.5 1420 -11207.5 1412.5 -11232.5 1412.5 -11275 1412.5 -11280 1417.5 -11280 1440 -11280 {bezier=1}
P 1 14 1455 -11277.5 1460 -11277.5 1465 -11277.5 1465 -11272.5 1465 -11252.5 1465 -11247.5 1460 -11247.5 1450 -11247.5 1445 -11247.5 1445 -11252.5 1445 -11272.5 1445 -11277.5 1450 -11277.5 1455 -11277.5 {bezier=1}
P 1 5 1437.5 -11275 1442.5 -11275 1442.5 -11250 1437.5 -11250 1437.5 -11275 {}
P 1 14 1810 -11280 1832.5 -11280 1837.5 -11280 1837.5 -11275 1837.5 -11232.5 1830 -11207.5 1825 -11207.5 1795 -11207.5 1790 -11207.5 1782.5 -11232.5 1782.5 -11275 1782.5 -11280 1787.5 -11280 1810 -11280 {bezier=1}
P 1 14 1825 -11277.5 1830 -11277.5 1835 -11277.5 1835 -11272.5 1835 -11252.5 1835 -11247.5 1830 -11247.5 1820 -11247.5 1815 -11247.5 1815 -11252.5 1815 -11272.5 1815 -11277.5 1820 -11277.5 1825 -11277.5 {bezier=1}
P 1 5 1807.5 -11275 1812.5 -11275 1812.5 -11250 1807.5 -11250 1807.5 -11275 {}
P 1 14 2300 -11280 2322.5 -11280 2327.5 -11280 2327.5 -11275 2327.5 -11232.5 2320 -11207.5 2315 -11207.5 2285 -11207.5 2280 -11207.5 2272.5 -11232.5 2272.5 -11275 2272.5 -11280 2277.5 -11280 2300 -11280 {bezier=1}
P 1 14 2315 -11277.5 2320 -11277.5 2325 -11277.5 2325 -11272.5 2325 -11252.5 2325 -11247.5 2320 -11247.5 2310 -11247.5 2305 -11247.5 2305 -11252.5 2305 -11272.5 2305 -11277.5 2310 -11277.5 2315 -11277.5 {bezier=1}
P 1 5 2297.5 -11275 2302.5 -11275 2302.5 -11250 2297.5 -11250 2297.5 -11275 {}
P 1 14 2250 -9590 2272.5 -9590 2277.5 -9590 2277.5 -9585 2277.5 -9542.5 2270 -9517.5 2265 -9517.5 2235 -9517.5 2230 -9517.5 2222.5 -9542.5 2222.5 -9585 2222.5 -9590 2227.5 -9590 2250 -9590 {bezier=1}
P 1 14 2265 -9587.5 2270 -9587.5 2275 -9587.5 2275 -9582.5 2275 -9562.5 2275 -9557.5 2270 -9557.5 2260 -9557.5 2255 -9557.5 2255 -9562.5 2255 -9582.5 2255 -9587.5 2260 -9587.5 2265 -9587.5 {bezier=1}
P 1 5 2247.5 -9585 2252.5 -9585 2252.5 -9560 2247.5 -9560 2247.5 -9585 {}
P 1 10 1980 -9735 2005 -9735 2015 -9725 2015 -9695 2005 -9685 1955 -9685 1945 -9695 1945 -9725 1955 -9735 1980 -9735 {bezier=1}
P 1 10 1980 -9740 2010 -9740 2020 -9730 2020 -9690 2010 -9680 1950 -9680 1940 -9690 1940 -9730 1950 -9740 1980 -9740 {bezier=1}
P 1 10 510 -9245 535 -9245 545 -9235 545 -9205 535 -9195 485 -9195 475 -9205 475 -9235 485 -9245 510 -9245 {bezier=1}
P 1 10 510 -9250 540 -9250 550 -9240 550 -9200 540 -9190 480 -9190 470 -9200 470 -9240 480 -9250 510 -9250 {bezier=1}
P 1 10 510 -9175 535 -9175 545 -9165 545 -9135 535 -9125 485 -9125 475 -9135 475 -9165 485 -9175 510 -9175 {bezier=1}
P 1 10 510 -9180 540 -9180 550 -9170 550 -9130 540 -9120 480 -9120 470 -9130 470 -9170 480 -9180 510 -9180 {bezier=1}
P 1 10 820 -9245 845 -9245 855 -9235 855 -9205 845 -9195 795 -9195 785 -9205 785 -9235 795 -9245 820 -9245 {bezier=1}
P 1 10 820 -9250 850 -9250 860 -9240 860 -9200 850 -9190 790 -9190 780 -9200 780 -9240 790 -9250 820 -9250 {bezier=1}
P 1 10 820 -9175 845 -9175 855 -9165 855 -9135 845 -9125 795 -9125 785 -9135 785 -9165 795 -9175 820 -9175 {bezier=1}
P 1 10 820 -9180 850 -9180 860 -9170 860 -9130 850 -9120 790 -9120 780 -9130 780 -9170 790 -9180 820 -9180 {bezier=1}
P 1 10 1120 -9245 1145 -9245 1155 -9235 1155 -9205 1145 -9195 1095 -9195 1085 -9205 1085 -9235 1095 -9245 1120 -9245 {bezier=1}
P 1 10 1120 -9250 1150 -9250 1160 -9240 1160 -9200 1150 -9190 1090 -9190 1080 -9200 1080 -9240 1090 -9250 1120 -9250 {bezier=1}
P 1 10 1120 -9175 1145 -9175 1155 -9165 1155 -9135 1145 -9125 1095 -9125 1085 -9135 1085 -9165 1095 -9175 1120 -9175 {bezier=1}
P 1 10 1120 -9180 1150 -9180 1160 -9170 1160 -9130 1150 -9120 1090 -9120 1080 -9130 1080 -9170 1090 -9180 1120 -9180 {bezier=1}
P 1 10 1430 -9245 1455 -9245 1465 -9235 1465 -9205 1455 -9195 1405 -9195 1395 -9205 1395 -9235 1405 -9245 1430 -9245 {bezier=1}
P 1 10 1430 -9250 1460 -9250 1470 -9240 1470 -9200 1460 -9190 1400 -9190 1390 -9200 1390 -9240 1400 -9250 1430 -9250 {bezier=1}
P 1 10 1430 -9175 1455 -9175 1465 -9165 1465 -9135 1455 -9125 1405 -9125 1395 -9135 1395 -9165 1405 -9175 1430 -9175 {bezier=1}
P 1 10 1430 -9180 1460 -9180 1470 -9170 1470 -9130 1460 -9120 1400 -9120 1390 -9130 1390 -9170 1400 -9180 1430 -9180 {bezier=1}
P 1 10 1750 -9245 1775 -9245 1785 -9235 1785 -9205 1775 -9195 1725 -9195 1715 -9205 1715 -9235 1725 -9245 1750 -9245 {bezier=1}
P 1 10 1750 -9250 1780 -9250 1790 -9240 1790 -9200 1780 -9190 1720 -9190 1710 -9200 1710 -9240 1720 -9250 1750 -9250 {bezier=1}
P 1 10 1750 -9175 1775 -9175 1785 -9165 1785 -9135 1775 -9125 1725 -9125 1715 -9135 1715 -9165 1725 -9175 1750 -9175 {bezier=1}
P 1 10 1750 -9180 1780 -9180 1790 -9170 1790 -9130 1780 -9120 1720 -9120 1710 -9130 1710 -9170 1720 -9180 1750 -9180 {bezier=1}
P 1 10 2080 -9245 2105 -9245 2115 -9235 2115 -9205 2105 -9195 2055 -9195 2045 -9205 2045 -9235 2055 -9245 2080 -9245 {bezier=1}
P 1 10 2080 -9250 2110 -9250 2120 -9240 2120 -9200 2110 -9190 2050 -9190 2040 -9200 2040 -9240 2050 -9250 2080 -9250 {bezier=1}
P 1 10 2080 -9175 2105 -9175 2115 -9165 2115 -9135 2105 -9125 2055 -9125 2045 -9135 2045 -9165 2055 -9175 2080 -9175 {bezier=1}
P 1 10 2080 -9180 2110 -9180 2120 -9170 2120 -9130 2110 -9120 2050 -9120 2040 -9130 2040 -9170 2050 -9180 2080 -9180 {bezier=1}
P 1 10 1940 -9055 1965 -9055 1975 -9045 1975 -9015 1965 -9005 1915 -9005 1905 -9015 1905 -9045 1915 -9055 1940 -9055 {bezier=1}
P 1 10 1940 -9060 1970 -9060 1980 -9050 1980 -9010 1970 -9000 1910 -9000 1900 -9010 1900 -9050 1910 -9060 1940 -9060 {bezier=1}
P 1 10 1940 -8985 1965 -8985 1975 -8975 1975 -8945 1965 -8935 1915 -8935 1905 -8945 1905 -8975 1915 -8985 1940 -8985 {bezier=1}
P 1 10 1940 -8990 1970 -8990 1980 -8980 1980 -8940 1970 -8930 1910 -8930 1900 -8940 1900 -8980 1910 -8990 1940 -8990 {bezier=1}
P 1 14 2050 -9040 2072.5 -9040 2077.5 -9040 2077.5 -9035 2077.5 -8992.5 2070 -8967.5 2065 -8967.5 2035 -8967.5 2030 -8967.5 2022.5 -8992.5 2022.5 -9035 2022.5 -9040 2027.5 -9040 2050 -9040 {bezier=1}
P 1 14 2065 -9037.5 2070 -9037.5 2075 -9037.5 2075 -9032.5 2075 -9012.5 2075 -9007.5 2070 -9007.5 2060 -9007.5 2055 -9007.5 2055 -9012.5 2055 -9032.5 2055 -9037.5 2060 -9037.5 2065 -9037.5 {bezier=1}
P 1 5 2047.5 -9035 2052.5 -9035 2052.5 -9010 2047.5 -9010 2047.5 -9035 {}
P 1 14 2035 -9037.5 2040 -9037.5 2045 -9037.5 2045 -9032.5 2045 -9012.5 2045 -9007.5 2040 -9007.5 2030 -9007.5 2025 -9007.5 2025 -9012.5 2025 -9032.5 2025 -9037.5 2030 -9037.5 2035 -9037.5 {bezier=1}
P 1 10 1940 -8625 1965 -8625 1975 -8615 1975 -8585 1965 -8575 1915 -8575 1905 -8585 1905 -8615 1915 -8625 1940 -8625 {bezier=1}
P 1 10 1940 -8630 1970 -8630 1980 -8620 1980 -8580 1970 -8570 1910 -8570 1900 -8580 1900 -8620 1910 -8630 1940 -8630 {bezier=1}
P 1 10 1940 -8555 1965 -8555 1975 -8545 1975 -8515 1965 -8505 1915 -8505 1905 -8515 1905 -8545 1915 -8555 1940 -8555 {bezier=1}
P 1 10 1940 -8560 1970 -8560 1980 -8550 1980 -8510 1970 -8500 1910 -8500 1900 -8510 1900 -8550 1910 -8560 1940 -8560 {bezier=1}
P 1 14 2050 -8610 2072.5 -8610 2077.5 -8610 2077.5 -8605 2077.5 -8562.5 2070 -8537.5 2065 -8537.5 2035 -8537.5 2030 -8537.5 2022.5 -8562.5 2022.5 -8605 2022.5 -8610 2027.5 -8610 2050 -8610 {bezier=1}
P 1 14 2065 -8607.5 2070 -8607.5 2075 -8607.5 2075 -8602.5 2075 -8582.5 2075 -8577.5 2070 -8577.5 2060 -8577.5 2055 -8577.5 2055 -8582.5 2055 -8602.5 2055 -8607.5 2060 -8607.5 2065 -8607.5 {bezier=1}
P 1 5 2047.5 -8605 2052.5 -8605 2052.5 -8580 2047.5 -8580 2047.5 -8605 {}
P 1 14 2035 -8607.5 2040 -8607.5 2045 -8607.5 2045 -8602.5 2045 -8582.5 2045 -8577.5 2040 -8577.5 2030 -8577.5 2025 -8577.5 2025 -8582.5 2025 -8602.5 2025 -8607.5 2030 -8607.5 2035 -8607.5 {bezier=1}
P 1 10 1050 -8145 1075 -8145 1085 -8135 1085 -8105 1075 -8095 1025 -8095 1015 -8105 1015 -8135 1025 -8145 1050 -8145 {bezier=1}
P 1 10 1050 -8150 1080 -8150 1090 -8140 1090 -8100 1080 -8090 1020 -8090 1010 -8100 1010 -8140 1020 -8150 1050 -8150 {bezier=1}
P 1 10 1050 -8075 1075 -8075 1085 -8065 1085 -8035 1075 -8025 1025 -8025 1015 -8035 1015 -8065 1025 -8075 1050 -8075 {bezier=1}
P 1 10 1050 -8080 1080 -8080 1090 -8070 1090 -8030 1080 -8020 1020 -8020 1010 -8030 1010 -8070 1020 -8080 1050 -8080 {bezier=1}
P 1 14 1160 -8130 1182.5 -8130 1187.5 -8130 1187.5 -8125 1187.5 -8082.5 1180 -8057.5 1175 -8057.5 1145 -8057.5 1140 -8057.5 1132.5 -8082.5 1132.5 -8125 1132.5 -8130 1137.5 -8130 1160 -8130 {bezier=1}
P 1 14 1175 -8127.5 1180 -8127.5 1185 -8127.5 1185 -8122.5 1185 -8102.5 1185 -8097.5 1180 -8097.5 1170 -8097.5 1165 -8097.5 1165 -8102.5 1165 -8122.5 1165 -8127.5 1170 -8127.5 1175 -8127.5 {bezier=1}
P 1 5 1157.5 -8125 1162.5 -8125 1162.5 -8100 1157.5 -8100 1157.5 -8125 {}
P 1 14 1145 -8127.5 1150 -8127.5 1155 -8127.5 1155 -8122.5 1155 -8102.5 1155 -8097.5 1150 -8097.5 1140 -8097.5 1135 -8097.5 1135 -8102.5 1135 -8122.5 1135 -8127.5 1140 -8127.5 1145 -8127.5 {bezier=1}
P 1 14 2480 -9650 2502.5 -9650 2507.5 -9650 2507.5 -9645 2507.5 -9602.5 2500 -9577.5 2495 -9577.5 2465 -9577.5 2460 -9577.5 2452.5 -9602.5 2452.5 -9645 2452.5 -9650 2457.5 -9650 2480 -9650 {bezier=1}
P 1 14 2495 -9647.5 2500 -9647.5 2505 -9647.5 2505 -9642.5 2505 -9622.5 2505 -9617.5 2500 -9617.5 2490 -9617.5 2485 -9617.5 2485 -9622.5 2485 -9642.5 2485 -9647.5 2490 -9647.5 2495 -9647.5 {bezier=1}
P 1 5 2477.5 -9645 2482.5 -9645 2482.5 -9620 2477.5 -9620 2477.5 -9645 {}
P 1 10 1520 -7375 1545 -7375 1555 -7365 1555 -7335 1545 -7325 1495 -7325 1485 -7335 1485 -7365 1495 -7375 1520 -7375 {bezier=1}
P 1 10 1520 -7380 1550 -7380 1560 -7370 1560 -7330 1550 -7320 1490 -7320 1480 -7330 1480 -7370 1490 -7380 1520 -7380 {bezier=1}
P 1 14 620 -9780 642.5 -9780 647.5 -9780 647.5 -9775 647.5 -9732.5 640 -9707.5 635 -9707.5 605 -9707.5 600 -9707.5 592.5 -9732.5 592.5 -9775 592.5 -9780 597.5 -9780 620 -9780 {bezier=1}
P 1 14 635 -9777.5 640 -9777.5 645 -9777.5 645 -9772.5 645 -9752.5 645 -9747.5 640 -9747.5 630 -9747.5 625 -9747.5 625 -9752.5 625 -9772.5 625 -9777.5 630 -9777.5 635 -9777.5 {bezier=1}
P 1 5 617.5 -9775 622.5 -9775 622.5 -9750 617.5 -9750 617.5 -9775 {}
P 1 10 1430 -1895 1455 -1895 1465 -1885 1465 -1855 1455 -1845 1405 -1845 1395 -1855 1395 -1885 1405 -1895 1430 -1895 {bezier=1}
P 1 10 1430 -1900 1460 -1900 1470 -1890 1470 -1850 1460 -1840 1400 -1840 1390 -1850 1390 -1890 1400 -1900 1430 -1900 {bezier=1}
P 1 10 1430 -1825 1455 -1825 1465 -1815 1465 -1785 1455 -1775 1405 -1775 1395 -1785 1395 -1815 1405 -1825 1430 -1825 {bezier=1}
P 1 10 1430 -1830 1460 -1830 1470 -1820 1470 -1780 1460 -1770 1400 -1770 1390 -1780 1390 -1820 1400 -1830 1430 -1830 {bezier=1}
P 1 10 2310 -1895 2335 -1895 2345 -1885 2345 -1855 2335 -1845 2285 -1845 2275 -1855 2275 -1885 2285 -1895 2310 -1895 {bezier=1}
P 1 10 2310 -1900 2340 -1900 2350 -1890 2350 -1850 2340 -1840 2280 -1840 2270 -1850 2270 -1890 2280 -1900 2310 -1900 {bezier=1}
P 1 10 2310 -1825 2335 -1825 2345 -1815 2345 -1785 2335 -1775 2285 -1775 2275 -1785 2275 -1815 2285 -1825 2310 -1825 {bezier=1}
P 1 10 2310 -1830 2340 -1830 2350 -1820 2350 -1780 2340 -1770 2280 -1770 2270 -1780 2270 -1820 2280 -1830 2310 -1830 {bezier=1}
P 1 10 1010 -1585 1035 -1585 1045 -1575 1045 -1545 1035 -1535 985 -1535 975 -1545 975 -1575 985 -1585 1010 -1585 {bezier=1}
P 1 10 1010 -1590 1040 -1590 1050 -1580 1050 -1540 1040 -1530 980 -1530 970 -1540 970 -1580 980 -1590 1010 -1590 {bezier=1}
P 1 10 1010 -1515 1035 -1515 1045 -1505 1045 -1475 1035 -1465 985 -1465 975 -1475 975 -1505 985 -1515 1010 -1515 {bezier=1}
P 1 10 1010 -1520 1040 -1520 1050 -1510 1050 -1470 1040 -1460 980 -1460 970 -1470 970 -1510 980 -1520 1010 -1520 {bezier=1}
P 1 10 1440 -1585 1465 -1585 1475 -1575 1475 -1545 1465 -1535 1415 -1535 1405 -1545 1405 -1575 1415 -1585 1440 -1585 {bezier=1}
P 1 10 1440 -1590 1470 -1590 1480 -1580 1480 -1540 1470 -1530 1410 -1530 1400 -1540 1400 -1580 1410 -1590 1440 -1590 {bezier=1}
P 1 10 1440 -1515 1465 -1515 1475 -1505 1475 -1475 1465 -1465 1415 -1465 1405 -1475 1405 -1505 1415 -1515 1440 -1515 {bezier=1}
P 1 10 1440 -1520 1470 -1520 1480 -1510 1480 -1470 1470 -1460 1410 -1460 1400 -1470 1400 -1510 1410 -1520 1440 -1520 {bezier=1}
P 1 10 2370 -1645 2395 -1645 2405 -1635 2405 -1605 2395 -1595 2345 -1595 2335 -1605 2335 -1635 2345 -1645 2370 -1645 {bezier=1}
P 1 10 2370 -1650 2400 -1650 2410 -1640 2410 -1600 2400 -1590 2340 -1590 2330 -1600 2330 -1640 2340 -1650 2370 -1650 {bezier=1}
P 1 10 2370 -1575 2395 -1575 2405 -1565 2405 -1535 2395 -1525 2345 -1525 2335 -1535 2335 -1565 2345 -1575 2370 -1575 {bezier=1}
P 1 10 2370 -1580 2400 -1580 2410 -1570 2410 -1530 2400 -1520 2340 -1520 2330 -1530 2330 -1570 2340 -1580 2370 -1580 {bezier=1}
P 1 14 650 -1600 672.5 -1600 677.5 -1600 677.5 -1595 677.5 -1552.5 670 -1527.5 665 -1527.5 635 -1527.5 630 -1527.5 622.5 -1552.5 622.5 -1595 622.5 -1600 627.5 -1600 650 -1600 {bezier=1}
P 1 14 665 -1597.5 670 -1597.5 675 -1597.5 675 -1592.5 675 -1572.5 675 -1567.5 670 -1567.5 660 -1567.5 655 -1567.5 655 -1572.5 655 -1592.5 655 -1597.5 660 -1597.5 665 -1597.5 {bezier=1}
P 1 5 647.5 -1595 652.5 -1595 652.5 -1570 647.5 -1570 647.5 -1595 {}
P 1 14 1100 -1600 1122.5 -1600 1127.5 -1600 1127.5 -1595 1127.5 -1552.5 1120 -1527.5 1115 -1527.5 1085 -1527.5 1080 -1527.5 1072.5 -1552.5 1072.5 -1595 1072.5 -1600 1077.5 -1600 1100 -1600 {bezier=1}
P 1 14 1115 -1597.5 1120 -1597.5 1125 -1597.5 1125 -1592.5 1125 -1572.5 1125 -1567.5 1120 -1567.5 1110 -1567.5 1105 -1567.5 1105 -1572.5 1105 -1592.5 1105 -1597.5 1110 -1597.5 1115 -1597.5 {bezier=1}
P 1 5 1097.5 -1595 1102.5 -1595 1102.5 -1570 1097.5 -1570 1097.5 -1595 {}
P 1 14 1085 -1597.5 1090 -1597.5 1095 -1597.5 1095 -1592.5 1095 -1572.5 1095 -1567.5 1090 -1567.5 1080 -1567.5 1075 -1567.5 1075 -1572.5 1075 -1592.5 1075 -1597.5 1080 -1597.5 1085 -1597.5 {bezier=1}
P 1 14 1520 -1570 1542.5 -1570 1547.5 -1570 1547.5 -1565 1547.5 -1522.5 1540 -1497.5 1535 -1497.5 1505 -1497.5 1500 -1497.5 1492.5 -1522.5 1492.5 -1565 1492.5 -1570 1497.5 -1570 1520 -1570 {bezier=1}
P 1 14 1535 -1567.5 1540 -1567.5 1545 -1567.5 1545 -1562.5 1545 -1542.5 1545 -1537.5 1540 -1537.5 1530 -1537.5 1525 -1537.5 1525 -1542.5 1525 -1562.5 1525 -1567.5 1530 -1567.5 1535 -1567.5 {bezier=1}
P 1 5 1517.5 -1565 1522.5 -1565 1522.5 -1540 1517.5 -1540 1517.5 -1565 {}
P 1 14 2450 -1630 2472.5 -1630 2477.5 -1630 2477.5 -1625 2477.5 -1582.5 2470 -1557.5 2465 -1557.5 2435 -1557.5 2430 -1557.5 2422.5 -1582.5 2422.5 -1625 2422.5 -1630 2427.5 -1630 2450 -1630 {bezier=1}
P 1 14 2465 -1627.5 2470 -1627.5 2475 -1627.5 2475 -1622.5 2475 -1602.5 2475 -1597.5 2470 -1597.5 2460 -1597.5 2455 -1597.5 2455 -1602.5 2455 -1622.5 2455 -1627.5 2460 -1627.5 2465 -1627.5 {bezier=1}
P 1 5 2447.5 -1625 2452.5 -1625 2452.5 -1600 2447.5 -1600 2447.5 -1625 {}
P 1 14 2210 -13520 2232.5 -13520 2237.5 -13520 2237.5 -13515 2237.5 -13472.5 2230 -13447.5 2225 -13447.5 2195 -13447.5 2190 -13447.5 2182.5 -13472.5 2182.5 -13515 2182.5 -13520 2187.5 -13520 2210 -13520 {bezier=1}
P 1 14 2225 -13517.5 2230 -13517.5 2235 -13517.5 2235 -13512.5 2235 -13492.5 2235 -13487.5 2230 -13487.5 2220 -13487.5 2215 -13487.5 2215 -13492.5 2215 -13512.5 2215 -13517.5 2220 -13517.5 2225 -13517.5 {bezier=1}
P 1 5 2207.5 -13515 2212.5 -13515 2212.5 -13490 2207.5 -13490 2207.5 -13515 {}
P 1 10 2210 -13415 2235 -13415 2245 -13405 2245 -13375 2235 -13365 2185 -13365 2175 -13375 2175 -13405 2185 -13415 2210 -13415 {bezier=1}
P 1 10 2210 -13420 2240 -13420 2250 -13410 2250 -13370 2240 -13360 2180 -13360 2170 -13370 2170 -13410 2180 -13420 2210 -13420 {bezier=1}
P 1 10 2210 -13335 2235 -13335 2245 -13325 2245 -13295 2235 -13285 2185 -13285 2175 -13295 2175 -13325 2185 -13335 2210 -13335 {bezier=1}
P 1 10 2210 -13340 2240 -13340 2250 -13330 2250 -13290 2240 -13280 2180 -13280 2170 -13290 2170 -13330 2180 -13340 2210 -13340 {bezier=1}
P 1 14 960 -1270 982.5 -1270 987.5 -1270 987.5 -1265 987.5 -1222.5 980 -1197.5 975 -1197.5 945 -1197.5 940 -1197.5 932.5 -1222.5 932.5 -1265 932.5 -1270 937.5 -1270 960 -1270 {bezier=1}
P 1 14 975 -1267.5 980 -1267.5 985 -1267.5 985 -1262.5 985 -1242.5 985 -1237.5 980 -1237.5 970 -1237.5 965 -1237.5 965 -1242.5 965 -1262.5 965 -1267.5 970 -1267.5 975 -1267.5 {bezier=1}
P 1 5 957.5 -1265 962.5 -1265 962.5 -1240 957.5 -1240 957.5 -1265 {}
P 1 10 1300 -1255 1325 -1255 1335 -1245 1335 -1215 1325 -1205 1275 -1205 1265 -1215 1265 -1245 1275 -1255 1300 -1255 {bezier=1}
P 1 10 1300 -1260 1330 -1260 1340 -1250 1340 -1210 1330 -1200 1270 -1200 1260 -1210 1260 -1250 1270 -1260 1300 -1260 {bezier=1}
P 1 10 1300 -1185 1325 -1185 1335 -1175 1335 -1145 1325 -1135 1275 -1135 1265 -1145 1265 -1175 1275 -1185 1300 -1185 {bezier=1}
P 1 10 1300 -1190 1330 -1190 1340 -1180 1340 -1140 1330 -1130 1270 -1130 1260 -1140 1260 -1180 1270 -1190 1300 -1190 {bezier=1}
P 1 14 1390 -1230 1412.5 -1230 1417.5 -1230 1417.5 -1225 1417.5 -1182.5 1410 -1157.5 1405 -1157.5 1375 -1157.5 1370 -1157.5 1362.5 -1182.5 1362.5 -1225 1362.5 -1230 1367.5 -1230 1390 -1230 {bezier=1}
P 1 14 1405 -1227.5 1410 -1227.5 1415 -1227.5 1415 -1222.5 1415 -1202.5 1415 -1197.5 1410 -1197.5 1400 -1197.5 1395 -1197.5 1395 -1202.5 1395 -1222.5 1395 -1227.5 1400 -1227.5 1405 -1227.5 {bezier=1}
P 1 5 1387.5 -1225 1392.5 -1225 1392.5 -1200 1387.5 -1200 1387.5 -1225 {}
P 1 14 1375 -1227.5 1380 -1227.5 1385 -1227.5 1385 -1222.5 1385 -1202.5 1385 -1197.5 1380 -1197.5 1370 -1197.5 1365 -1197.5 1365 -1202.5 1365 -1222.5 1365 -1227.5 1370 -1227.5 1375 -1227.5 {bezier=1}
P 1 10 1630 -1255 1655 -1255 1665 -1245 1665 -1215 1655 -1205 1605 -1205 1595 -1215 1595 -1245 1605 -1255 1630 -1255 {bezier=1}
P 1 10 1630 -1260 1660 -1260 1670 -1250 1670 -1210 1660 -1200 1600 -1200 1590 -1210 1590 -1250 1600 -1260 1630 -1260 {bezier=1}
P 1 10 1630 -1185 1655 -1185 1665 -1175 1665 -1145 1655 -1135 1605 -1135 1595 -1145 1595 -1175 1605 -1185 1630 -1185 {bezier=1}
P 1 10 1630 -1190 1660 -1190 1670 -1180 1670 -1140 1660 -1130 1600 -1130 1590 -1140 1590 -1180 1600 -1190 1630 -1190 {bezier=1}
P 1 14 1720 -1230 1742.5 -1230 1747.5 -1230 1747.5 -1225 1747.5 -1182.5 1740 -1157.5 1735 -1157.5 1705 -1157.5 1700 -1157.5 1692.5 -1182.5 1692.5 -1225 1692.5 -1230 1697.5 -1230 1720 -1230 {bezier=1}
P 1 14 1735 -1227.5 1740 -1227.5 1745 -1227.5 1745 -1222.5 1745 -1202.5 1745 -1197.5 1740 -1197.5 1730 -1197.5 1725 -1197.5 1725 -1202.5 1725 -1222.5 1725 -1227.5 1730 -1227.5 1735 -1227.5 {bezier=1}
P 1 5 1717.5 -1225 1722.5 -1225 1722.5 -1200 1717.5 -1200 1717.5 -1225 {}
P 1 14 1705 -1227.5 1710 -1227.5 1715 -1227.5 1715 -1222.5 1715 -1202.5 1715 -1197.5 1710 -1197.5 1700 -1197.5 1695 -1197.5 1695 -1202.5 1695 -1222.5 1695 -1227.5 1700 -1227.5 1705 -1227.5 {bezier=1}
P 1 10 1950 -1255 1975 -1255 1985 -1245 1985 -1215 1975 -1205 1925 -1205 1915 -1215 1915 -1245 1925 -1255 1950 -1255 {bezier=1}
P 1 10 1950 -1260 1980 -1260 1990 -1250 1990 -1210 1980 -1200 1920 -1200 1910 -1210 1910 -1250 1920 -1260 1950 -1260 {bezier=1}
P 1 10 1950 -1185 1975 -1185 1985 -1175 1985 -1145 1975 -1135 1925 -1135 1915 -1145 1915 -1175 1925 -1185 1950 -1185 {bezier=1}
P 1 10 1950 -1190 1980 -1190 1990 -1180 1990 -1140 1980 -1130 1920 -1130 1910 -1140 1910 -1180 1920 -1190 1950 -1190 {bezier=1}
P 1 14 2040 -1230 2062.5 -1230 2067.5 -1230 2067.5 -1225 2067.5 -1182.5 2060 -1157.5 2055 -1157.5 2025 -1157.5 2020 -1157.5 2012.5 -1182.5 2012.5 -1225 2012.5 -1230 2017.5 -1230 2040 -1230 {bezier=1}
P 1 14 2055 -1227.5 2060 -1227.5 2065 -1227.5 2065 -1222.5 2065 -1202.5 2065 -1197.5 2060 -1197.5 2050 -1197.5 2045 -1197.5 2045 -1202.5 2045 -1222.5 2045 -1227.5 2050 -1227.5 2055 -1227.5 {bezier=1}
P 1 5 2037.5 -1225 2042.5 -1225 2042.5 -1200 2037.5 -1200 2037.5 -1225 {}
P 1 14 2025 -1227.5 2030 -1227.5 2035 -1227.5 2035 -1222.5 2035 -1202.5 2035 -1197.5 2030 -1197.5 2020 -1197.5 2015 -1197.5 2015 -1202.5 2015 -1222.5 2015 -1227.5 2020 -1227.5 2025 -1227.5 {bezier=1}
P 1 14 1090 -990 1112.5 -990 1117.5 -990 1117.5 -985 1117.5 -942.5 1110 -917.5 1105 -917.5 1075 -917.5 1070 -917.5 1062.5 -942.5 1062.5 -985 1062.5 -990 1067.5 -990 1090 -990 {bezier=1}
P 1 14 1105 -987.5 1110 -987.5 1115 -987.5 1115 -982.5 1115 -962.5 1115 -957.5 1110 -957.5 1100 -957.5 1095 -957.5 1095 -962.5 1095 -982.5 1095 -987.5 1100 -987.5 1105 -987.5 {bezier=1}
P 1 5 1087.5 -985 1092.5 -985 1092.5 -960 1087.5 -960 1087.5 -985 {}
P 1 10 1180 -975 1205 -975 1215 -965 1215 -935 1205 -925 1155 -925 1145 -935 1145 -965 1155 -975 1180 -975 {bezier=1}
P 1 10 1180 -980 1210 -980 1220 -970 1220 -930 1210 -920 1150 -920 1140 -930 1140 -970 1150 -980 1180 -980 {bezier=1}
P 1 10 1600 -975 1625 -975 1635 -965 1635 -935 1625 -925 1575 -925 1565 -935 1565 -965 1575 -975 1600 -975 {bezier=1}
P 1 10 1600 -980 1630 -980 1640 -970 1640 -930 1630 -920 1570 -920 1560 -930 1560 -970 1570 -980 1600 -980 {bezier=1}
P 1 14 540 -520 562.5 -520 567.5 -520 567.5 -515 567.5 -472.5 560 -447.5 555 -447.5 525 -447.5 520 -447.5 512.5 -472.5 512.5 -515 512.5 -520 517.5 -520 540 -520 {bezier=1}
P 1 14 555 -517.5 560 -517.5 565 -517.5 565 -512.5 565 -492.5 565 -487.5 560 -487.5 550 -487.5 545 -487.5 545 -492.5 545 -512.5 545 -517.5 550 -517.5 555 -517.5 {bezier=1}
P 1 5 537.5 -515 542.5 -515 542.5 -490 537.5 -490 537.5 -515 {}
P 1 10 630 -505 655 -505 665 -495 665 -465 655 -455 605 -455 595 -465 595 -495 605 -505 630 -505 {bezier=1}
P 1 10 630 -510 660 -510 670 -500 670 -460 660 -450 600 -450 590 -460 590 -500 600 -510 630 -510 {bezier=1}
P 1 14 525 -517.5 530 -517.5 535 -517.5 535 -512.5 535 -492.5 535 -487.5 530 -487.5 520 -487.5 515 -487.5 515 -492.5 515 -512.5 515 -517.5 520 -517.5 525 -517.5 {bezier=1}
P 1 14 950 -580 972.5 -580 977.5 -580 977.5 -575 977.5 -532.5 970 -507.5 965 -507.5 935 -507.5 930 -507.5 922.5 -532.5 922.5 -575 922.5 -580 927.5 -580 950 -580 {bezier=1}
P 1 14 965 -577.5 970 -577.5 975 -577.5 975 -572.5 975 -552.5 975 -547.5 970 -547.5 960 -547.5 955 -547.5 955 -552.5 955 -572.5 955 -577.5 960 -577.5 965 -577.5 {bezier=1}
P 1 5 947.5 -575 952.5 -575 952.5 -550 947.5 -550 947.5 -575 {}
P 1 14 1240 -460 1262.5 -460 1267.5 -460 1267.5 -455 1267.5 -412.5 1260 -387.5 1255 -387.5 1225 -387.5 1220 -387.5 1212.5 -412.5 1212.5 -455 1212.5 -460 1217.5 -460 1240 -460 {bezier=1}
P 1 14 1255 -457.5 1260 -457.5 1265 -457.5 1265 -452.5 1265 -432.5 1265 -427.5 1260 -427.5 1250 -427.5 1245 -427.5 1245 -432.5 1245 -452.5 1245 -457.5 1250 -457.5 1255 -457.5 {bezier=1}
P 1 5 1237.5 -455 1242.5 -455 1242.5 -430 1237.5 -430 1237.5 -455 {}
P 1 14 1420 -520 1442.5 -520 1447.5 -520 1447.5 -515 1447.5 -472.5 1440 -447.5 1435 -447.5 1405 -447.5 1400 -447.5 1392.5 -472.5 1392.5 -515 1392.5 -520 1397.5 -520 1420 -520 {bezier=1}
P 1 14 1435 -517.5 1440 -517.5 1445 -517.5 1445 -512.5 1445 -492.5 1445 -487.5 1440 -487.5 1430 -487.5 1425 -487.5 1425 -492.5 1425 -512.5 1425 -517.5 1430 -517.5 1435 -517.5 {bezier=1}
P 1 5 1417.5 -515 1422.5 -515 1422.5 -490 1417.5 -490 1417.5 -515 {}
P 1 14 1720 -490 1742.5 -490 1747.5 -490 1747.5 -485 1747.5 -442.5 1740 -417.5 1735 -417.5 1705 -417.5 1700 -417.5 1692.5 -442.5 1692.5 -485 1692.5 -490 1697.5 -490 1720 -490 {bezier=1}
P 1 14 1735 -487.5 1740 -487.5 1745 -487.5 1745 -482.5 1745 -462.5 1745 -457.5 1740 -457.5 1730 -457.5 1725 -457.5 1725 -462.5 1725 -482.5 1725 -487.5 1730 -487.5 1735 -487.5 {bezier=1}
P 1 5 1717.5 -485 1722.5 -485 1722.5 -460 1717.5 -460 1717.5 -485 {}
P 1 14 2090 -480 2112.5 -480 2117.5 -480 2117.5 -475 2117.5 -432.5 2110 -407.5 2105 -407.5 2075 -407.5 2070 -407.5 2062.5 -432.5 2062.5 -475 2062.5 -480 2067.5 -480 2090 -480 {bezier=1}
P 1 14 2105 -477.5 2110 -477.5 2115 -477.5 2115 -472.5 2115 -452.5 2115 -447.5 2110 -447.5 2100 -447.5 2095 -447.5 2095 -452.5 2095 -472.5 2095 -477.5 2100 -477.5 2105 -477.5 {bezier=1}
P 1 5 2087.5 -475 2092.5 -475 2092.5 -450 2087.5 -450 2087.5 -475 {}
P 1 14 2350 -430 2372.5 -430 2377.5 -430 2377.5 -425 2377.5 -382.5 2370 -357.5 2365 -357.5 2335 -357.5 2330 -357.5 2322.5 -382.5 2322.5 -425 2322.5 -430 2327.5 -430 2350 -430 {bezier=1}
P 1 14 2365 -427.5 2370 -427.5 2375 -427.5 2375 -422.5 2375 -402.5 2375 -397.5 2370 -397.5 2360 -397.5 2355 -397.5 2355 -402.5 2355 -422.5 2355 -427.5 2360 -427.5 2365 -427.5 {bezier=1}
P 1 5 2347.5 -425 2352.5 -425 2352.5 -400 2347.5 -400 2347.5 -425 {}
P 1 10 2507.5 -475 2532.5 -475 2542.5 -465 2542.5 -435 2532.5 -425 2482.5 -425 2472.5 -435 2472.5 -465 2482.5 -475 2507.5 -475 {bezier=1}
P 1 10 2507.5 -480 2537.5 -480 2547.5 -470 2547.5 -430 2537.5 -420 2477.5 -420 2467.5 -430 2467.5 -470 2477.5 -480 2507.5 -480 {bezier=1}
P 1 14 820 -128.75 842.5 -128.75 847.5 -128.75 847.5 -123.75 847.5 -81.25 840 -56.25 835 -56.25 805 -56.25 800 -56.25 792.5 -81.25 792.5 -123.75 792.5 -128.75 797.5 -128.75 820 -128.75 {bezier=1}
P 1 14 835 -126.25 840 -126.25 845 -126.25 845 -121.25 845 -101.25 845 -96.25 840 -96.25 830 -96.25 825 -96.25 825 -101.25 825 -121.25 825 -126.25 830 -126.25 835 -126.25 {bezier=1}
P 1 5 817.5 -123.75 822.5 -123.75 822.5 -98.75 817.5 -98.75 817.5 -123.75 {}
P 1 10 1143.75 -258.75 1168.75 -258.75 1178.75 -248.75 1178.75 -218.75 1168.75 -208.75 1118.75 -208.75 1108.75 -218.75 1108.75 -248.75 1118.75 -258.75 1143.75 -258.75 {bezier=1}
P 1 10 1143.75 -263.75 1173.75 -263.75 1183.75 -253.75 1183.75 -213.75 1173.75 -203.75 1113.75 -203.75 1103.75 -213.75 1103.75 -253.75 1113.75 -263.75 1143.75 -263.75 {bezier=1}
P 1 14 1710 -150 1732.5 -150 1737.5 -150 1737.5 -145 1737.5 -102.5 1730 -77.5 1725 -77.5 1695 -77.5 1690 -77.5 1682.5 -102.5 1682.5 -145 1682.5 -150 1687.5 -150 1710 -150 {bezier=1}
P 1 14 1725 -147.5 1730 -147.5 1735 -147.5 1735 -142.5 1735 -122.5 1735 -117.5 1730 -117.5 1720 -117.5 1715 -117.5 1715 -122.5 1715 -142.5 1715 -147.5 1720 -147.5 1725 -147.5 {bezier=1}
P 1 5 1707.5 -145 1712.5 -145 1712.5 -120 1707.5 -120 1707.5 -145 {}
P 1 14 2260 -200 2282.5 -200 2287.5 -200 2287.5 -195 2287.5 -152.5 2280 -127.5 2275 -127.5 2245 -127.5 2240 -127.5 2232.5 -152.5 2232.5 -195 2232.5 -200 2237.5 -200 2260 -200 {bezier=1}
P 1 14 2275 -197.5 2280 -197.5 2285 -197.5 2285 -192.5 2285 -172.5 2285 -167.5 2280 -167.5 2270 -167.5 2265 -167.5 2265 -172.5 2265 -192.5 2265 -197.5 2270 -197.5 2275 -197.5 {bezier=1}
P 1 5 2257.5 -195 2262.5 -195 2262.5 -170 2257.5 -170 2257.5 -195 {}
P 1 10 1710 -6255 1735 -6255 1745 -6245 1745 -6215 1735 -6205 1685 -6205 1675 -6215 1675 -6245 1685 -6255 1710 -6255 {bezier=1}
P 1 10 1710 -6260 1740 -6260 1750 -6250 1750 -6210 1740 -6200 1680 -6200 1670 -6210 1670 -6250 1680 -6260 1710 -6260 {bezier=1}
P 1 10 2560 -6435 2585 -6435 2595 -6425 2595 -6395 2585 -6385 2535 -6385 2525 -6395 2525 -6425 2535 -6435 2560 -6435 {bezier=1}
P 1 10 2560 -6440 2590 -6440 2600 -6430 2600 -6390 2590 -6380 2530 -6380 2520 -6390 2520 -6430 2530 -6440 2560 -6440 {bezier=1}
P 1 14 1300 -10500 1322.5 -10500 1327.5 -10500 1327.5 -10495 1327.5 -10452.5 1320 -10427.5 1315 -10427.5 1285 -10427.5 1280 -10427.5 1272.5 -10452.5 1272.5 -10495 1272.5 -10500 1277.5 -10500 1300 -10500 {bezier=1}
P 1 14 1315 -10497.5 1320 -10497.5 1325 -10497.5 1325 -10492.5 1325 -10472.5 1325 -10467.5 1320 -10467.5 1310 -10467.5 1305 -10467.5 1305 -10472.5 1305 -10492.5 1305 -10497.5 1310 -10497.5 1315 -10497.5 {bezier=1}
P 1 5 1297.5 -10495 1302.5 -10495 1302.5 -10470 1297.5 -10470 1297.5 -10495 {}
P 1 14 2550 -10560 2572.5 -10560 2577.5 -10560 2577.5 -10555 2577.5 -10512.5 2570 -10487.5 2565 -10487.5 2535 -10487.5 2530 -10487.5 2522.5 -10512.5 2522.5 -10555 2522.5 -10560 2527.5 -10560 2550 -10560 {bezier=1}
P 1 14 2565 -10557.5 2570 -10557.5 2575 -10557.5 2575 -10552.5 2575 -10532.5 2575 -10527.5 2570 -10527.5 2560 -10527.5 2555 -10527.5 2555 -10532.5 2555 -10552.5 2555 -10557.5 2560 -10557.5 2565 -10557.5 {bezier=1}
P 1 5 2547.5 -10555 2552.5 -10555 2552.5 -10530 2547.5 -10530 2547.5 -10555 {}
P 1 14 1770 -10630 1792.5 -10630 1797.5 -10630 1797.5 -10625 1797.5 -10582.5 1790 -10557.5 1785 -10557.5 1755 -10557.5 1750 -10557.5 1742.5 -10582.5 1742.5 -10625 1742.5 -10630 1747.5 -10630 1770 -10630 {bezier=1}
P 1 14 1785 -10627.5 1790 -10627.5 1795 -10627.5 1795 -10622.5 1795 -10602.5 1795 -10597.5 1790 -10597.5 1780 -10597.5 1775 -10597.5 1775 -10602.5 1775 -10622.5 1775 -10627.5 1780 -10627.5 1785 -10627.5 {bezier=1}
P 1 5 1767.5 -10625 1772.5 -10625 1772.5 -10600 1767.5 -10600 1767.5 -10625 {}
P 1 14 2550 -10150 2572.5 -10150 2577.5 -10150 2577.5 -10145 2577.5 -10102.5 2570 -10077.5 2565 -10077.5 2535 -10077.5 2530 -10077.5 2522.5 -10102.5 2522.5 -10145 2522.5 -10150 2527.5 -10150 2550 -10150 {bezier=1}
P 1 14 2565 -10147.5 2570 -10147.5 2575 -10147.5 2575 -10142.5 2575 -10122.5 2575 -10117.5 2570 -10117.5 2560 -10117.5 2555 -10117.5 2555 -10122.5 2555 -10142.5 2555 -10147.5 2560 -10147.5 2565 -10147.5 {bezier=1}
P 1 5 2547.5 -10145 2552.5 -10145 2552.5 -10120 2547.5 -10120 2547.5 -10145 {}
P 1 14 1340 -10180 1362.5 -10180 1367.5 -10180 1367.5 -10175 1367.5 -10132.5 1360 -10107.5 1355 -10107.5 1325 -10107.5 1320 -10107.5 1312.5 -10132.5 1312.5 -10175 1312.5 -10180 1317.5 -10180 1340 -10180 {bezier=1}
P 1 14 1355 -10177.5 1360 -10177.5 1365 -10177.5 1365 -10172.5 1365 -10152.5 1365 -10147.5 1360 -10147.5 1350 -10147.5 1345 -10147.5 1345 -10152.5 1345 -10172.5 1345 -10177.5 1350 -10177.5 1355 -10177.5 {bezier=1}
P 1 5 1337.5 -10175 1342.5 -10175 1342.5 -10150 1337.5 -10150 1337.5 -10175 {}
P 1 10 1420 -10175 1445 -10175 1455 -10165 1455 -10135 1445 -10125 1395 -10125 1385 -10135 1385 -10165 1395 -10175 1420 -10175 {bezier=1}
P 1 10 1420 -10180 1450 -10180 1460 -10170 1460 -10130 1450 -10120 1390 -10120 1380 -10130 1380 -10170 1390 -10180 1420 -10180 {bezier=1}
P 1 10 1690 -10115 1715 -10115 1725 -10105 1725 -10075 1715 -10065 1665 -10065 1655 -10075 1655 -10105 1665 -10115 1690 -10115 {bezier=1}
P 1 10 1690 -10120 1720 -10120 1730 -10110 1730 -10070 1720 -10060 1660 -10060 1650 -10070 1650 -10110 1660 -10120 1690 -10120 {bezier=1}
P 2 7 897.5 -6830 893.75 -6835 885 -6835 888.75 -6830 885 -6825 893.75 -6825 897.5 -6830 {fill=true}
P 2 7 1457.5 -6830 1453.75 -6835 1445 -6835 1448.75 -6830 1445 -6825 1453.75 -6825 1457.5 -6830 {fill=true}
P 2 7 2277.5 -6830 2273.75 -6835 2265 -6835 2268.75 -6830 2265 -6825 2273.75 -6825 2277.5 -6830 {fill=true}
P 2 7 2030 -3210 2020 -3220 2030 -3220 2030 -3220 2010 -3230 2020 -3210 2020 -3220 {}
P 2 7 1520 -3110 1510 -3120 1520 -3120 1520 -3120 1500 -3130 1510 -3110 1510 -3120 {}
P 2 7 2030 -2830 2020 -2840 2030 -2840 2030 -2840 2010 -2850 2020 -2830 2020 -2840 {}
P 2 7 1520 -2730 1510 -2740 1520 -2740 1520 -2740 1500 -2750 1510 -2730 1510 -2740 {}
P 2 7 455 -9380 451.25 -9385 442.5 -9385 446.25 -9380 442.5 -9375 451.25 -9375 455 -9380 {fill=true}
P 2 7 820 -9385 825 -9388.75 825 -9397.5 820 -9393.75 815 -9397.5 815 -9388.75 820 -9385 {fill=true}
P 2 7 1175 -9310 1178.75 -9305 1187.5 -9305 1183.75 -9310 1187.5 -9315 1178.75 -9315 1175 -9310 {fill=true}
P 2 7 1410 -9315 1405 -9311.25 1405 -9302.5 1410 -9306.25 1415 -9302.5 1415 -9311.25 1410 -9315 {fill=true}
P 2 7 1750 -9315 1755 -9311.25 1755 -9302.5 1750 -9306.25 1745 -9302.5 1745 -9311.25 1750 -9315 {fill=true}
P 2 7 2080 -9395 2085 -9398.75 2085 -9407.5 2080 -9403.75 2075 -9407.5 2075 -9398.75 2080 -9395 {fill=true}
P 2 7 605 -8880 601.25 -8885 592.5 -8885 596.25 -8880 592.5 -8875 601.25 -8875 605 -8880 {fill=true}
P 2 7 1080 -8880 1076.25 -8885 1067.5 -8885 1071.25 -8880 1067.5 -8875 1076.25 -8875 1080 -8880 {fill=true}
P 2 7 1700 -8955 1705 -8958.75 1705 -8967.5 1700 -8963.75 1695 -8967.5 1695 -8958.75 1700 -8955 {fill=true}
P 2 7 605 -8450 601.25 -8455 592.5 -8455 596.25 -8450 592.5 -8445 601.25 -8445 605 -8450 {fill=true}
P 2 7 1055 -8450 1051.25 -8455 1042.5 -8455 1046.25 -8450 1042.5 -8445 1051.25 -8445 1055 -8450 {fill=true}
P 2 7 1765 -8450 1768.75 -8455 1777.5 -8455 1773.75 -8450 1777.5 -8445 1768.75 -8445 1765 -8450 {fill=true}
P 2 4 1600 -540 1700 -600 1730 -480 1600 -540 {}
P 2 4 1820 -540 1920 -600 2040 -500 1820 -540 {}
P 2 5 2160 -540 2260 -600 2380 -500 2300 -450 2160 -540 {}
P 2 14 2430 -480 2452.5 -480 2457.5 -480 2457.5 -475 2457.5 -432.5 2450 -407.5 2445 -407.5 2415 -407.5 2410 -407.5 2402.5 -432.5 2402.5 -475 2402.5 -480 2407.5 -480 2430 -480 {bezier=1 dash=4}
P 2 14 2445 -477.5 2450 -477.5 2455 -477.5 2455 -472.5 2455 -452.5 2455 -447.5 2450 -447.5 2440 -447.5 2435 -447.5 2435 -452.5 2435 -472.5 2435 -477.5 2440 -477.5 2445 -477.5 {bezier=1
dash=4}
P 2 5 2427.5 -475 2432.5 -475 2432.5 -450 2427.5 -450 2427.5 -475 {dash=4}
P 2 7 2397.5 -482.5 2390 -490 2395 -495 2380 -500 2385 -485 2390 -490 2397.5 -482.5 {fill=1 dash=4}
P 2 4 700 -178.75 800 -238.75 830 -118.75 700 -178.75 {}
P 2 4 1360 -180 1460 -240 1490 -120 1360 -180 {bezier=1}
P 2 4 1680 -180 1780 -240 1810 -120 1680 -180 {bezier=1}
P 2 4 2220 -230 2060 -230 2090 -110 1960 -170 {bezier=1}
P 3 6 1280 -3790 1280 -3800 1270 -3800 1280 -3820 1290 -3800 1280 -3800 {}
P 3 6 740 -3790 740 -3800 730 -3800 740 -3820 750 -3800 740 -3800 {}
P 3 6 1750 -6390 1860 -6390 1860 -6400 1900 -6390 1860 -6380 1860 -6390 {}
P 3 6 1680 -6390 1570 -6390 1570 -6400 1530 -6390 1570 -6380 1570 -6390 {}
P 3 6 2420 -6390 2420 -6280 2430 -6280 2420 -6240 2410 -6280 2420 -6280 {}
P 3 6 2420 -6410 2420 -6520 2430 -6520 2420 -6560 2410 -6520 2420 -6520 {}
P 4 4 1115 -9010 1185 -8980 1185 -8870 1125 -8840 {bezier=1}
P 4 4 1122.5 -8845 1127.5 -8835 1105 -8832.5 1122.5 -8845 {fill=1}
P 4 7 1120 -8520 1170 -8520 1170 -8525 1190 -8520 1170 -8515 1170 -8520 1120 -8520 {fill=1}
P 4 7 1120 -8520 1070 -8520 1070 -8525 1050 -8520 1070 -8515 1070 -8520 1120 -8520 {fill=1}
P 4 7 2420 -400 2390 -375 2385 -380 2376.25 -363.75 2395 -370 2390 -375 2420 -400 {fill=1}
P 5 7 1105 -12530 1101.25 -12535 1092.5 -12535 1096.25 -12530 1092.5 -12525 1101.25 -12525 1105 -12530 {fill=true}
P 5 7 1427.5 -12560 1423.75 -12565 1415 -12565 1418.75 -12560 1415 -12555 1423.75 -12555 1427.5 -12560 {fill=true}
P 5 7 1645 -12530 1641.25 -12535 1632.5 -12535 1636.25 -12530 1632.5 -12525 1641.25 -12525 1645 -12530 {fill=true}
P 5 7 1967.5 -12560 1963.75 -12565 1955 -12565 1958.75 -12560 1955 -12555 1963.75 -12555 1967.5 -12560 {fill=true}
P 5 7 575 -12530 571.25 -12535 562.5 -12535 566.25 -12530 562.5 -12525 571.25 -12525 575 -12530 {fill=true}
P 5 7 897.5 -12560 893.75 -12565 885 -12565 888.75 -12560 885 -12555 893.75 -12555 897.5 -12560 {fill=true}
P 5 7 575 -12070 571.25 -12075 562.5 -12075 566.25 -12070 562.5 -12065 571.25 -12065 575 -12070 {fill=true}
P 5 7 897.5 -12100 893.75 -12105 885 -12105 888.75 -12100 885 -12095 893.75 -12095 897.5 -12100 {fill=true}
P 5 7 1115 -12070 1111.25 -12075 1102.5 -12075 1106.25 -12070 1102.5 -12065 1111.25 -12065 1115 -12070 {fill=true}
P 5 7 1437.5 -12100 1433.75 -12105 1425 -12105 1428.75 -12100 1425 -12095 1433.75 -12095 1437.5 -12100 {fill=true}
P 5 7 575 -7640 571.25 -7645 562.5 -7645 566.25 -7640 562.5 -7635 571.25 -7635 575 -7640 {fill=true}
P 5 7 897.5 -7670 893.75 -7675 885 -7675 888.75 -7670 885 -7665 893.75 -7665 897.5 -7670 {fill=true}
P 5 7 1115 -7640 1111.25 -7645 1102.5 -7645 1106.25 -7640 1102.5 -7635 1111.25 -7635 1115 -7640 {fill=true}
P 5 7 1437.5 -7670 1433.75 -7675 1425 -7675 1428.75 -7670 1425 -7665 1433.75 -7665 1437.5 -7670 {fill=true}
P 5 7 575 -7240 571.25 -7245 562.5 -7245 566.25 -7240 562.5 -7235 571.25 -7235 575 -7240 {fill=true}
P 5 7 897.5 -7270 893.75 -7275 885 -7275 888.75 -7270 885 -7265 893.75 -7265 897.5 -7270 {fill=true}
P 5 7 1115 -7240 1111.25 -7245 1102.5 -7245 1106.25 -7240 1102.5 -7235 1111.25 -7235 1115 -7240 {fill=true}
P 5 7 1437.5 -7270 1433.75 -7275 1425 -7275 1428.75 -7270 1425 -7265 1433.75 -7265 1437.5 -7270 {fill=true}
P 5 7 575 -6800 571.25 -6805 562.5 -6805 566.25 -6800 562.5 -6795 571.25 -6795 575 -6800 {fill=true}
P 5 7 1765 -6800 1761.25 -6805 1752.5 -6805 1756.25 -6800 1752.5 -6795 1761.25 -6795 1765 -6800 {fill=true}
P 5 7 1135 -6800 1131.25 -6805 1122.5 -6805 1126.25 -6800 1122.5 -6795 1131.25 -6795 1135 -6800 {fill=true}
P 5 7 1105 -11700 1101.25 -11705 1092.5 -11705 1096.25 -11700 1092.5 -11695 1101.25 -11695 1105 -11700 {fill=true}
P 5 7 1427.5 -11730 1423.75 -11735 1415 -11735 1418.75 -11730 1415 -11725 1423.75 -11725 1427.5 -11730 {fill=true}
P 5 7 575 -11700 571.25 -11705 562.5 -11705 566.25 -11700 562.5 -11695 571.25 -11695 575 -11700 {fill=true}
P 5 7 897.5 -11730 893.75 -11735 885 -11735 888.75 -11730 885 -11725 893.75 -11725 897.5 -11730 {fill=true}
P 5 7 1605 -11700 1601.25 -11705 1592.5 -11705 1596.25 -11700 1592.5 -11695 1601.25 -11695 1605 -11700 {fill=true}
P 5 7 1927.5 -11730 1923.75 -11735 1915 -11735 1918.75 -11730 1915 -11725 1923.75 -11725 1927.5 -11730 {fill=true}
P 5 7 1645 -13000 1641.25 -13005 1632.5 -13005 1636.25 -13000 1632.5 -12995 1641.25 -12995 1645 -13000 {fill=true}
P 5 7 1967.5 -13030 1963.75 -13035 1955 -13035 1958.75 -13030 1955 -13025 1963.75 -13025 1967.5 -13030 {fill=true}
P 5 7 520 -13000 516.25 -13005 507.5 -13005 511.25 -13000 507.5 -12995 516.25 -12995 520 -13000 {fill=true}
P 5 7 842.5 -13030 838.75 -13035 830 -13035 833.75 -13030 830 -13025 838.75 -13025 842.5 -13030 {fill=true}
P 5 7 2105 -13000 2101.25 -13005 2092.5 -13005 2096.25 -13000 2092.5 -12995 2101.25 -12995 2105 -13000 {fill=true}
P 5 7 2427.5 -13030 2423.75 -13035 2415 -13035 2418.75 -13030 2415 -13025 2423.75 -13025 2427.5 -13030 {fill=true}
P 5 7 595 -10860 591.25 -10865 582.5 -10865 586.25 -10860 582.5 -10855 591.25 -10855 595 -10860 {fill=true}
P 5 7 917.5 -10890 913.75 -10895 905 -10895 908.75 -10890 905 -10885 913.75 -10885 917.5 -10890 {fill=true}
P 5 7 1135 -10860 1131.25 -10865 1122.5 -10865 1126.25 -10860 1122.5 -10855 1131.25 -10855 1135 -10860 {fill=true}
P 5 7 1457.5 -10890 1453.75 -10895 1445 -10895 1448.75 -10890 1445 -10885 1453.75 -10885 1457.5 -10890 {fill=true}
P 5 7 2265 -10860 2261.25 -10865 2252.5 -10865 2256.25 -10860 2252.5 -10855 2261.25 -10855 2265 -10860 {fill=true}
P 5 7 2587.5 -10890 2583.75 -10895 2575 -10895 2578.75 -10890 2575 -10885 2583.75 -10885 2587.5 -10890 {fill=true}
P 5 7 1105 -13000 1101.25 -13005 1092.5 -13005 1096.25 -13000 1092.5 -12995 1101.25 -12995 1105 -13000 {fill=true}
P 5 7 1427.5 -13030 1423.75 -13035 1415 -13035 1418.75 -13030 1415 -13025 1423.75 -13025 1427.5 -13030 {fill=true}
P 5 7 655 -2330 651.25 -2335 642.5 -2335 646.25 -2330 642.5 -2325 651.25 -2325 655 -2330 {fill=true}
P 5 7 977.5 -2360 973.75 -2365 965 -2365 968.75 -2360 965 -2355 973.75 -2355 977.5 -2360 {fill=true}
P 5 7 1255 -2330 1251.25 -2335 1242.5 -2335 1246.25 -2330 1242.5 -2325 1251.25 -2325 1255 -2330 {fill=true}
P 5 7 1577.5 -2360 1573.75 -2365 1565 -2365 1568.75 -2360 1565 -2355 1573.75 -2355 1577.5 -2360 {fill=true}
P 5 7 1865 -2330 1861.25 -2335 1852.5 -2335 1856.25 -2330 1852.5 -2325 1861.25 -2325 1865 -2330 {fill=true}
P 5 7 2187.5 -2360 2183.75 -2365 2175 -2365 2178.75 -2360 2175 -2355 2183.75 -2355 2187.5 -2360 {fill=true}
P 5 7 595 -6390 591.25 -6395 582.5 -6395 586.25 -6390 582.5 -6385 591.25 -6385 595 -6390 {fill=true}
P 5 7 917.5 -6420 913.75 -6425 905 -6425 908.75 -6420 905 -6415 913.75 -6415 917.5 -6420 {fill=true}
P 5 7 1155 -6390 1151.25 -6395 1142.5 -6395 1146.25 -6390 1142.5 -6385 1151.25 -6385 1155 -6390 {fill=true}
P 5 7 1477.5 -6420 1473.75 -6425 1465 -6425 1468.75 -6420 1465 -6415 1473.75 -6415 1477.5 -6420 {fill=true}
P 5 7 540 -11280 536.25 -11285 527.5 -11285 531.25 -11280 527.5 -11275 536.25 -11275 540 -11280 {fill=true}
P 5 7 862.5 -11310 858.75 -11315 850 -11315 853.75 -11310 850 -11305 858.75 -11305 862.5 -11310 {fill=true}
P 5 7 1105 -11280 1101.25 -11285 1092.5 -11285 1096.25 -11280 1092.5 -11275 1101.25 -11275 1105 -11280 {fill=true}
P 5 7 1427.5 -11310 1423.75 -11315 1415 -11315 1418.75 -11310 1415 -11305 1423.75 -11305 1427.5 -11310 {fill=true}
P 5 7 1605 -11280 1601.25 -11285 1592.5 -11285 1596.25 -11280 1592.5 -11275 1601.25 -11275 1605 -11280 {fill=true}
P 5 7 1927.5 -11310 1923.75 -11315 1915 -11315 1918.75 -11310 1915 -11305 1923.75 -11305 1927.5 -11310 {fill=true}
P 5 7 2095 -11280 2091.25 -11285 2082.5 -11285 2086.25 -11280 2082.5 -11275 2091.25 -11275 2095 -11280 {fill=true}
P 5 7 2417.5 -11310 2413.75 -11315 2405 -11315 2408.75 -11310 2405 -11305 2413.75 -11305 2417.5 -11310 {fill=true}
P 5 38 90 -13395 85 -13390 75 -13380 85 -13370 97.5 -13357.5 105 -13350 97.5 -13350 90 -13350 85 -13350 80 -13355 75 -13360 65 -13370 55 -13360 50 -13355 45 -13350 40 -13350 32.5 -13350 25 -13350 32.5 -13357.5 45 -13370 55 -13380 45 -13390 32.5 -13402.5 25 -13410 32.5 -13410 40 -13410 45 -13410 50 -13405 55 -13400 65 -13390 75 -13400 80 -13405 85 -13410 90 -13410 97.5 -13410 105 -13410 97.5 -13402.5 90 -13395 {fill=true
bezier=1}
P 7 14 905 -12387.5 910 -12387.5 915 -12387.5 915 -12382.5 915 -12362.5 915 -12357.5 910 -12357.5 900 -12357.5 895 -12357.5 895 -12362.5 895 -12382.5 895 -12387.5 900 -12387.5 905 -12387.5 {fill=1
bezier=1}
P 7 14 1335 -12387.5 1340 -12387.5 1345 -12387.5 1345 -12382.5 1345 -12362.5 1345 -12357.5 1340 -12357.5 1330 -12357.5 1325 -12357.5 1325 -12362.5 1325 -12382.5 1325 -12387.5 1330 -12387.5 1335 -12387.5 {fill=1
bezier=1}
P 7 14 1405 -12197.5 1410 -12197.5 1415 -12197.5 1415 -12192.5 1415 -12172.5 1415 -12167.5 1410 -12167.5 1400 -12167.5 1395 -12167.5 1395 -12172.5 1395 -12192.5 1395 -12197.5 1400 -12197.5 1405 -12197.5 {fill=1
bezier=1}
P 7 14 1425 -7777.5 1430 -7777.5 1435 -7777.5 1435 -7772.5 1435 -7752.5 1435 -7747.5 1430 -7747.5 1420 -7747.5 1415 -7747.5 1415 -7752.5 1415 -7772.5 1415 -7777.5 1420 -7777.5 1425 -7777.5 {fill=1
bezier=1}
P 7 14 1425 -7377.5 1430 -7377.5 1435 -7377.5 1435 -7372.5 1435 -7352.5 1435 -7347.5 1430 -7347.5 1420 -7347.5 1415 -7347.5 1415 -7352.5 1415 -7372.5 1415 -7377.5 1420 -7377.5 1425 -7377.5 {fill=1
bezier=1}
P 7 14 935 -6697.5 940 -6697.5 945 -6697.5 945 -6692.5 945 -6672.5 945 -6667.5 940 -6667.5 930 -6667.5 925 -6667.5 925 -6672.5 925 -6692.5 925 -6697.5 930 -6697.5 935 -6697.5 {fill=1
bezier=1}
P 7 14 1435 -6707.5 1440 -6707.5 1445 -6707.5 1445 -6702.5 1445 -6682.5 1445 -6677.5 1440 -6677.5 1430 -6677.5 1425 -6677.5 1425 -6682.5 1425 -6702.5 1425 -6707.5 1430 -6707.5 1435 -6707.5 {fill=1
bezier=1}
P 7 14 905 -11557.5 910 -11557.5 915 -11557.5 915 -11552.5 915 -11532.5 915 -11527.5 910 -11527.5 900 -11527.5 895 -11527.5 895 -11532.5 895 -11552.5 895 -11557.5 900 -11557.5 905 -11557.5 {fill=1
bezier=1}
P 7 14 850 -12857.5 855 -12857.5 860 -12857.5 860 -12852.5 860 -12832.5 860 -12827.5 855 -12827.5 845 -12827.5 840 -12827.5 840 -12832.5 840 -12852.5 840 -12857.5 845 -12857.5 850 -12857.5 {fill=1
bezier=1}
P 7 14 1615 -12847.5 1620 -12847.5 1625 -12847.5 1625 -12842.5 1625 -12822.5 1625 -12817.5 1620 -12817.5 1610 -12817.5 1605 -12817.5 1605 -12822.5 1605 -12842.5 1605 -12847.5 1610 -12847.5 1615 -12847.5 {fill=1
bezier=1}
P 7 14 2395 -12837.5 2400 -12837.5 2405 -12837.5 2405 -12832.5 2405 -12812.5 2405 -12807.5 2400 -12807.5 2390 -12807.5 2385 -12807.5 2385 -12812.5 2385 -12832.5 2385 -12837.5 2390 -12837.5 2395 -12837.5 {fill=1
bezier=1}
P 7 14 675 -10977.5 680 -10977.5 685 -10977.5 685 -10972.5 685 -10952.5 685 -10947.5 680 -10947.5 670 -10947.5 665 -10947.5 665 -10952.5 665 -10972.5 665 -10977.5 670 -10977.5 675 -10977.5 {fill=1
bezier=1}
P 7 14 1335 -10997.5 1340 -10997.5 1345 -10997.5 1345 -10992.5 1345 -10972.5 1345 -10967.5 1340 -10967.5 1330 -10967.5 1325 -10967.5 1325 -10972.5 1325 -10992.5 1325 -10997.5 1330 -10997.5 1335 -10997.5 {fill=1
bezier=1}
P 7 14 1415 -5917.5 1420 -5917.5 1425 -5917.5 1425 -5912.5 1425 -5892.5 1425 -5887.5 1420 -5887.5 1410 -5887.5 1405 -5887.5 1405 -5892.5 1405 -5912.5 1405 -5917.5 1410 -5917.5 1415 -5917.5 {fill=1
bezier=1}
P 7 14 2065 -3187.5 2070 -3187.5 2075 -3187.5 2075 -3182.5 2075 -3162.5 2075 -3157.5 2070 -3157.5 2060 -3157.5 2055 -3157.5 2055 -3162.5 2055 -3182.5 2055 -3187.5 2060 -3187.5 2065 -3187.5 {fill=1
bezier=1}
P 7 14 1555 -3157.5 1560 -3157.5 1565 -3157.5 1565 -3152.5 1565 -3132.5 1565 -3127.5 1560 -3127.5 1550 -3127.5 1545 -3127.5 1545 -3132.5 1545 -3152.5 1545 -3157.5 1550 -3157.5 1555 -3157.5 {fill=1
bezier=1}
P 7 14 1445 -5557.5 1440 -5557.5 1435 -5557.5 1435 -5552.5 1435 -5532.5 1435 -5527.5 1440 -5527.5 1450 -5527.5 1455 -5527.5 1455 -5532.5 1455 -5552.5 1455 -5557.5 1450 -5557.5 1445 -5557.5 {fill=1
bezier=1}
P 7 14 1945 -5667.5 1950 -5667.5 1955 -5667.5 1955 -5662.5 1955 -5642.5 1955 -5637.5 1950 -5637.5 1940 -5637.5 1935 -5637.5 1935 -5642.5 1935 -5662.5 1935 -5667.5 1940 -5667.5 1945 -5667.5 {fill=1
bezier=1}
P 7 14 1565 -5147.5 1570 -5147.5 1575 -5147.5 1575 -5142.5 1575 -5122.5 1575 -5117.5 1570 -5117.5 1560 -5117.5 1555 -5117.5 1555 -5122.5 1555 -5142.5 1555 -5147.5 1560 -5147.5 1565 -5147.5 {fill=1
bezier=1}
P 7 14 2055 -5207.5 2060 -5207.5 2065 -5207.5 2065 -5202.5 2065 -5182.5 2065 -5177.5 2060 -5177.5 2050 -5177.5 2045 -5177.5 2045 -5182.5 2045 -5202.5 2045 -5207.5 2050 -5207.5 2055 -5207.5 {fill=1
bezier=1}
P 7 14 975 -13127.5 980 -13127.5 985 -13127.5 985 -13122.5 985 -13102.5 985 -13097.5 980 -13097.5 970 -13097.5 965 -13097.5 965 -13102.5 965 -13122.5 965 -13127.5 970 -13127.5 975 -13127.5 {fill=1
bezier=1}
P 7 14 1555 -2777.5 1560 -2777.5 1565 -2777.5 1565 -2772.5 1565 -2752.5 1565 -2747.5 1560 -2747.5 1550 -2747.5 1545 -2747.5 1545 -2752.5 1545 -2772.5 1545 -2777.5 1550 -2777.5 1555 -2777.5 {fill=1
bezier=1}
P 7 14 2065 -2727.5 2070 -2727.5 2075 -2727.5 2075 -2722.5 2075 -2702.5 2075 -2697.5 2070 -2697.5 2060 -2697.5 2055 -2697.5 2055 -2702.5 2055 -2722.5 2055 -2727.5 2060 -2727.5 2065 -2727.5 {fill=1
bezier=1}
P 7 14 2485 -5587.5 2490 -5587.5 2495 -5587.5 2495 -5582.5 2495 -5562.5 2495 -5557.5 2490 -5557.5 2480 -5557.5 2475 -5557.5 2475 -5562.5 2475 -5582.5 2475 -5587.5 2480 -5587.5 2485 -5587.5 {fill=1
bezier=1}
P 7 14 1805 -3627.5 1810 -3627.5 1815 -3627.5 1815 -3622.5 1815 -3602.5 1815 -3597.5 1810 -3597.5 1800 -3597.5 1795 -3597.5 1795 -3602.5 1795 -3622.5 1795 -3627.5 1800 -3627.5 1805 -3627.5 {fill=1
bezier=1}
P 7 14 655 -3557.5 660 -3557.5 665 -3557.5 665 -3552.5 665 -3532.5 665 -3527.5 660 -3527.5 650 -3527.5 645 -3527.5 645 -3532.5 645 -3552.5 645 -3557.5 650 -3557.5 655 -3557.5 {fill=1
bezier=1}
P 7 14 775 -3557.5 780 -3557.5 785 -3557.5 785 -3552.5 785 -3532.5 785 -3527.5 780 -3527.5 770 -3527.5 765 -3527.5 765 -3532.5 765 -3552.5 765 -3557.5 770 -3557.5 775 -3557.5 {fill=1
bezier=1}
P 7 14 1615 -2227.5 1610 -2227.5 1605 -2227.5 1605 -2222.5 1605 -2202.5 1605 -2197.5 1610 -2197.5 1620 -2197.5 1625 -2197.5 1625 -2202.5 1625 -2222.5 1625 -2227.5 1620 -2227.5 1615 -2227.5 {fill=1
bezier=1}
P 7 14 2265 -6707.5 2270 -6707.5 2275 -6707.5 2275 -6702.5 2275 -6682.5 2275 -6677.5 2270 -6677.5 2260 -6677.5 2255 -6677.5 2255 -6682.5 2255 -6702.5 2255 -6707.5 2260 -6707.5 2265 -6707.5 {fill=1
bezier=1}
P 7 14 1965 -5917.5 1970 -5917.5 1975 -5917.5 1975 -5912.5 1975 -5892.5 1975 -5887.5 1970 -5887.5 1960 -5887.5 1955 -5887.5 1955 -5892.5 1955 -5912.5 1955 -5917.5 1960 -5917.5 1965 -5917.5 {fill=1
bezier=1}
P 7 14 2325 -4217.5 2330 -4217.5 2335 -4217.5 2335 -4212.5 2335 -4192.5 2335 -4187.5 2330 -4187.5 2320 -4187.5 2315 -4187.5 2315 -4192.5 2315 -4212.5 2315 -4217.5 2320 -4217.5 2325 -4217.5 {fill=1
bezier=1}
P 7 14 795 -4337.5 800 -4337.5 805 -4337.5 805 -4332.5 805 -4312.5 805 -4307.5 800 -4307.5 790 -4307.5 785 -4307.5 785 -4312.5 785 -4332.5 785 -4337.5 790 -4337.5 795 -4337.5 {fill=1
bezier=1}
P 7 14 1335 -4317.5 1340 -4317.5 1345 -4317.5 1345 -4312.5 1345 -4292.5 1345 -4287.5 1340 -4287.5 1330 -4287.5 1325 -4287.5 1325 -4292.5 1325 -4312.5 1325 -4317.5 1330 -4317.5 1335 -4317.5 {fill=1
bezier=1}
P 7 14 1245 -3937.5 1250 -3937.5 1255 -3937.5 1255 -3932.5 1255 -3912.5 1255 -3907.5 1250 -3907.5 1240 -3907.5 1235 -3907.5 1235 -3912.5 1235 -3932.5 1235 -3937.5 1240 -3937.5 1245 -3937.5 {fill=1
bezier=1}
P 7 14 2505 -3887.5 2510 -3887.5 2515 -3887.5 2515 -3882.5 2515 -3862.5 2515 -3857.5 2510 -3857.5 2500 -3857.5 2495 -3857.5 2495 -3862.5 2495 -3882.5 2495 -3887.5 2500 -3887.5 2505 -3887.5 {fill=1
bezier=1}
P 7 14 2465 -2477.5 2460 -2477.5 2455 -2477.5 2455 -2472.5 2455 -2452.5 2455 -2447.5 2460 -2447.5 2470 -2447.5 2475 -2447.5 2475 -2452.5 2475 -2472.5 2475 -2477.5 2470 -2477.5 2465 -2477.5 {fill=1
bezier=1}
P 7 14 2525 -11047.5 2530 -11047.5 2535 -11047.5 2535 -11042.5 2535 -11022.5 2535 -11017.5 2530 -11017.5 2520 -11017.5 2515 -11017.5 2515 -11022.5 2515 -11042.5 2515 -11047.5 2520 -11047.5 2525 -11047.5 {fill=1
bezier=1}
P 7 14 1335 -11557.5 1340 -11557.5 1345 -11557.5 1345 -11552.5 1345 -11532.5 1345 -11527.5 1340 -11527.5 1330 -11527.5 1325 -11527.5 1325 -11532.5 1325 -11552.5 1325 -11557.5 1330 -11557.5 1335 -11557.5 {fill=1
bezier=1}
P 7 14 2105 -11557.5 2110 -11557.5 2115 -11557.5 2115 -11552.5 2115 -11532.5 2115 -11527.5 2110 -11527.5 2100 -11527.5 2095 -11527.5 2095 -11532.5 2095 -11552.5 2095 -11557.5 2100 -11557.5 2105 -11557.5 {fill=1
bezier=1}
P 7 14 355 -9567.5 360 -9567.5 365 -9567.5 365 -9562.5 365 -9542.5 365 -9537.5 360 -9537.5 350 -9537.5 345 -9537.5 345 -9542.5 345 -9562.5 345 -9567.5 350 -9567.5 355 -9567.5 {fill=1
bezier=1}
P 7 14 885 -9737.5 890 -9737.5 895 -9737.5 895 -9732.5 895 -9712.5 895 -9707.5 890 -9707.5 880 -9707.5 875 -9707.5 875 -9712.5 875 -9732.5 875 -9737.5 880 -9737.5 885 -9737.5 {fill=1
bezier=1}
P 7 14 1135 -9777.5 1140 -9777.5 1145 -9777.5 1145 -9772.5 1145 -9752.5 1145 -9747.5 1140 -9747.5 1130 -9747.5 1125 -9747.5 1125 -9752.5 1125 -9772.5 1125 -9777.5 1130 -9777.5 1135 -9777.5 {fill=1
bezier=1}
P 7 14 1425 -9777.5 1430 -9777.5 1435 -9777.5 1435 -9772.5 1435 -9752.5 1435 -9747.5 1430 -9747.5 1420 -9747.5 1415 -9747.5 1415 -9752.5 1415 -9772.5 1415 -9777.5 1420 -9777.5 1425 -9777.5 {fill=1
bezier=1}
P 7 14 1885 -9737.5 1890 -9737.5 1895 -9737.5 1895 -9732.5 1895 -9712.5 1895 -9707.5 1890 -9707.5 1880 -9707.5 1875 -9707.5 1875 -9712.5 1875 -9732.5 1875 -9737.5 1880 -9737.5 1885 -9737.5 {fill=1
bezier=1}
P 7 14 2105 -12387.5 2110 -12387.5 2115 -12387.5 2115 -12382.5 2115 -12362.5 2115 -12357.5 2110 -12357.5 2100 -12357.5 2095 -12357.5 2095 -12362.5 2095 -12382.5 2095 -12387.5 2100 -12387.5 2105 -12387.5 {fill=1
bezier=1}
P 7 14 2585 -5337.5 2590 -5337.5 2595 -5337.5 2595 -5332.5 2595 -5312.5 2595 -5307.5 2590 -5307.5 2580 -5307.5 2575 -5307.5 2575 -5312.5 2575 -5332.5 2575 -5337.5 2580 -5337.5 2585 -5337.5 {fill=1
bezier=1}
P 7 14 915 -6287.5 920 -6287.5 925 -6287.5 925 -6282.5 925 -6262.5 925 -6257.5 920 -6257.5 910 -6257.5 905 -6257.5 905 -6262.5 905 -6282.5 905 -6287.5 910 -6287.5 915 -6287.5 {fill=1
bezier=1}
P 7 14 1755 -6337.5 1760 -6337.5 1765 -6337.5 1765 -6332.5 1765 -6312.5 1765 -6307.5 1760 -6307.5 1750 -6307.5 1745 -6307.5 1745 -6312.5 1745 -6332.5 1745 -6337.5 1750 -6337.5 1755 -6337.5 {fill=1
bezier=1}
P 7 14 2515 -6337.5 2520 -6337.5 2525 -6337.5 2525 -6332.5 2525 -6312.5 2525 -6307.5 2520 -6307.5 2510 -6307.5 2505 -6307.5 2505 -6312.5 2505 -6332.5 2505 -6337.5 2510 -6337.5 2515 -6337.5 {fill=1
bezier=1}
P 7 14 890 -11397.5 895 -11397.5 900 -11397.5 900 -11392.5 900 -11372.5 900 -11367.5 895 -11367.5 885 -11367.5 880 -11367.5 880 -11372.5 880 -11392.5 880 -11397.5 885 -11397.5 890 -11397.5 {fill=1
bezier=1}
P 7 14 1425 -11277.5 1430 -11277.5 1435 -11277.5 1435 -11272.5 1435 -11252.5 1435 -11247.5 1430 -11247.5 1420 -11247.5 1415 -11247.5 1415 -11252.5 1415 -11272.5 1415 -11277.5 1420 -11277.5 1425 -11277.5 {fill=1
bezier=1}
P 7 14 1795 -11277.5 1800 -11277.5 1805 -11277.5 1805 -11272.5 1805 -11252.5 1805 -11247.5 1800 -11247.5 1790 -11247.5 1785 -11247.5 1785 -11252.5 1785 -11272.5 1785 -11277.5 1790 -11277.5 1795 -11277.5 {fill=1
bezier=1}
P 7 14 2285 -11277.5 2290 -11277.5 2295 -11277.5 2295 -11272.5 2295 -11252.5 2295 -11247.5 2290 -11247.5 2280 -11247.5 2275 -11247.5 2275 -11252.5 2275 -11272.5 2275 -11277.5 2280 -11277.5 2285 -11277.5 {fill=1
bezier=1}
P 7 14 2235 -9587.5 2240 -9587.5 2245 -9587.5 2245 -9582.5 2245 -9562.5 2245 -9557.5 2240 -9557.5 2230 -9557.5 2225 -9557.5 2225 -9562.5 2225 -9582.5 2225 -9587.5 2230 -9587.5 2235 -9587.5 {fill=1
bezier=1}
P 7 14 2465 -9647.5 2470 -9647.5 2475 -9647.5 2475 -9642.5 2475 -9622.5 2475 -9617.5 2470 -9617.5 2460 -9617.5 2455 -9617.5 2455 -9622.5 2455 -9642.5 2455 -9647.5 2460 -9647.5 2465 -9647.5 {fill=1
bezier=1}
P 7 14 605 -9777.5 610 -9777.5 615 -9777.5 615 -9772.5 615 -9752.5 615 -9747.5 610 -9747.5 600 -9747.5 595 -9747.5 595 -9752.5 595 -9772.5 595 -9777.5 600 -9777.5 605 -9777.5 {fill=1
bezier=1}
P 7 14 635 -1597.5 640 -1597.5 645 -1597.5 645 -1592.5 645 -1572.5 645 -1567.5 640 -1567.5 630 -1567.5 625 -1567.5 625 -1572.5 625 -1592.5 625 -1597.5 630 -1597.5 635 -1597.5 {fill=1
bezier=1}
P 7 14 1505 -1567.5 1510 -1567.5 1515 -1567.5 1515 -1562.5 1515 -1542.5 1515 -1537.5 1510 -1537.5 1500 -1537.5 1495 -1537.5 1495 -1542.5 1495 -1562.5 1495 -1567.5 1500 -1567.5 1505 -1567.5 {fill=1
bezier=1}
P 7 14 2435 -1627.5 2440 -1627.5 2445 -1627.5 2445 -1622.5 2445 -1602.5 2445 -1597.5 2440 -1597.5 2430 -1597.5 2425 -1597.5 2425 -1602.5 2425 -1622.5 2425 -1627.5 2430 -1627.5 2435 -1627.5 {fill=1
bezier=1}
P 7 14 2195 -13517.5 2200 -13517.5 2205 -13517.5 2205 -13512.5 2205 -13492.5 2205 -13487.5 2200 -13487.5 2190 -13487.5 2185 -13487.5 2185 -13492.5 2185 -13512.5 2185 -13517.5 2190 -13517.5 2195 -13517.5 {fill=1
bezier=1}
P 7 14 945 -1267.5 950 -1267.5 955 -1267.5 955 -1262.5 955 -1242.5 955 -1237.5 950 -1237.5 940 -1237.5 935 -1237.5 935 -1242.5 935 -1262.5 935 -1267.5 940 -1267.5 945 -1267.5 {fill=1
bezier=1}
P 7 14 1075 -987.5 1080 -987.5 1085 -987.5 1085 -982.5 1085 -962.5 1085 -957.5 1080 -957.5 1070 -957.5 1065 -957.5 1065 -962.5 1065 -982.5 1065 -987.5 1070 -987.5 1075 -987.5 {fill=1
bezier=1}
P 7 14 935 -577.5 940 -577.5 945 -577.5 945 -572.5 945 -552.5 945 -547.5 940 -547.5 930 -547.5 925 -547.5 925 -552.5 925 -572.5 925 -577.5 930 -577.5 935 -577.5 {fill=1
bezier=1}
P 7 14 1225 -457.5 1230 -457.5 1235 -457.5 1235 -452.5 1235 -432.5 1235 -427.5 1230 -427.5 1220 -427.5 1215 -427.5 1215 -432.5 1215 -452.5 1215 -457.5 1220 -457.5 1225 -457.5 {fill=1
bezier=1}
P 7 14 1405 -517.5 1410 -517.5 1415 -517.5 1415 -512.5 1415 -492.5 1415 -487.5 1410 -487.5 1400 -487.5 1395 -487.5 1395 -492.5 1395 -512.5 1395 -517.5 1400 -517.5 1405 -517.5 {fill=1
bezier=1}
P 7 14 1705 -487.5 1710 -487.5 1715 -487.5 1715 -482.5 1715 -462.5 1715 -457.5 1710 -457.5 1700 -457.5 1695 -457.5 1695 -462.5 1695 -482.5 1695 -487.5 1700 -487.5 1705 -487.5 {fill=1
bezier=1}
P 7 14 2075 -477.5 2080 -477.5 2085 -477.5 2085 -472.5 2085 -452.5 2085 -447.5 2080 -447.5 2070 -447.5 2065 -447.5 2065 -452.5 2065 -472.5 2065 -477.5 2070 -477.5 2075 -477.5 {fill=1
bezier=1}
P 7 14 2335 -427.5 2340 -427.5 2345 -427.5 2345 -422.5 2345 -402.5 2345 -397.5 2340 -397.5 2330 -397.5 2325 -397.5 2325 -402.5 2325 -422.5 2325 -427.5 2330 -427.5 2335 -427.5 {fill=1
bezier=1}
P 7 14 2415 -477.5 2420 -477.5 2425 -477.5 2425 -472.5 2425 -452.5 2425 -447.5 2420 -447.5 2410 -447.5 2405 -447.5 2405 -452.5 2405 -472.5 2405 -477.5 2410 -477.5 2415 -477.5 {fill=1
bezier=1
dash=4}
P 7 14 805 -126.25 810 -126.25 815 -126.25 815 -121.25 815 -101.25 815 -96.25 810 -96.25 800 -96.25 795 -96.25 795 -101.25 795 -121.25 795 -126.25 800 -126.25 805 -126.25 {fill=1
bezier=1}
P 7 14 1695 -147.5 1700 -147.5 1705 -147.5 1705 -142.5 1705 -122.5 1705 -117.5 1700 -117.5 1690 -117.5 1685 -117.5 1685 -122.5 1685 -142.5 1685 -147.5 1690 -147.5 1695 -147.5 {fill=1
bezier=1}
P 7 14 2245 -197.5 2250 -197.5 2255 -197.5 2255 -192.5 2255 -172.5 2255 -167.5 2250 -167.5 2240 -167.5 2235 -167.5 2235 -172.5 2235 -192.5 2235 -197.5 2240 -197.5 2245 -197.5 {fill=1
bezier=1}
P 7 14 1285 -10497.5 1290 -10497.5 1295 -10497.5 1295 -10492.5 1295 -10472.5 1295 -10467.5 1290 -10467.5 1280 -10467.5 1275 -10467.5 1275 -10472.5 1275 -10492.5 1275 -10497.5 1280 -10497.5 1285 -10497.5 {fill=1
bezier=1}
P 7 14 2535 -10557.5 2540 -10557.5 2545 -10557.5 2545 -10552.5 2545 -10532.5 2545 -10527.5 2540 -10527.5 2530 -10527.5 2525 -10527.5 2525 -10532.5 2525 -10552.5 2525 -10557.5 2530 -10557.5 2535 -10557.5 {fill=1
bezier=1}
P 7 14 1755 -10627.5 1760 -10627.5 1765 -10627.5 1765 -10622.5 1765 -10602.5 1765 -10597.5 1760 -10597.5 1750 -10597.5 1745 -10597.5 1745 -10602.5 1745 -10622.5 1745 -10627.5 1750 -10627.5 1755 -10627.5 {fill=1
bezier=1}
P 7 14 2535 -10147.5 2540 -10147.5 2545 -10147.5 2545 -10142.5 2545 -10122.5 2545 -10117.5 2540 -10117.5 2530 -10117.5 2525 -10117.5 2525 -10122.5 2525 -10142.5 2525 -10147.5 2530 -10147.5 2535 -10147.5 {fill=1
bezier=1}
P 7 14 1325 -10177.5 1330 -10177.5 1335 -10177.5 1335 -10172.5 1335 -10152.5 1335 -10147.5 1330 -10147.5 1320 -10147.5 1315 -10147.5 1315 -10152.5 1315 -10172.5 1315 -10177.5 1320 -10177.5 1325 -10177.5 {fill=1
bezier=1}
P 9 8 1800 -10930 1942.5 -10902.5 1920 -10870 2010 -10810 1990 -10780 1900 -10840 1875 -10805 1800 -10930 {fill=0}
P 10 7 880 -12360 872.5 -12367.5 877.5 -12372.5 862.5 -12377.5 867.5 -12362.5 872.5 -12367.5 880 -12360 {fill=1}
P 10 7 2110 -12410 2102.5 -12417.5 2107.5 -12422.5 2092.5 -12427.5 2097.5 -12412.5 2102.5 -12417.5 2110 -12410 {fill=1}
P 10 7 1330 -12400 1322.5 -12407.5 1327.5 -12412.5 1312.5 -12417.5 1317.5 -12402.5 1322.5 -12407.5 1330 -12400 {fill=1}
P 10 7 760 -12140 752.5 -12147.5 757.5 -12152.5 742.5 -12157.5 747.5 -12142.5 752.5 -12147.5 760 -12140 {fill=1}
P 10 7 1380 -12140 1372.5 -12147.5 1377.5 -12152.5 1362.5 -12157.5 1367.5 -12142.5 1372.5 -12147.5 1380 -12140 {fill=1}
P 10 7 760 -7710 752.5 -7717.5 757.5 -7722.5 742.5 -7727.5 747.5 -7712.5 752.5 -7717.5 760 -7710 {fill=1}
P 10 7 1380 -7710 1372.5 -7717.5 1377.5 -7722.5 1362.5 -7727.5 1367.5 -7712.5 1372.5 -7717.5 1380 -7710 {fill=1}
P 10 7 760 -7310 752.5 -7317.5 757.5 -7322.5 742.5 -7327.5 747.5 -7312.5 752.5 -7317.5 760 -7310 {fill=1}
P 10 7 1380 -7310 1372.5 -7317.5 1377.5 -7322.5 1362.5 -7327.5 1367.5 -7312.5 1372.5 -7317.5 1380 -7310 {fill=1}
P 10 7 920 -6640 912.5 -6647.5 917.5 -6652.5 902.5 -6657.5 907.5 -6642.5 912.5 -6647.5 920 -6640 {fill=1}
P 10 7 1410 -6700 1402.5 -6707.5 1407.5 -6712.5 1392.5 -6717.5 1397.5 -6702.5 1402.5 -6707.5 1410 -6700 {fill=1}
P 10 7 2230 -6700 2222.5 -6707.5 2227.5 -6712.5 2212.5 -6717.5 2217.5 -6702.5 2222.5 -6707.5 2230 -6700 {fill=1}
P 10 7 880 -11530 872.5 -11537.5 877.5 -11542.5 862.5 -11547.5 867.5 -11532.5 872.5 -11537.5 880 -11530 {fill=1}
P 10 7 2110 -11580 2102.5 -11587.5 2107.5 -11592.5 2092.5 -11597.5 2097.5 -11582.5 2102.5 -11587.5 2110 -11580 {fill=1}
P 10 7 1330 -11570 1322.5 -11577.5 1327.5 -11582.5 1312.5 -11587.5 1317.5 -11572.5 1322.5 -11577.5 1330 -11570 {fill=1}
P 10 7 825 -12830 817.5 -12837.5 822.5 -12842.5 807.5 -12847.5 812.5 -12832.5 817.5 -12837.5 825 -12830 {fill=1}
P 10 7 1630 -12860 1622.5 -12867.5 1627.5 -12872.5 1612.5 -12877.5 1617.5 -12862.5 1622.5 -12867.5 1630 -12860 {fill=1}
P 10 7 2410 -12850 2402.5 -12857.5 2407.5 -12862.5 2392.5 -12867.5 2397.5 -12852.5 2402.5 -12857.5 2410 -12850 {fill=1}
P 10 7 730 -10990 722.5 -10997.5 727.5 -11002.5 712.5 -11007.5 717.5 -10992.5 722.5 -10997.5 730 -10990 {fill=1}
P 10 7 1310 -10990 1302.5 -10997.5 1307.5 -11002.5 1292.5 -11007.5 1297.5 -10992.5 1302.5 -10997.5 1310 -10990 {fill=1}
P 10 7 2520 -11060 2512.5 -11067.5 2517.5 -11072.5 2502.5 -11077.5 2507.5 -11062.5 2512.5 -11067.5 2520 -11060 {fill=1}
P 10 7 1380 -5910 1372.5 -5917.5 1377.5 -5922.5 1362.5 -5927.5 1367.5 -5912.5 1372.5 -5917.5 1380 -5910 {fill=1}
P 10 7 1920 -5950 1912.5 -5957.5 1917.5 -5962.5 1902.5 -5967.5 1907.5 -5952.5 1912.5 -5957.5 1920 -5950 {fill=1}
P 10 7 660 -4810 652.5 -4817.5 657.5 -4822.5 642.5 -4827.5 647.5 -4812.5 652.5 -4817.5 660 -4810 {fill=1}
P 10 7 1240 -4810 1232.5 -4817.5 1237.5 -4822.5 1222.5 -4827.5 1227.5 -4812.5 1232.5 -4817.5 1240 -4810 {fill=1}
P 10 7 1010 -13140 1002.5 -13147.5 1007.5 -13152.5 992.5 -13157.5 997.5 -13142.5 1002.5 -13147.5 1010 -13140 {fill=1}
P 10 7 680 -4570 672.5 -4577.5 677.5 -4582.5 662.5 -4587.5 667.5 -4572.5 672.5 -4577.5 680 -4570 {fill=1}
P 10 7 1300 -4480 1292.5 -4487.5 1297.5 -4492.5 1282.5 -4497.5 1287.5 -4482.5 1292.5 -4487.5 1300 -4480 {fill=1}
P 10 7 760 -4300 752.5 -4307.5 757.5 -4312.5 742.5 -4317.5 747.5 -4302.5 752.5 -4307.5 760 -4300 {fill=1}
P 10 7 1300 -4270 1292.5 -4277.5 1297.5 -4282.5 1282.5 -4287.5 1287.5 -4272.5 1292.5 -4277.5 1300 -4270 {fill=1}
P 10 7 2350 -4240 2342.5 -4247.5 2347.5 -4252.5 2332.5 -4257.5 2337.5 -4242.5 2342.5 -4247.5 2350 -4240 {fill=1}
P 10 7 1830 -3520 1822.5 -3527.5 1827.5 -3532.5 1812.5 -3537.5 1817.5 -3522.5 1822.5 -3527.5 1830 -3520 {fill=1}
P 10 7 700 -3590 692.5 -3597.5 697.5 -3602.5 682.5 -3607.5 687.5 -3592.5 692.5 -3597.5 700 -3590 {fill=1}
P 10 7 820 -3590 812.5 -3597.5 817.5 -3602.5 802.5 -3607.5 807.5 -3592.5 812.5 -3597.5 820 -3590 {fill=1}
P 10 7 930 -2310 922.5 -2317.5 927.5 -2322.5 912.5 -2327.5 917.5 -2312.5 922.5 -2317.5 930 -2310 {fill=1}
P 10 7 1530 -2310 1522.5 -2317.5 1527.5 -2322.5 1512.5 -2327.5 1517.5 -2312.5 1522.5 -2317.5 1530 -2310 {fill=1}
P 10 7 760 -3870 752.5 -3877.5 757.5 -3882.5 742.5 -3887.5 747.5 -3872.5 752.5 -3877.5 760 -3870 {fill=1}
P 10 7 1220 -3920 1212.5 -3927.5 1217.5 -3932.5 1202.5 -3937.5 1207.5 -3922.5 1212.5 -3927.5 1220 -3920 {fill=1}
P 10 7 840 -5560 832.5 -5567.5 837.5 -5572.5 822.5 -5577.5 827.5 -5562.5 832.5 -5567.5 840 -5560 {fill=1}
P 10 7 1380 -5560 1372.5 -5567.5 1377.5 -5572.5 1362.5 -5577.5 1367.5 -5562.5 1372.5 -5567.5 1380 -5560 {fill=1}
P 10 7 1920 -5640 1912.5 -5647.5 1917.5 -5652.5 1902.5 -5657.5 1907.5 -5642.5 1912.5 -5647.5 1920 -5640 {fill=1}
P 10 7 2460 -5560 2452.5 -5567.5 2457.5 -5572.5 2442.5 -5577.5 2447.5 -5562.5 2452.5 -5567.5 2460 -5560 {fill=1}
P 10 7 2560 -5310 2552.5 -5317.5 2557.5 -5322.5 2542.5 -5327.5 2547.5 -5312.5 2552.5 -5317.5 2560 -5310 {fill=1}
P 10 7 2030 -5210 2022.5 -5217.5 2027.5 -5222.5 2012.5 -5227.5 2017.5 -5212.5 2022.5 -5217.5 2030 -5210 {fill=1}
P 10 7 1520 -5200 1512.5 -5207.5 1517.5 -5212.5 1502.5 -5217.5 1507.5 -5202.5 1512.5 -5207.5 1520 -5200 {fill=1}
P 10 8 1800 -10930 1942.5 -10902.5 1920 -10870 2010 -10810 1990 -10780 1900 -10840 1875 -10805 1800 -10930 {fill=1}
P 10 7 2470 -3880 2462.5 -3887.5 2467.5 -3892.5 2452.5 -3897.5 2457.5 -3882.5 2462.5 -3887.5 2470 -3880 {fill=1}
P 10 7 2450 -2490 2442.5 -2497.5 2447.5 -2502.5 2432.5 -2507.5 2437.5 -2492.5 2442.5 -2497.5 2450 -2490 {fill=1}
P 10 7 380 -9640 372.5 -9647.5 377.5 -9652.5 362.5 -9657.5 367.5 -9642.5 372.5 -9647.5 380 -9640 {fill=1}
P 10 7 860 -9710 852.5 -9717.5 857.5 -9722.5 842.5 -9727.5 847.5 -9712.5 852.5 -9717.5 860 -9710 {fill=1}
P 10 7 1110 -9750 1102.5 -9757.5 1107.5 -9762.5 1092.5 -9767.5 1097.5 -9752.5 1102.5 -9757.5 1110 -9750 {fill=1}
P 10 7 1400 -9750 1392.5 -9757.5 1397.5 -9762.5 1382.5 -9767.5 1387.5 -9752.5 1392.5 -9757.5 1400 -9750 {fill=1}
P 10 7 1900 -9750 1892.5 -9757.5 1897.5 -9762.5 1882.5 -9767.5 1887.5 -9752.5 1892.5 -9757.5 1900 -9750 {fill=1}
P 10 7 890 -6240 882.5 -6247.5 887.5 -6252.5 872.5 -6257.5 877.5 -6242.5 882.5 -6247.5 890 -6240 {fill=1}
P 10 7 1730 -6290 1722.5 -6297.5 1727.5 -6302.5 1712.5 -6307.5 1717.5 -6292.5 1722.5 -6297.5 1730 -6290 {fill=1}
P 10 7 2490 -6290 2482.5 -6297.5 2487.5 -6302.5 2472.5 -6307.5 2477.5 -6292.5 2482.5 -6297.5 2490 -6290 {fill=1}
P 10 7 875 -11400 867.5 -11407.5 872.5 -11412.5 857.5 -11417.5 862.5 -11402.5 867.5 -11407.5 875 -11400 {fill=1}
P 10 7 1400 -11290 1392.5 -11297.5 1397.5 -11302.5 1382.5 -11307.5 1387.5 -11292.5 1392.5 -11297.5 1400 -11290 {fill=1}
P 10 7 1850 -11290 1842.5 -11297.5 1847.5 -11302.5 1832.5 -11307.5 1837.5 -11292.5 1842.5 -11297.5 1850 -11290 {fill=1}
P 10 7 2280 -11290 2272.5 -11297.5 2277.5 -11302.5 2262.5 -11307.5 2267.5 -11292.5 2272.5 -11297.5 2280 -11290 {fill=1}
P 10 7 2200 -9580 2192.5 -9587.5 2197.5 -9592.5 2182.5 -9597.5 2187.5 -9582.5 2192.5 -9587.5 2200 -9580 {fill=1}
P 10 7 1025 -9010 1017.5 -9017.5 1022.5 -9022.5 1007.5 -9027.5 1012.5 -9012.5 1017.5 -9017.5 1025 -9010 {fill=1}
P 10 7 1870 -9010 1862.5 -9017.5 1867.5 -9022.5 1852.5 -9027.5 1857.5 -9012.5 1862.5 -9017.5 1870 -9010 {fill=1}
P 10 7 1000 -8580 992.5 -8587.5 997.5 -8592.5 982.5 -8597.5 987.5 -8582.5 992.5 -8587.5 1000 -8580 {fill=1}
P 10 7 1860 -8580 1852.5 -8587.5 1857.5 -8592.5 1842.5 -8597.5 1847.5 -8582.5 1852.5 -8587.5 1860 -8580 {fill=1}
P 10 7 2440 -9640 2432.5 -9647.5 2437.5 -9652.5 2422.5 -9657.5 2427.5 -9642.5 2432.5 -9647.5 2440 -9640 {fill=1}
P 10 7 580 -9750 572.5 -9757.5 577.5 -9762.5 562.5 -9767.5 567.5 -9752.5 572.5 -9757.5 580 -9750 {fill=1}
P 10 7 740 -1940 732.5 -1947.5 737.5 -1952.5 722.5 -1957.5 727.5 -1942.5 732.5 -1947.5 740 -1940 {fill=1}
P 10 7 2320 -1940 2312.5 -1947.5 2317.5 -1952.5 2302.5 -1957.5 2307.5 -1942.5 2312.5 -1947.5 2320 -1940 {fill=1}
P 10 7 1430 -1605 1422.5 -1612.5 1427.5 -1617.5 1412.5 -1622.5 1417.5 -1607.5 1422.5 -1612.5 1430 -1605 {fill=1}
P 10 7 2360 -1665 2352.5 -1672.5 2357.5 -1677.5 2342.5 -1682.5 2347.5 -1667.5 2352.5 -1672.5 2360 -1665 {fill=1}
P 10 7 640 -1605 632.5 -1612.5 637.5 -1617.5 622.5 -1622.5 627.5 -1607.5 632.5 -1612.5 640 -1605 {fill=1}
P 10 7 2210 -13230 2202.5 -13237.5 2207.5 -13242.5 2192.5 -13247.5 2197.5 -13232.5 2202.5 -13237.5 2210 -13230 {fill=1}
P 10 7 952.5 -1290 945 -1297.5 950 -1302.5 935 -1307.5 940 -1292.5 945 -1297.5 952.5 -1290 {fill=1}
P 10 7 1297.5 -1302.5 1290 -1310 1295 -1315 1280 -1320 1285 -1305 1290 -1310 1297.5 -1302.5 {fill=1}
P 10 7 1627.5 -1302.5 1620 -1310 1625 -1315 1610 -1320 1615 -1305 1620 -1310 1627.5 -1302.5 {fill=1}
P 10 7 1947.5 -1302.5 1940 -1310 1945 -1315 1930 -1320 1935 -1305 1940 -1310 1947.5 -1302.5 {fill=1}
P 10 7 1052.5 -990 1045 -997.5 1050 -1002.5 1035 -1007.5 1040 -992.5 1045 -997.5 1052.5 -990 {fill=1}
P 10 7 497.5 -522.5 490 -530 495 -535 480 -540 485 -525 490 -530 497.5 -522.5 {fill=1}
P 10 7 917.5 -582.5 910 -590 915 -595 900 -600 905 -585 910 -590 917.5 -582.5 {fill=1}
P 10 7 1207.5 -462.5 1200 -470 1205 -475 1190 -480 1195 -465 1200 -470 1207.5 -462.5 {fill=1}
P 10 7 1387.5 -522.5 1380 -530 1385 -535 1370 -540 1375 -525 1380 -530 1387.5 -522.5 {fill=1}
P 10 7 1687.5 -492.5 1680 -500 1685 -505 1670 -510 1675 -495 1680 -500 1687.5 -492.5 {fill=1}
P 10 7 2057.5 -482.5 2050 -490 2055 -495 2040 -500 2045 -485 2050 -490 2057.5 -482.5 {fill=1}
P 10 7 2317.5 -432.5 2310 -440 2315 -445 2300 -450 2305 -435 2310 -440 2317.5 -432.5 {fill=1}
P 10 7 787.5 -131.25 780 -138.75 785 -143.75 770 -148.75 775 -133.75 780 -138.75 787.5 -131.25 {fill=1}
P 10 7 1697.5 -162.5 1690 -170 1695 -175 1680 -180 1685 -165 1690 -170 1697.5 -162.5 {fill=1}
P 10 7 2247.5 -212.5 2240 -220 2245 -225 2230 -230 2235 -215 2240 -220 2247.5 -212.5 {fill=1}
P 10 7 1260 -10470 1252.5 -10477.5 1257.5 -10482.5 1242.5 -10487.5 1247.5 -10472.5 1252.5 -10477.5 1260 -10470 {fill=1}
P 10 7 2510 -10550 2502.5 -10557.5 2507.5 -10562.5 2492.5 -10567.5 2497.5 -10552.5 2502.5 -10557.5 2510 -10550 {fill=1}
P 10 7 1730 -10600 1722.5 -10607.5 1727.5 -10612.5 1712.5 -10617.5 1717.5 -10602.5 1722.5 -10607.5 1730 -10600 {fill=1}
P 10 7 1300 -10160 1292.5 -10167.5 1297.5 -10172.5 1282.5 -10177.5 1287.5 -10162.5 1292.5 -10167.5 1300 -10160 {fill=1}
P 10 7 2510 -10140 2502.5 -10147.5 2507.5 -10152.5 2492.5 -10157.5 2497.5 -10142.5 2502.5 -10147.5 2510 -10140 {fill=1}
T {INTUITIVE_INTERFACE CHEAT SHEET} 1110 -13580 0 0 2 2 {hcenter=1}
T {D} 1275 -12557.5 0 0 0.15 0.15 { layer=2}
T {D} 2055 -12567.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -12557.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -12097.5 0 0 0.15 0.15 {}
T {D} 1285 -12097.5 0 0 0.15 0.15 {}
T {D} 745 -7667.5 0 0 0.15 0.15 {}
T {D} 1285 -7667.5 0 0 0.15 0.15 {}
T {D} 745 -7267.5 0 0 0.15 0.15 {}
T {D} 1285 -7267.5 0 0 0.15 0.15 {}
T {D} 745 -6827.5 0 0 0.15 0.15 { layer=2}
T {D} 2125 -6827.5 0 0 0.15 0.15 { layer=2}
T {D} 1305 -6827.5 0 0 0.15 0.15 { layer=2}
T {(Enable Options → Intuitive Click & Drag interface
or add: `set intuitive_interface 1` in xschemrc file).} 1090 -13440 0 0 1 1 {hcenter=1 layer=1}
T {Move objects} 0 -12630 0 0 1 1 {}
T {Move objects} 0 -12220 0 0 1 1 {}
T {Move objects,
create wires} 0 -7790 0 0 1 1 {}
T {Move objects,
keep attached
wires
} 0 -7390 0 0 1 1 {}
T {Move objects,
keep attached
wires / stretch
circuit
} 0 -6990 0 0 1 1 {}
T {Shift} 1520 -7725 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1520 -7795 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1540 -6685 0 0 0.5 0.5 {hcenter=1}
T {Duplicate objects} 0 -11780 0 0 1 1 {}
T {D} 1275 -11727.5 0 0 0.15 0.15 { layer=2}
T {D} 2055 -11737.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -11727.5 0 0 0.15 0.15 { layer=2}
T {D} 1775 -11727.5 0 0 0.15 0.15 {}
T {Shift} 1270 -11545 0 0 0.5 0.5 {hcenter=1}
T {D} 1815 -13027.5 0 0 0.15 0.15 { layer=2}
T {D} 690 -13027.5 0 0 0.15 0.15 { layer=2}
T {Select
and unselect
objects} 0 -13080 0 0 1 1 {}
T {Shift} 1710 -12825 0 0 0.5 0.5 {hcenter=1}
T {D} 2275 -13027.5 0 0 0.15 0.15 { layer=2}
T {Alt} 2490 -12815 0 0 0.5 0.5 {hcenter=1}
T {Select} 695 -12830 0 0 0.5 0.5 {}
T {Add
Selection} 1770 -12840 0 0 0.5 0.5 {}
T {Remove
Selection} 2220 -12840 0 0 0.5 0.5 {}
T {D} 765 -10887.5 0 0 0.15 0.15 {}
T {D} 1305 -10887.5 0 0 0.15 0.15 {}
T {D} 2435 -10887.5 0 0 0.15 0.15 {}
T {Resize wires} 0 -11010 0 0 1 1 {}
T {Constrained move
horizontal / 
vertical} 0 -6520 0 0 1 1 {}
T {Move components, 
create wires,
resize wires} 0 -6060 0 0 1 1 {}
T {Cut wires} 0 -5710 0 0 1 1 {}
T {Stretch multiple
shapes} 0 -5290 0 0 1 1 {}
T {Ctrl} 1430 -6065 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1430 -5985 0 0 0.5 0.5 {hcenter=1}
T {Accurately position close
to the wire end to be moved} 1600 -11070 0 0 0.5 0.5 {}
T {Move multiple
objects keeping
connections} 0 -3270 0 0 1 1 {}
T {Ctrl} 2080 -3245 0 0 0.5 0.5 {hcenter=1}
T {Alt} 1430 -5615 0 0 0.5 0.5 {hcenter=1}
T {Click to select wire, release button
click wire endpoint and drag it away} 660 -11100 0 0 0.5 0.5 {}
T {Ctrl} 1580 -5205 0 0 0.5 0.5 {hcenter=1}
T {D} 655 -4867.5 0 0 0.15 0.15 { layer=2}
T {D} 1235 -4867.5 0 0 0.15 0.15 { layer=2}
T {D} 1885 -4867.5 0 0 0.15 0.15 {}
T {Ctrl} 1960 -4905 0 0 0.5 0.5 {hcenter=1}
T {!} 1960 -4825 0 0 0.5 0.5 {hcenter=1}
T {Remove wires
under component
} 0 -4940 0 0 1 1 {}
T {If Shift key is needed for ! 
use also Shift} 2020 -4880 0 0 0.5 0.5 {}
T {D} 1275 -13027.5 0 0 0.15 0.15 { layer=2}
T {Add
Selection} 1090 -12850 0 0 0.5 0.5 {}
T {Shift} 1080 -13105 0 0 0.5 0.5 {hcenter=1}
T {Move multiple
objects keeping
connections,
adding wires} 0 -2890 0 0 1 1 {}
T {Ctrl} 2080 -2865 0 0 0.5 0.5 {hcenter=1}
T {Shift} 2080 -2795 0 0 0.5 0.5 {hcenter=1}
T {Join / Trim wires} 0 -4600 0 0 1 1 {}
T {&} 1920 -4605 0 0 0.5 0.5 {hcenter=1}
T {This wire will not be broken} 1120 -4190 0 0 0.5 0.5 {}
T {&} 1830 -4175 0 0 0.5 0.5 {hcenter=1}
T {This wire is now 
broken} 1890 -4190 0 0 0.5 0.5 {}
T {break wires
at instance
pins} 0 -3670 0 0 1 1 {}
T {!} 1290 -3525 0 0 0.5 0.5 {hcenter=1}
T {Shift} 790 -3455 0 0 0.5 0.5 {hcenter=1}
T {+} 720 -3530 0 0 0.5 0.5 {}
T {The single wire line will be
broken at selected instance pins} 1640 -3700 0 0 0.5 0.5 {}
T {Single wire line} 640 -3690 0 0 0.5 0.5 {}
T {D} 825 -2357.5 0 0 0.15 0.15 {}
T {D} 1425 -2357.5 0 0 0.15 0.15 {}
T {Shift} 1600 -2295 0 0 0.5 0.5 {hcenter=1}
T {Select instance
and all connected
wires} 0 -2490 0 0 1 1 {}
T {Join / Trim wires} 0 -4320 0 0 1 1 {}
T {Options->Auto join / trim wires to perform this function automatically} 840 -4420 0 0 0.5 0.5 {}
T {Join / Trim wires} 0 -3930 0 0 1 1 {}
T {This wire is broken} 630 -3790 0 0 0.5 0.5 {}
T {This wire is still broken} 1170 -3790 0 0 0.5 0.5 {}
T {This wire is now joined} 1800 -3790 0 0 0.5 0.5 {}
T {&} 1920 -4035 0 0 0.5 0.5 {hcenter=1}
T {Options->Auto join / trim wires to perform this function automatically} 840 -4050 0 0 0.5 0.5 {}
T {Options->Auto join / trim wires to perform this function automatically} 840 -4660 0 0 0.5 0.5 {}
T {multiple overlayed wires create
unneeded connecting dots} 1110 -4580 0 0 0.5 0.5 {}
T {overlayed wires are removed} 2270 -4560 0 0 0.5 0.5 {}
T {Ctrl} 2370 -6685 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1980 -6065 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1980 -5985 0 0 0.5 0.5 {hcenter=1}
T {you can now 
select one of
the cut segments...} 1930 -5580 0 0 0.4 0.4 {}
T {... and move it.} 2420 -5500 0 0 0.4 0.4 {}
T {D} 2035 -2357.5 0 0 0.15 0.15 {}
T {Component
wiring} 0 -9690 0 0 1 1 {}
T {Click to
unselect} 850 -9810 0 0 0.5 0.5 {}
T {Click to select} 1810 -9810 0 0 0.5 0.5 {}
T {Click one of the
selected objects
and drag it away.} 2330 -2390 0 0 0.4 0.4 {}
T {This command will work also on multiple selected objects.} 1710 -4730 0 0 0.5 0.5 {}
T {D} 765 -6417.5 0 0 0.15 0.15 {}
T {D} 1325 -6417.5 0 0 0.15 0.15 {}
T {Press and release 'h'
while keeping left mouse
button pressed.
move will be horizontal only} 1550 -6570 0 0 0.5 0.5 {}
T {Press and release 'v'
while keeping left mouse
button pressed.
move will be vertical only} 2050 -6440 0 0 0.5 0.5 {}
T {D} 710 -11307.5 0 0 0.15 0.15 {}
T {Move and
extend
wires} 0 -11400 0 0 1 1 {}
T {D} 1275 -11307.5 0 0 0.15 0.15 {}
T {D} 1775 -11307.5 0 0 0.15 0.15 {}
T {D} 2265 -11307.5 0 0 0.15 0.15 {}
T {Shift} 1980 -9725 0 0 0.5 0.5 {hcenter=1}
T {Rotate / Flip} 0 -9350 0 0 1 1 {}
T {Shift} 510 -9235 0 0 0.5 0.5 {hcenter=1}
T {R} 510 -9165 0 0 0.5 0.5 {hcenter=1}
T {Shift} 820 -9235 0 0 0.5 0.5 {hcenter=1}
T {R} 820 -9165 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1120 -9235 0 0 0.5 0.5 {hcenter=1}
T {R} 1120 -9165 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1430 -9235 0 0 0.5 0.5 {hcenter=1}
T {R} 1430 -9165 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1750 -9235 0 0 0.5 0.5 {hcenter=1}
T {F} 1750 -9165 0 0 0.5 0.5 {hcenter=1}
T {Shift} 2080 -9235 0 0 0.5 0.5 {hcenter=1}
T {V} 2080 -9165 0 0 0.5 0.5 {hcenter=1}
T {D} 775 -8907.5 0 0 0.15 0.15 { layer=2}
T {D} 1727.5 -8785 1 0 0.15 0.15 { layer=2}
T {D} 1250 -8907.5 0 0 0.15 0.15 { layer=2}
T {Shift} 1940 -9045 0 0 0.5 0.5 {hcenter=1}
T {R} 1940 -8975 0 0 0.5 0.5 {hcenter=1}
T {Selected shapes rotate around mouse pointer} 1920 -8900 0 0 0.5 0.5 {}
T {Rotate} 0 -8930 0 0 1 1 {}
T {D} 775 -8477.5 0 0 0.15 0.15 { layer=2}
T {D} 1225 -8477.5 0 0 0.15 0.15 { layer=2}
T {Shift} 1940 -8615 0 0 0.5 0.5 {hcenter=1}
T {F} 1940 -8545 0 0 0.5 0.5 {hcenter=1}
T {Selected shapes flip around mouse pointer} 1920 -8470 0 0 0.5 0.5 {}
T {Flip} 0 -8500 0 0 1 1 {}
T {D} 1595 -8477.5 0 1 0.15 0.15 { layer=2}
T {Rotate around
center point} 0 -8100 0 0 1 1 {}
T {Alt} 1050 -8135 0 0 0.5 0.5 {hcenter=1}
T {R} 1050 -8065 0 0 0.5 0.5 {hcenter=1}
T {Same commands are available for
vertical flip (Alt-v) and
horizontal flip (Alt-f)} 1350 -8110 0 0 0.5 0.5 {}
T {get existing wire} 750 -11465 0 0 0.5 0.5 {}
T {move} 1335 -11355 0 0 0.5 0.5 {}
T {extend} 2310 -11360 0 0 0.5 0.5 {}
T {duplicated} 2070 -9530 0 0 0.5 0.5 {}
T {Ctrl} 1520 -7365 0 0 0.5 0.5 {hcenter=1}
T {Toggle mouse vs 
crosshair display} 0 -2030 0 0 1 1 {}
T {Alt} 1430 -1885 0 0 0.5 0.5 {hcenter=1}
T {x} 1430 -1815 0 0 0.5 0.5 {hcenter=1}
T {Alt} 2310 -1885 0 0 0.5 0.5 {hcenter=1}
T {x} 2310 -1815 0 0 0.5 0.5 {hcenter=1}
T {X1} 1085 -1712 0 0 0.2 0.2 { layer=2}
T {CODE[5:0]} 1075 -1694 0 1 0.2 0.2 { layer=2}
T {SIG_IN} 965 -1694 0 0 0.2 0.2 { layer=2}
T {VREF} 965 -1674 0 0 0.2 0.2 { layer=2}
T {CK} 965 -1654 0 0 0.2 0.2 { layer=2}
T {RST} 965 -1634 0 0 0.2 0.2 { layer=2}
T {adc} 1009.75 -1658.5 0 0 0.2 0.2 { layer=2}
T {Auto-wiring
of components} 0 -1630 0 0 1 1 {}
T {X1} 1655 -1712 0 0 0.2 0.2 {}
T {CODE[5:0]} 1645 -1694 0 1 0.2 0.2 {}
T {SIG_IN} 1535 -1694 0 0 0.2 0.2 {}
T {VREF} 1535 -1674 0 0 0.2 0.2 {}
T {CK} 1535 -1654 0 0 0.2 0.2 {}
T {RST} 1535 -1634 0 0 0.2 0.2 {}
T {adc} 1579.75 -1658.5 0 0 0.2 0.2 {}
T {SIG_IN} 932.5 -1698.125 0 1 0.33 0.33 { layer=1}
T {VREF} 932.5 -1678.125 0 1 0.33 0.33 { layer=1}
T {CK} 932.5 -1658.125 0 1 0.33 0.33 { layer=1}
T {RST} 932.5 -1638.125 0 1 0.33 0.33 { layer=1}
T {CODE[5:0]} 1107.5 -1698.125 0 0 0.33 0.33 { layer=1}
T {Shift} 1010 -1575 0 0 0.5 0.5 {hcenter=1}
T {H} 1010 -1505 0 0 0.5 0.5 {hcenter=1}
T {SIG_IN} 1432.5 -1698.125 0 1 0.33 0.33 { layer=2}
T {VREF} 1432.5 -1678.125 0 1 0.33 0.33 { layer=2}
T {CK} 1432.5 -1658.125 0 1 0.33 0.33 { layer=2}
T {RST} 1432.5 -1638.125 0 1 0.33 0.33 { layer=2}
T {Ctrl} 1440 -1575 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1440 -1505 0 0 0.5 0.5 {hcenter=1}
T {CODE[5:0]} 1677.5 -1698.125 0 0 0.33 0.33 { layer=1}
T {X1} 2185 -1712 0 0 0.2 0.2 {}
T {CODE[5:0]} 2175 -1694 0 1 0.2 0.2 {}
T {SIG_IN} 2065 -1694 0 0 0.2 0.2 {}
T {VREF} 2065 -1674 0 0 0.2 0.2 {}
T {CK} 2065 -1654 0 0 0.2 0.2 {}
T {RST} 2065 -1634 0 0 0.2 0.2 {}
T {adc} 2109.75 -1658.5 0 0 0.2 0.2 {}
T {SIG_IN} 1962.5 -1698.125 0 1 0.33 0.33 { layer=1}
T {VREF} 1962.5 -1678.125 0 1 0.33 0.33 { layer=1}
T {CK} 1962.5 -1658.125 0 1 0.33 0.33 { layer=1}
T {RST} 1962.5 -1638.125 0 1 0.33 0.33 { layer=1}
T {CODE[5:0]} 2297.5 -1698.125 0 0 0.33 0.33 { layer=2}
T {Ctrl} 2370 -1635 0 0 0.5 0.5 {hcenter=1}
T {Shift} 2370 -1565 0 0 0.5 0.5 {hcenter=1}
T {X1} 665 -1712 0 0 0.2 0.2 { layer=2}
T {CODE[5:0]} 655 -1694 0 1 0.2 0.2 { layer=2}
T {SIG_IN} 545 -1694 0 0 0.2 0.2 { layer=2}
T {VREF} 545 -1674 0 0 0.2 0.2 { layer=2}
T {CK} 545 -1654 0 0 0.2 0.2 { layer=2}
T {RST} 545 -1634 0 0 0.2 0.2 { layer=2}
T {adc} 589.75 -1658.5 0 0 0.2 0.2 { layer=2}
T {This represents the mouse
device. Red rectangle
indicates a pressed button} 2265 -13530 0 0 0.5 0.5 {}
T {Alt} 2210 -13405 0 0 0.5 0.5 {hcenter=1}
T {This represents 
a pressed modifier key} 2265 -13420 0 0 0.5 0.5 {}
T {R} 2210 -13325 0 0 0.5 0.5 {hcenter=1}
T {This represents 
a pressed key} 2265 -13340 0 0 0.5 0.5 {}
T {This represents the
mouse pointer} 2265 -13270 0 0 0.5 0.5 {}
T {Rotate / Flip
wire labels} 0 -1360 0 0 1 1 {}
T {SIG_IN} 572.5 -1328.125 0 1 0.33 0.33 { layer=1}
T {SIG_IN} 962.5 -1328.125 0 1 0.33 0.33 { layer=2}
T {Shift} 1300 -1245 0 0 0.5 0.5 {hcenter=1}
T {R} 1300 -1175 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1630 -1245 0 0 0.5 0.5 {hcenter=1}
T {R} 1630 -1175 0 0 0.5 0.5 {hcenter=1}
T {SIG_IN} 1288.125 -1327.5 1 1 0.33 0.33 { layer=2}
T {SIG_IN} 1617.5 -1311.875 2 1 0.33 0.33 { layer=2}
T {Shift} 1950 -1245 0 0 0.5 0.5 {hcenter=1}
T {F} 1950 -1175 0 0 0.5 0.5 {hcenter=1}
T {SIG_IN} 1922.5 -1311.875 2 0 0.33 0.33 { layer=2}
T {7/0.15/1} 527.5 -1037.5 0 0 0.2 0.2 {}
T {M1} 527.5 -1012.5 0 0 0.2 0.2 {}
T {10/0.15/1} 657.5 -1037.5 0 0 0.2 0.2 {}
T {M1} 657.5 -1012.5 0 0 0.2 0.2 {}
T {4/0.15/1} 527.5 -838.75 0 0 0.2 0.2 {}
T {M1} 527.5 -812.5 0 0 0.2 0.2 {}
T {D} 545 -847.5 0 0 0.15 0.15 {}
T {D} 545 -1000 0 0 0.15 0.15 {}
T {D} 675 -1000 0 0 0.15 0.15 {}
T {4/0.15/1} 527.5 -758.75 0 0 0.2 0.2 {}
T {M1} 527.5 -732.5 0 0 0.2 0.2 {}
T {D} 545 -767.5 0 0 0.15 0.15 {}
T {7/0.15/1} 897.5 -1037.5 0 0 0.2 0.2 { layer=2}
T {M1} 897.5 -1012.5 0 0 0.2 0.2 { layer=2}
T {10/0.15/1} 1027.5 -1037.5 0 0 0.2 0.2 { layer=2}
T {M1} 1027.5 -1012.5 0 0 0.2 0.2 { layer=2}
T {4/0.15/1} 897.5 -838.75 0 0 0.2 0.2 { layer=2}
T {M1} 897.5 -812.5 0 0 0.2 0.2 { layer=2}
T {D} 915 -847.5 0 0 0.15 0.15 { layer=2}
T {D} 915 -1000 0 0 0.15 0.15 { layer=2}
T {D} 1045 -1000 0 0 0.15 0.15 { layer=2}
T {4/0.15/1} 897.5 -758.75 0 0 0.2 0.2 { layer=2}
T {M1} 897.5 -732.5 0 0 0.2 0.2 { layer=2}
T {D} 915 -767.5 0 0 0.15 0.15 { layer=2}
T {Shift} 1180 -965 0 0 0.5 0.5 {hcenter=1}
T {q} 1600 -965 0 0 0.5 0.5 {hcenter=1}
T {or double click
last element} 1680 -970 0 0 0.4 0.4 {}
T {7/0.3/1} 2227.5 -1037.5 0 0 0.2 0.2 {}
T {M1} 2227.5 -1012.5 0 0 0.2 0.2 {}
T {7/0.3/1} 2357.5 -1037.5 0 0 0.2 0.2 {}
T {M1} 2357.5 -1012.5 0 0 0.2 0.2 {}
T {4/0.3/1} 2227.5 -838.75 0 0 0.2 0.2 {}
T {M1} 2227.5 -812.5 0 0 0.2 0.2 {}
T {D} 2245 -847.5 0 0 0.15 0.15 {}
T {D} 2245 -1000 0 0 0.15 0.15 {}
T {D} 2375 -1000 0 0 0.15 0.15 {}
T {4/0.3/1} 2227.5 -758.75 0 0 0.2 0.2 {}
T {M1} 2227.5 -732.5 0 0 0.2 0.2 {}
T {D} 2245 -767.5 0 0 0.15 0.15 {}
T {Select one or multiple
objects using the Shift
key} 1000 -890 0 0 0.4 0.4 {}
T {Only the l=... attribute
is changed. Elements retain
their other attributes.} 2310 -920 0 0 0.4 0.4 {}
T {Edit attributes} 0 -950 0 0 1 1 {}
T {SCHEM} 105 -13405 0 0 1 1 {}
T {Polygon editing} 0 -540 0 0 1 1 {}
T {p} 630 -495 0 0 0.5 0.5 {hcenter=1}
T {Shift} 2507.5 -465 0 0 0.5 0.5 {hcenter=1}
T {Clicking a polygon point
with Shift key will add
one more point.
Using Ctrl will delete
point} 2391.25 -641.25 0 0 0.4 0.4 {}
T {Editing polygon points} 1815 -383.75 0 0 0.5 0.5 {}
T {Transforming
polygons to
beziers} 0 -240 0 0 1 1 {}
T {q} 1143.75 -248.75 0 0 0.5 0.5 {hcenter=1}
T {Add attribute:} 1048.75 -173.75 0 0 0.5 0.5 {}
T {bezier=1} 1050 -131.25 0 0 0.7 0.7 {font=monospace layer=4}
T {h} 1710 -6245 0 0 0.5 0.5 {hcenter=1}
T {v} 2560 -6425 0 0 0.5 0.5 {hcenter=1}
T {Resize rectangles} 0 -10560 0 0 1 1 {}
T {Click inner border to select} 940 -10675 0 0 0.5 0.5 {}
T {drag to resize} 1980 -10675 0 0 0.5 0.5 {}
T {Click inner part of corner} 1410 -10675 0 0 0.5 0.5 {}
T {Resize rectangles} 0 -10150 0 0 1 1 {}
T {Drag around a corner with ctrl pressed} 910 -10265 0 0 0.5 0.5 {}
T {drag to resize, left-click to confirm} 1980 -10265 0 0 0.5 0.5 {}
T {Ctrl} 1420 -10165 0 0 0.5 0.5 {hcenter=1}
T {M} 1690 -10105 0 0 0.5 0.5 {hcenter=1}
T {press 'm' for "move"} 1560 -10265 0 0 0.5 0.5 {}
C {bindkeys_cheatsheet.sym} 190 700 0 0 {}
