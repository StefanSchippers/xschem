v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 1 917.5 -8672.5 922.5 -8672.5 {}
L 1 917.5 -8670 922.5 -8670 {}
L 1 917.5 -8667.5 922.5 -8667.5 {}
L 1 917.5 -8665 922.5 -8665 {}
L 1 917.5 -8662.5 922.5 -8662.5 {}
L 1 917.5 -8660 922.5 -8660 {}
L 1 917.5 -8657.5 922.5 -8657.5 {}
L 1 917.5 -8655 922.5 -8655 {}
L 1 917.5 -8652.5 922.5 -8652.5 {}
L 1 1347.5 -8672.5 1352.5 -8672.5 {}
L 1 1347.5 -8670 1352.5 -8670 {}
L 1 1347.5 -8667.5 1352.5 -8667.5 {}
L 1 1347.5 -8665 1352.5 -8665 {}
L 1 1347.5 -8662.5 1352.5 -8662.5 {}
L 1 1347.5 -8660 1352.5 -8660 {}
L 1 1347.5 -8657.5 1352.5 -8657.5 {}
L 1 1347.5 -8655 1352.5 -8655 {}
L 1 1347.5 -8652.5 1352.5 -8652.5 {}
L 1 2117.5 -8672.5 2122.5 -8672.5 {}
L 1 2117.5 -8670 2122.5 -8670 {}
L 1 2117.5 -8667.5 2122.5 -8667.5 {}
L 1 2117.5 -8665 2122.5 -8665 {}
L 1 2117.5 -8662.5 2122.5 -8662.5 {}
L 1 2117.5 -8660 2122.5 -8660 {}
L 1 2117.5 -8657.5 2122.5 -8657.5 {}
L 1 2117.5 -8655 2122.5 -8655 {}
L 1 2117.5 -8652.5 2122.5 -8652.5 {}
L 1 1417.5 -8482.5 1422.5 -8482.5 {}
L 1 1417.5 -8480 1422.5 -8480 {}
L 1 1417.5 -8477.5 1422.5 -8477.5 {}
L 1 1417.5 -8475 1422.5 -8475 {}
L 1 1417.5 -8472.5 1422.5 -8472.5 {}
L 1 1417.5 -8470 1422.5 -8470 {}
L 1 1417.5 -8467.5 1422.5 -8467.5 {}
L 1 1417.5 -8465 1422.5 -8465 {}
L 1 1417.5 -8462.5 1422.5 -8462.5 {}
L 1 1437.5 -6872.5 1442.5 -6872.5 {}
L 1 1437.5 -6870 1442.5 -6870 {}
L 1 1437.5 -6867.5 1442.5 -6867.5 {}
L 1 1437.5 -6865 1442.5 -6865 {}
L 1 1437.5 -6862.5 1442.5 -6862.5 {}
L 1 1437.5 -6860 1442.5 -6860 {}
L 1 1437.5 -6857.5 1442.5 -6857.5 {}
L 1 1437.5 -6855 1442.5 -6855 {}
L 1 1437.5 -6852.5 1442.5 -6852.5 {}
L 1 1437.5 -6382.5 1442.5 -6382.5 {}
L 1 1437.5 -6380 1442.5 -6380 {}
L 1 1437.5 -6377.5 1442.5 -6377.5 {}
L 1 1437.5 -6375 1442.5 -6375 {}
L 1 1437.5 -6372.5 1442.5 -6372.5 {}
L 1 1437.5 -6370 1442.5 -6370 {}
L 1 1437.5 -6367.5 1442.5 -6367.5 {}
L 1 1437.5 -6365 1442.5 -6365 {}
L 1 1437.5 -6362.5 1442.5 -6362.5 {}
L 1 947.5 -5652.5 952.5 -5652.5 {}
L 1 947.5 -5650 952.5 -5650 {}
L 1 947.5 -5647.5 952.5 -5647.5 {}
L 1 947.5 -5645 952.5 -5645 {}
L 1 947.5 -5642.5 952.5 -5642.5 {}
L 1 947.5 -5640 952.5 -5640 {}
L 1 947.5 -5637.5 952.5 -5637.5 {}
L 1 947.5 -5635 952.5 -5635 {}
L 1 947.5 -5632.5 952.5 -5632.5 {}
L 1 1040 -5910 1280 -5910 {}
L 1 1040 -5650 1280 -5650 {}
L 1 1427.5 -5662.5 1432.5 -5662.5 {}
L 1 1427.5 -5660 1432.5 -5660 {}
L 1 1427.5 -5657.5 1432.5 -5657.5 {}
L 1 1427.5 -5655 1432.5 -5655 {}
L 1 1427.5 -5652.5 1432.5 -5652.5 {}
L 1 1427.5 -5650 1432.5 -5650 {}
L 1 1427.5 -5647.5 1432.5 -5647.5 {}
L 1 1427.5 -5645 1432.5 -5645 {}
L 1 1427.5 -5642.5 1432.5 -5642.5 {}
L 1 917.5 -7842.5 922.5 -7842.5 {}
L 1 917.5 -7840 922.5 -7840 {}
L 1 917.5 -7837.5 922.5 -7837.5 {}
L 1 917.5 -7835 922.5 -7835 {}
L 1 917.5 -7832.5 922.5 -7832.5 {}
L 1 917.5 -7830 922.5 -7830 {}
L 1 917.5 -7827.5 922.5 -7827.5 {}
L 1 917.5 -7825 922.5 -7825 {}
L 1 917.5 -7822.5 922.5 -7822.5 {}
L 1 1347.5 -7842.5 1352.5 -7842.5 {}
L 1 1347.5 -7840 1352.5 -7840 {}
L 1 1347.5 -7837.5 1352.5 -7837.5 {}
L 1 1347.5 -7835 1352.5 -7835 {}
L 1 1347.5 -7832.5 1352.5 -7832.5 {}
L 1 1347.5 -7830 1352.5 -7830 {}
L 1 1347.5 -7827.5 1352.5 -7827.5 {}
L 1 1347.5 -7825 1352.5 -7825 {}
L 1 1347.5 -7822.5 1352.5 -7822.5 {}
L 1 2117.5 -7842.5 2122.5 -7842.5 {}
L 1 2117.5 -7840 2122.5 -7840 {}
L 1 2117.5 -7837.5 2122.5 -7837.5 {}
L 1 2117.5 -7835 2122.5 -7835 {}
L 1 2117.5 -7832.5 2122.5 -7832.5 {}
L 1 2117.5 -7830 2122.5 -7830 {}
L 1 2117.5 -7827.5 2122.5 -7827.5 {}
L 1 2117.5 -7825 2122.5 -7825 {}
L 1 2117.5 -7822.5 2122.5 -7822.5 {}
L 1 917.5 -9142.5 922.5 -9142.5 {}
L 1 917.5 -9140 922.5 -9140 {}
L 1 917.5 -9137.5 922.5 -9137.5 {}
L 1 917.5 -9135 922.5 -9135 {}
L 1 917.5 -9132.5 922.5 -9132.5 {}
L 1 917.5 -9130 922.5 -9130 {}
L 1 917.5 -9127.5 922.5 -9127.5 {}
L 1 917.5 -9125 922.5 -9125 {}
L 1 917.5 -9122.5 922.5 -9122.5 {}
L 1 1627.5 -9132.5 1632.5 -9132.5 {}
L 1 1627.5 -9130 1632.5 -9130 {}
L 1 1627.5 -9127.5 1632.5 -9127.5 {}
L 1 1627.5 -9125 1632.5 -9125 {}
L 1 1627.5 -9122.5 1632.5 -9122.5 {}
L 1 1627.5 -9120 1632.5 -9120 {}
L 1 1627.5 -9117.5 1632.5 -9117.5 {}
L 1 1627.5 -9115 1632.5 -9115 {}
L 1 1627.5 -9112.5 1632.5 -9112.5 {}
L 1 2407.5 -9122.5 2412.5 -9122.5 {}
L 1 2407.5 -9120 2412.5 -9120 {}
L 1 2407.5 -9117.5 2412.5 -9117.5 {}
L 1 2407.5 -9115 2412.5 -9115 {}
L 1 2407.5 -9112.5 2412.5 -9112.5 {}
L 1 2407.5 -9110 2412.5 -9110 {}
L 1 2407.5 -9107.5 2412.5 -9107.5 {}
L 1 2407.5 -9105 2412.5 -9105 {}
L 1 2407.5 -9102.5 2412.5 -9102.5 {}
L 1 520 -5090 760 -5090 {}
L 1 820 -3610 820 -3280 {}
L 1 1360 -3610 1360 -3280 {}
L 1 1900 -3440 1900 -3280 {}
L 1 820 -3090 820 -2990 {}
L 1 710 -3090 710 -2990 {}
L 1 930 -3090 930 -2990 {}
L 1 820 -3970 820 -3820 {}
L 1 1360 -3970 1360 -3820 {}
L 1 1900 -3970 1900 -3860 {}
L 1 1487.5 -5462.5 1492.5 -5462.5 {}
L 1 1487.5 -5460 1492.5 -5460 {}
L 1 1487.5 -5457.5 1492.5 -5457.5 {}
L 1 1487.5 -5455 1492.5 -5455 {}
L 1 1487.5 -5452.5 1492.5 -5452.5 {}
L 1 1487.5 -5450 1492.5 -5450 {}
L 1 1487.5 -5447.5 1492.5 -5447.5 {}
L 1 1487.5 -5445 1492.5 -5445 {}
L 1 1487.5 -5442.5 1492.5 -5442.5 {}
L 1 1937.5 -5532.5 1942.5 -5532.5 {}
L 1 1937.5 -5530 1942.5 -5530 {}
L 1 1937.5 -5527.5 1942.5 -5527.5 {}
L 1 1937.5 -5525 1942.5 -5525 {}
L 1 1937.5 -5522.5 1942.5 -5522.5 {}
L 1 1937.5 -5520 1942.5 -5520 {}
L 1 1937.5 -5517.5 1942.5 -5517.5 {}
L 1 1937.5 -5515 1942.5 -5515 {}
L 1 1937.5 -5512.5 1942.5 -5512.5 {}
L 1 2557.5 -5442.5 2562.5 -5442.5 {}
L 1 2557.5 -5440 2562.5 -5440 {}
L 1 2557.5 -5437.5 2562.5 -5437.5 {}
L 1 2557.5 -5435 2562.5 -5435 {}
L 1 2557.5 -5432.5 2562.5 -5432.5 {}
L 1 2557.5 -5430 2562.5 -5430 {}
L 1 2557.5 -5427.5 2562.5 -5427.5 {}
L 1 2557.5 -5425 2562.5 -5425 {}
L 1 2557.5 -5422.5 2562.5 -5422.5 {}
L 1 687.5 -7262.5 692.5 -7262.5 {}
L 1 687.5 -7260 692.5 -7260 {}
L 1 687.5 -7257.5 692.5 -7257.5 {}
L 1 687.5 -7255 692.5 -7255 {}
L 1 687.5 -7252.5 692.5 -7252.5 {}
L 1 687.5 -7250 692.5 -7250 {}
L 1 687.5 -7247.5 692.5 -7247.5 {}
L 1 687.5 -7245 692.5 -7245 {}
L 1 687.5 -7242.5 692.5 -7242.5 {}
L 1 1347.5 -7282.5 1352.5 -7282.5 {}
L 1 1347.5 -7280 1352.5 -7280 {}
L 1 1347.5 -7277.5 1352.5 -7277.5 {}
L 1 1347.5 -7275 1352.5 -7275 {}
L 1 1347.5 -7272.5 1352.5 -7272.5 {}
L 1 1347.5 -7270 1352.5 -7270 {}
L 1 1347.5 -7267.5 1352.5 -7267.5 {}
L 1 1347.5 -7265 1352.5 -7265 {}
L 1 1347.5 -7262.5 1352.5 -7262.5 {}
L 1 2537.5 -7332.5 2542.5 -7332.5 {}
L 1 2537.5 -7330 2542.5 -7330 {}
L 1 2537.5 -7327.5 2542.5 -7327.5 {}
L 1 2537.5 -7325 2542.5 -7325 {}
L 1 2537.5 -7322.5 2542.5 -7322.5 {}
L 1 2537.5 -7320 2542.5 -7320 {}
L 1 2537.5 -7317.5 2542.5 -7317.5 {}
L 1 2537.5 -7315 2542.5 -7315 {}
L 1 2537.5 -7312.5 2542.5 -7312.5 {}
L 1 1387.5 -4722.5 1392.5 -4722.5 {}
L 1 1387.5 -4720 1392.5 -4720 {}
L 1 1387.5 -4717.5 1392.5 -4717.5 {}
L 1 1387.5 -4715 1392.5 -4715 {}
L 1 1387.5 -4712.5 1392.5 -4712.5 {}
L 1 1387.5 -4710 1392.5 -4710 {}
L 1 1387.5 -4707.5 1392.5 -4707.5 {}
L 1 1387.5 -4705 1392.5 -4705 {}
L 1 1387.5 -4702.5 1392.5 -4702.5 {}
L 1 1787.5 -4672.5 1792.5 -4672.5 {}
L 1 1787.5 -4670 1792.5 -4670 {}
L 1 1787.5 -4667.5 1792.5 -4667.5 {}
L 1 1787.5 -4665 1792.5 -4665 {}
L 1 1787.5 -4662.5 1792.5 -4662.5 {}
L 1 1787.5 -4660 1792.5 -4660 {}
L 1 1787.5 -4657.5 1792.5 -4657.5 {}
L 1 1787.5 -4655 1792.5 -4655 {}
L 1 1787.5 -4652.5 1792.5 -4652.5 {}
L 1 2347.5 -4702.5 2352.5 -4702.5 {}
L 1 2347.5 -4700 2352.5 -4700 {}
L 1 2347.5 -4697.5 2352.5 -4697.5 {}
L 1 2347.5 -4695 2352.5 -4695 {}
L 1 2347.5 -4692.5 2352.5 -4692.5 {}
L 1 2347.5 -4690 2352.5 -4690 {}
L 1 2347.5 -4687.5 2352.5 -4687.5 {}
L 1 2347.5 -4685 2352.5 -4685 {}
L 1 2347.5 -4682.5 2352.5 -4682.5 {}
L 1 1427.5 -4152.5 1432.5 -4152.5 {}
L 1 1427.5 -4150 1432.5 -4150 {}
L 1 1427.5 -4147.5 1432.5 -4147.5 {}
L 1 1427.5 -4145 1432.5 -4145 {}
L 1 1427.5 -4142.5 1432.5 -4142.5 {}
L 1 1427.5 -4140 1432.5 -4140 {}
L 1 1427.5 -4137.5 1432.5 -4137.5 {}
L 1 1427.5 -4135 1432.5 -4135 {}
L 1 1427.5 -4132.5 1432.5 -4132.5 {}
L 1 1697.5 -4152.5 1702.5 -4152.5 {}
L 1 1697.5 -4150 1702.5 -4150 {}
L 1 1697.5 -4147.5 1702.5 -4147.5 {}
L 1 1697.5 -4145 1702.5 -4145 {}
L 1 1697.5 -4142.5 1702.5 -4142.5 {}
L 1 1697.5 -4140 1702.5 -4140 {}
L 1 1697.5 -4137.5 1702.5 -4137.5 {}
L 1 1697.5 -4135 1702.5 -4135 {}
L 1 1697.5 -4132.5 1702.5 -4132.5 {}
L 1 2297.5 -4152.5 2302.5 -4152.5 {}
L 1 2297.5 -4150 2302.5 -4150 {}
L 1 2297.5 -4147.5 2302.5 -4147.5 {}
L 1 2297.5 -4145 2302.5 -4145 {}
L 1 2297.5 -4142.5 2302.5 -4142.5 {}
L 1 2297.5 -4140 2302.5 -4140 {}
L 1 2297.5 -4137.5 2302.5 -4137.5 {}
L 1 2297.5 -4135 2302.5 -4135 {}
L 1 2297.5 -4132.5 2302.5 -4132.5 {}
L 1 1427.5 -3772.5 1432.5 -3772.5 {}
L 1 1427.5 -3770 1432.5 -3770 {}
L 1 1427.5 -3767.5 1432.5 -3767.5 {}
L 1 1427.5 -3765 1432.5 -3765 {}
L 1 1427.5 -3762.5 1432.5 -3762.5 {}
L 1 1427.5 -3760 1432.5 -3760 {}
L 1 1427.5 -3757.5 1432.5 -3757.5 {}
L 1 1427.5 -3755 1432.5 -3755 {}
L 1 1427.5 -3752.5 1432.5 -3752.5 {}
L 1 820 -1160 820 -1060 {}
L 1 710 -1160 710 -1060 {}
L 1 930 -1160 930 -1060 {}
L 1 820 -1000 820 -970 {}
L 1 710 -1000 710 -970 {}
L 1 930 -1000 930 -970 {}
L 1 2077.5 -1042.5 2082.5 -1042.5 {}
L 1 2077.5 -1040 2082.5 -1040 {}
L 1 2077.5 -1037.5 2082.5 -1037.5 {}
L 1 2077.5 -1035 2082.5 -1035 {}
L 1 2077.5 -1032.5 2082.5 -1032.5 {}
L 1 2077.5 -1030 2082.5 -1030 {}
L 1 2077.5 -1027.5 2082.5 -1027.5 {}
L 1 2077.5 -1025 2082.5 -1025 {}
L 1 2077.5 -1022.5 2082.5 -1022.5 {}
L 1 1567.5 -1012.5 1572.5 -1012.5 {}
L 1 1567.5 -1010 1572.5 -1010 {}
L 1 1567.5 -1007.5 1572.5 -1007.5 {}
L 1 1567.5 -1005 1572.5 -1005 {}
L 1 1567.5 -1002.5 1572.5 -1002.5 {}
L 1 1567.5 -1000 1572.5 -1000 {}
L 1 1567.5 -997.5 1572.5 -997.5 {}
L 1 1567.5 -995 1572.5 -995 {}
L 1 1567.5 -992.5 1572.5 -992.5 {}
L 1 1427.5 -3412.5 1432.5 -3412.5 {}
L 1 1427.5 -3410 1432.5 -3410 {}
L 1 1427.5 -3407.5 1432.5 -3407.5 {}
L 1 1427.5 -3405 1432.5 -3405 {}
L 1 1427.5 -3402.5 1432.5 -3402.5 {}
L 1 1427.5 -3400 1432.5 -3400 {}
L 1 1427.5 -3397.5 1432.5 -3397.5 {}
L 1 1427.5 -3395 1432.5 -3395 {}
L 1 1427.5 -3392.5 1432.5 -3392.5 {}
L 1 1957.5 -3522.5 1962.5 -3522.5 {}
L 1 1957.5 -3520 1962.5 -3520 {}
L 1 1957.5 -3517.5 1962.5 -3517.5 {}
L 1 1957.5 -3515 1962.5 -3515 {}
L 1 1957.5 -3512.5 1962.5 -3512.5 {}
L 1 1957.5 -3510 1962.5 -3510 {}
L 1 1957.5 -3507.5 1962.5 -3507.5 {}
L 1 1957.5 -3505 1962.5 -3505 {}
L 1 1957.5 -3502.5 1962.5 -3502.5 {}
L 1 1577.5 -3002.5 1582.5 -3002.5 {}
L 1 1577.5 -3000 1582.5 -3000 {}
L 1 1577.5 -2997.5 1582.5 -2997.5 {}
L 1 1577.5 -2995 1582.5 -2995 {}
L 1 1577.5 -2992.5 1582.5 -2992.5 {}
L 1 1577.5 -2990 1582.5 -2990 {}
L 1 1577.5 -2987.5 1582.5 -2987.5 {}
L 1 1577.5 -2985 1582.5 -2985 {}
L 1 1577.5 -2982.5 1582.5 -2982.5 {}
L 1 2067.5 -3062.5 2072.5 -3062.5 {}
L 1 2067.5 -3060 2072.5 -3060 {}
L 1 2067.5 -3057.5 2072.5 -3057.5 {}
L 1 2067.5 -3055 2072.5 -3055 {}
L 1 2067.5 -3052.5 2072.5 -3052.5 {}
L 1 2067.5 -3050 2072.5 -3050 {}
L 1 2067.5 -3047.5 2072.5 -3047.5 {}
L 1 2067.5 -3045 2072.5 -3045 {}
L 1 2067.5 -3042.5 2072.5 -3042.5 {}
L 1 2597.5 -3192.5 2602.5 -3192.5 {}
L 1 2597.5 -3190 2602.5 -3190 {}
L 1 2597.5 -3187.5 2602.5 -3187.5 {}
L 1 2597.5 -3185 2602.5 -3185 {}
L 1 2597.5 -3182.5 2602.5 -3182.5 {}
L 1 2597.5 -3180 2602.5 -3180 {}
L 1 2597.5 -3177.5 2602.5 -3177.5 {}
L 1 2597.5 -3175 2602.5 -3175 {}
L 1 2597.5 -3172.5 2602.5 -3172.5 {}
L 1 987.5 -9412.5 992.5 -9412.5 {}
L 1 987.5 -9410 992.5 -9410 {}
L 1 987.5 -9407.5 992.5 -9407.5 {}
L 1 987.5 -9405 992.5 -9405 {}
L 1 987.5 -9402.5 992.5 -9402.5 {}
L 1 987.5 -9400 992.5 -9400 {}
L 1 987.5 -9397.5 992.5 -9397.5 {}
L 1 987.5 -9395 992.5 -9395 {}
L 1 987.5 -9392.5 992.5 -9392.5 {}
L 1 820 -780 820 -680 {}
L 1 710 -780 710 -680 {}
L 1 930 -780 930 -680 {}
L 1 1567.5 -632.5 1572.5 -632.5 {}
L 1 1567.5 -630 1572.5 -630 {}
L 1 1567.5 -627.5 1572.5 -627.5 {}
L 1 1567.5 -625 1572.5 -625 {}
L 1 1567.5 -622.5 1572.5 -622.5 {}
L 1 1567.5 -620 1572.5 -620 {}
L 1 1567.5 -617.5 1572.5 -617.5 {}
L 1 1567.5 -615 1572.5 -615 {}
L 1 1567.5 -612.5 1572.5 -612.5 {}
L 1 2077.5 -582.5 2082.5 -582.5 {}
L 1 2077.5 -580 2082.5 -580 {}
L 1 2077.5 -577.5 2082.5 -577.5 {}
L 1 2077.5 -575 2082.5 -575 {}
L 1 2077.5 -572.5 2082.5 -572.5 {}
L 1 2077.5 -570 2082.5 -570 {}
L 1 2077.5 -567.5 2082.5 -567.5 {}
L 1 2077.5 -565 2082.5 -565 {}
L 1 2077.5 -562.5 2082.5 -562.5 {}
L 1 620 -2360 870 -2360 {}
L 1 1340 -2360 1410 -2360 {}
L 1 1160 -2360 1220 -2360 {}
L 1 1790 -2360 2040 -2360 {}
L 1 2340 -2360 2590 -2360 {}
L 1 620 -2080 870 -2080 {}
L 1 1160 -2080 1410 -2080 {}
L 1 1790 -2080 2040 -2080 {}
L 1 1910 -2200 1910 -2080 {}
L 1 2460 -2080 2590 -2080 {}
L 1 2460 -2200 2460 -2080 {}
L 1 2360 -3440 2360 -3280 {}
L 1 2497.5 -3442.5 2502.5 -3442.5 {}
L 1 2497.5 -3440 2502.5 -3440 {}
L 1 2497.5 -3437.5 2502.5 -3437.5 {}
L 1 2497.5 -3435 2502.5 -3435 {}
L 1 2497.5 -3432.5 2502.5 -3432.5 {}
L 1 2497.5 -3430 2502.5 -3430 {}
L 1 2497.5 -3427.5 2502.5 -3427.5 {}
L 1 2497.5 -3425 2502.5 -3425 {}
L 1 2497.5 -3422.5 2502.5 -3422.5 {}
L 1 1160 -1500 1410 -1500 {}
L 1 1880 -1370 1950 -1370 {}
L 1 1700 -1370 1760 -1370 {}
L 1 1817.5 -1482.5 1822.5 -1482.5 {}
L 1 1817.5 -1480 1822.5 -1480 {}
L 1 1817.5 -1477.5 1822.5 -1477.5 {}
L 1 1817.5 -1475 1822.5 -1475 {}
L 1 1817.5 -1472.5 1822.5 -1472.5 {}
L 1 1817.5 -1470 1822.5 -1470 {}
L 1 1817.5 -1467.5 1822.5 -1467.5 {}
L 1 1817.5 -1465 1822.5 -1465 {}
L 1 1817.5 -1462.5 1822.5 -1462.5 {}
L 1 620 -1500 870 -1500 {}
L 1 667.5 -1412.5 672.5 -1412.5 {}
L 1 667.5 -1410 672.5 -1410 {}
L 1 667.5 -1407.5 672.5 -1407.5 {}
L 1 667.5 -1405 672.5 -1405 {}
L 1 667.5 -1402.5 672.5 -1402.5 {}
L 1 667.5 -1400 672.5 -1400 {}
L 1 667.5 -1397.5 672.5 -1397.5 {}
L 1 667.5 -1395 672.5 -1395 {}
L 1 667.5 -1392.5 672.5 -1392.5 {}
L 1 787.5 -1412.5 792.5 -1412.5 {}
L 1 787.5 -1410 792.5 -1410 {}
L 1 787.5 -1407.5 792.5 -1407.5 {}
L 1 787.5 -1405 792.5 -1405 {}
L 1 787.5 -1402.5 792.5 -1402.5 {}
L 1 787.5 -1400 792.5 -1400 {}
L 1 787.5 -1397.5 792.5 -1397.5 {}
L 1 787.5 -1395 792.5 -1395 {}
L 1 787.5 -1392.5 792.5 -1392.5 {}
L 1 1647.5 -82.5 1652.5 -82.5 {}
L 1 1647.5 -80 1652.5 -80 {}
L 1 1647.5 -77.5 1652.5 -77.5 {}
L 1 1647.5 -75 1652.5 -75 {}
L 1 1647.5 -72.5 1652.5 -72.5 {}
L 1 1647.5 -70 1652.5 -70 {}
L 1 1647.5 -67.5 1652.5 -67.5 {}
L 1 1647.5 -65 1652.5 -65 {}
L 1 1647.5 -62.5 1652.5 -62.5 {}
L 1 620 -1680 870 -1680 {}
L 1 1160 -1680 1410 -1680 {}
L 1 1790 -1680 2040 -1680 {}
L 1 1830 -1850 1830 -1730 {}
L 1 457.5 -4902.5 462.5 -4902.5 {}
L 1 457.5 -4900 462.5 -4900 {}
L 1 457.5 -4897.5 462.5 -4897.5 {}
L 1 457.5 -4895 462.5 -4895 {}
L 1 457.5 -4892.5 462.5 -4892.5 {}
L 1 457.5 -4890 462.5 -4890 {}
L 1 457.5 -4887.5 462.5 -4887.5 {}
L 1 457.5 -4885 462.5 -4885 {}
L 1 457.5 -4882.5 462.5 -4882.5 {}
L 1 1060 -5090 1300 -5090 {}
L 1 997.5 -5082.5 1002.5 -5082.5 {}
L 1 997.5 -5080 1002.5 -5080 {}
L 1 997.5 -5077.5 1002.5 -5077.5 {}
L 1 997.5 -5075 1002.5 -5075 {}
L 1 997.5 -5072.5 1002.5 -5072.5 {}
L 1 997.5 -5070 1002.5 -5070 {}
L 1 997.5 -5067.5 1002.5 -5067.5 {}
L 1 997.5 -5065 1002.5 -5065 {}
L 1 997.5 -5062.5 1002.5 -5062.5 {}
L 1 1620 -5090 1860 -5090 {}
L 1 2007.5 -4872.5 2012.5 -4872.5 {}
L 1 2007.5 -4870 2012.5 -4870 {}
L 1 2007.5 -4867.5 2012.5 -4867.5 {}
L 1 2007.5 -4865 2012.5 -4865 {}
L 1 2007.5 -4862.5 2012.5 -4862.5 {}
L 1 2007.5 -4860 2012.5 -4860 {}
L 1 2007.5 -4857.5 2012.5 -4857.5 {}
L 1 2007.5 -4855 2012.5 -4855 {}
L 1 2007.5 -4852.5 2012.5 -4852.5 {}
L 1 1620 -5090 1620 -4910 {}
L 1 2190 -5090 2430 -5090 {}
L 1 2577.5 -4872.5 2582.5 -4872.5 {}
L 1 2577.5 -4870 2582.5 -4870 {}
L 1 2577.5 -4867.5 2582.5 -4867.5 {}
L 1 2577.5 -4865 2582.5 -4865 {}
L 1 2577.5 -4862.5 2582.5 -4862.5 {}
L 1 2577.5 -4860 2582.5 -4860 {}
L 1 2577.5 -4857.5 2582.5 -4857.5 {}
L 1 2577.5 -4855 2582.5 -4855 {}
L 1 2577.5 -4852.5 2582.5 -4852.5 {}
L 1 2190 -5090 2190 -4910 {}
L 1 2277.5 -5662.5 2282.5 -5662.5 {}
L 1 2277.5 -5660 2282.5 -5660 {}
L 1 2277.5 -5657.5 2282.5 -5657.5 {}
L 1 2277.5 -5655 2282.5 -5655 {}
L 1 2277.5 -5652.5 2282.5 -5652.5 {}
L 1 2277.5 -5650 2282.5 -5650 {}
L 1 2277.5 -5647.5 2282.5 -5647.5 {}
L 1 2277.5 -5645 2282.5 -5645 {}
L 1 2277.5 -5642.5 2282.5 -5642.5 {}
L 1 1977.5 -3772.5 1982.5 -3772.5 {}
L 1 1977.5 -3770 1982.5 -3770 {}
L 1 1977.5 -3767.5 1982.5 -3767.5 {}
L 1 1977.5 -3765 1982.5 -3765 {}
L 1 1977.5 -3762.5 1982.5 -3762.5 {}
L 1 1977.5 -3760 1982.5 -3760 {}
L 1 1977.5 -3757.5 1982.5 -3757.5 {}
L 1 1977.5 -3755 1982.5 -3755 {}
L 1 1977.5 -3752.5 1982.5 -3752.5 {}
L 1 2337.5 -2072.5 2342.5 -2072.5 {}
L 1 2337.5 -2070 2342.5 -2070 {}
L 1 2337.5 -2067.5 2342.5 -2067.5 {}
L 1 2337.5 -2065 2342.5 -2065 {}
L 1 2337.5 -2062.5 2342.5 -2062.5 {}
L 1 2337.5 -2060 2342.5 -2060 {}
L 1 2337.5 -2057.5 2342.5 -2057.5 {}
L 1 2337.5 -2055 2342.5 -2055 {}
L 1 2337.5 -2052.5 2342.5 -2052.5 {}
L 1 807.5 -2192.5 812.5 -2192.5 {}
L 1 807.5 -2190 812.5 -2190 {}
L 1 807.5 -2187.5 812.5 -2187.5 {}
L 1 807.5 -2185 812.5 -2185 {}
L 1 807.5 -2182.5 812.5 -2182.5 {}
L 1 807.5 -2180 812.5 -2180 {}
L 1 807.5 -2177.5 812.5 -2177.5 {}
L 1 807.5 -2175 812.5 -2175 {}
L 1 807.5 -2172.5 812.5 -2172.5 {}
L 1 1347.5 -2172.5 1352.5 -2172.5 {}
L 1 1347.5 -2170 1352.5 -2170 {}
L 1 1347.5 -2167.5 1352.5 -2167.5 {}
L 1 1347.5 -2165 1352.5 -2165 {}
L 1 1347.5 -2162.5 1352.5 -2162.5 {}
L 1 1347.5 -2160 1352.5 -2160 {}
L 1 1347.5 -2157.5 1352.5 -2157.5 {}
L 1 1347.5 -2155 1352.5 -2155 {}
L 1 1347.5 -2152.5 1352.5 -2152.5 {}
L 1 2320 -1850 2320 -1730 {}
L 1 1257.5 -1792.5 1262.5 -1792.5 {}
L 1 1257.5 -1790 1262.5 -1790 {}
L 1 1257.5 -1787.5 1262.5 -1787.5 {}
L 1 1257.5 -1785 1262.5 -1785 {}
L 1 1257.5 -1782.5 1262.5 -1782.5 {}
L 1 1257.5 -1780 1262.5 -1780 {}
L 1 1257.5 -1777.5 1262.5 -1777.5 {}
L 1 1257.5 -1775 1262.5 -1775 {}
L 1 1257.5 -1772.5 1262.5 -1772.5 {}
L 1 2517.5 -1742.5 2522.5 -1742.5 {}
L 1 2517.5 -1740 2522.5 -1740 {}
L 1 2517.5 -1737.5 2522.5 -1737.5 {}
L 1 2517.5 -1735 2522.5 -1735 {}
L 1 2517.5 -1732.5 2522.5 -1732.5 {}
L 1 2517.5 -1730 2522.5 -1730 {}
L 1 2517.5 -1727.5 2522.5 -1727.5 {}
L 1 2517.5 -1725 2522.5 -1725 {}
L 1 2517.5 -1722.5 2522.5 -1722.5 {}
L 1 2477.5 -332.5 2482.5 -332.5 {}
L 1 2477.5 -330 2482.5 -330 {}
L 1 2477.5 -327.5 2482.5 -327.5 {}
L 1 2477.5 -325 2482.5 -325 {}
L 1 2477.5 -322.5 2482.5 -322.5 {}
L 1 2477.5 -320 2482.5 -320 {}
L 1 2477.5 -317.5 2482.5 -317.5 {}
L 1 2477.5 -315 2482.5 -315 {}
L 1 2477.5 -312.5 2482.5 -312.5 {}
L 1 457.5 -4562.5 462.5 -4562.5 {}
L 1 457.5 -4560 462.5 -4560 {}
L 1 457.5 -4557.5 462.5 -4557.5 {}
L 1 457.5 -4555 462.5 -4555 {}
L 1 457.5 -4552.5 462.5 -4552.5 {}
L 1 457.5 -4550 462.5 -4550 {}
L 1 457.5 -4547.5 462.5 -4547.5 {}
L 1 457.5 -4545 462.5 -4545 {}
L 1 457.5 -4542.5 462.5 -4542.5 {}
L 1 817.5 -5432.5 822.5 -5432.5 {}
L 1 817.5 -5430 822.5 -5430 {}
L 1 817.5 -5427.5 822.5 -5427.5 {}
L 1 817.5 -5425 822.5 -5425 {}
L 1 817.5 -5422.5 822.5 -5422.5 {}
L 1 817.5 -5420 822.5 -5420 {}
L 1 817.5 -5417.5 822.5 -5417.5 {}
L 1 817.5 -5415 822.5 -5415 {}
L 1 817.5 -5412.5 822.5 -5412.5 {}
L 1 477.5 -7592.5 482.5 -7592.5 {}
L 1 477.5 -7590 482.5 -7590 {}
L 1 477.5 -7587.5 482.5 -7587.5 {}
L 1 477.5 -7585 482.5 -7585 {}
L 1 477.5 -7582.5 482.5 -7582.5 {}
L 1 477.5 -7580 482.5 -7580 {}
L 1 477.5 -7577.5 482.5 -7577.5 {}
L 1 477.5 -7575 482.5 -7575 {}
L 1 477.5 -7572.5 482.5 -7572.5 {}
L 1 667.5 -7702.5 672.5 -7702.5 {}
L 1 667.5 -7700 672.5 -7700 {}
L 1 667.5 -7697.5 672.5 -7697.5 {}
L 1 667.5 -7695 672.5 -7695 {}
L 1 667.5 -7692.5 672.5 -7692.5 {}
L 1 667.5 -7690 672.5 -7690 {}
L 1 667.5 -7687.5 672.5 -7687.5 {}
L 1 667.5 -7685 672.5 -7685 {}
L 1 667.5 -7682.5 672.5 -7682.5 {}
L 1 897.5 -7662.5 902.5 -7662.5 {}
L 1 897.5 -7660 902.5 -7660 {}
L 1 897.5 -7657.5 902.5 -7657.5 {}
L 1 897.5 -7655 902.5 -7655 {}
L 1 897.5 -7652.5 902.5 -7652.5 {}
L 1 897.5 -7650 902.5 -7650 {}
L 1 897.5 -7647.5 902.5 -7647.5 {}
L 1 897.5 -7645 902.5 -7645 {}
L 1 897.5 -7642.5 902.5 -7642.5 {}
L 1 800 -7700 800 -7590 {}
L 1 1107.5 -7702.5 1112.5 -7702.5 {}
L 1 1107.5 -7700 1112.5 -7700 {}
L 1 1107.5 -7697.5 1112.5 -7697.5 {}
L 1 1107.5 -7695 1112.5 -7695 {}
L 1 1107.5 -7692.5 1112.5 -7692.5 {}
L 1 1107.5 -7690 1112.5 -7690 {}
L 1 1107.5 -7687.5 1112.5 -7687.5 {}
L 1 1107.5 -7685 1112.5 -7685 {}
L 1 1107.5 -7682.5 1112.5 -7682.5 {}
L 1 1050 -7700 1050 -7590 {}
L 1 1377.5 -7702.5 1382.5 -7702.5 {}
L 1 1377.5 -7700 1382.5 -7700 {}
L 1 1377.5 -7697.5 1382.5 -7697.5 {}
L 1 1377.5 -7695 1382.5 -7695 {}
L 1 1377.5 -7692.5 1382.5 -7692.5 {}
L 1 1377.5 -7690 1382.5 -7690 {}
L 1 1377.5 -7687.5 1382.5 -7687.5 {}
L 1 1377.5 -7685 1382.5 -7685 {}
L 1 1377.5 -7682.5 1382.5 -7682.5 {}
L 1 1240 -7700 1240 -7590 {}
L 1 1717.5 -7562.5 1722.5 -7562.5 {}
L 1 1717.5 -7560 1722.5 -7560 {}
L 1 1717.5 -7557.5 1722.5 -7557.5 {}
L 1 1717.5 -7555 1722.5 -7555 {}
L 1 1717.5 -7552.5 1722.5 -7552.5 {}
L 1 1717.5 -7550 1722.5 -7550 {}
L 1 1717.5 -7547.5 1722.5 -7547.5 {}
L 1 1717.5 -7545 1722.5 -7545 {}
L 1 1717.5 -7542.5 1722.5 -7542.5 {}
L 1 1530 -7700 1530 -7590 {}
L 1 1530 -7700 1610 -7700 {}
L 1 1967.5 -7672.5 1972.5 -7672.5 {}
L 1 1967.5 -7670 1972.5 -7670 {}
L 1 1967.5 -7667.5 1972.5 -7667.5 {}
L 1 1967.5 -7665 1972.5 -7665 {}
L 1 1967.5 -7662.5 1972.5 -7662.5 {}
L 1 1967.5 -7660 1972.5 -7660 {}
L 1 1967.5 -7657.5 1972.5 -7657.5 {}
L 1 1967.5 -7655 1972.5 -7655 {}
L 1 1967.5 -7652.5 1972.5 -7652.5 {}
L 1 1860 -7700 1860 -7590 {}
L 1 2587.5 -7672.5 2592.5 -7672.5 {}
L 1 2587.5 -7670 2592.5 -7670 {}
L 1 2587.5 -7667.5 2592.5 -7667.5 {}
L 1 2587.5 -7665 2592.5 -7665 {}
L 1 2587.5 -7662.5 2592.5 -7662.5 {}
L 1 2587.5 -7660 2592.5 -7660 {}
L 1 2587.5 -7657.5 2592.5 -7657.5 {}
L 1 2587.5 -7655 2592.5 -7655 {}
L 1 2587.5 -7652.5 2592.5 -7652.5 {}
L 1 2400 -7700 2400 -7590 {}
L 1 2247.5 -7672.5 2252.5 -7672.5 {}
L 1 2247.5 -7670 2252.5 -7670 {}
L 1 2247.5 -7667.5 2252.5 -7667.5 {}
L 1 2247.5 -7665 2252.5 -7665 {}
L 1 2247.5 -7662.5 2252.5 -7662.5 {}
L 1 2247.5 -7660 2252.5 -7660 {}
L 1 2247.5 -7657.5 2252.5 -7657.5 {}
L 1 2247.5 -7655 2252.5 -7655 {}
L 1 2247.5 -7652.5 2252.5 -7652.5 {}
L 1 2110 -7700 2110 -7590 {}
L 1 2380 -4200 2500 -4200 {}
L 1 2380 -4140 2500 -4140 {}
L 2 1255 -8850 1255 -8790 {}
L 2 1255 -8840 1270 -8840 {}
L 2 1270 -8850 1270 -8840 {}
L 2 1255 -8800 1270 -8800 {}
L 2 1270 -8800 1270 -8790 {}
L 2 1245 -8835 1245 -8805 {}
L 2 1245 -8820 1245 -8815 {}
L 2 1230 -8820 1237.5 -8820 {}
L 2 1230 -8820 1245 -8820 {}
L 2 1260 -8820 1270 -8820 {}
L 2 1255 -8825 1260 -8820 {}
L 2 1255 -8815 1260 -8820 {}
L 2 1270 -8890 1270 -8880 {}
L 2 1270 -8890 1277.5 -8892.5 {}
L 2 1262.5 -8897.5 1277.5 -8892.5 {}
L 2 1262.5 -8897.5 1277.5 -8902.5 {}
L 2 1262.5 -8907.5 1277.5 -8902.5 {}
L 2 1262.5 -8907.5 1277.5 -8912.5 {}
L 2 1262.5 -8917.5 1277.5 -8912.5 {}
L 2 1262.5 -8917.5 1277.5 -8922.5 {}
L 2 1262.5 -8927.5 1277.5 -8922.5 {}
L 2 1262.5 -8927.5 1270 -8930 {}
L 2 1270 -8940 1270 -8930 {}
L 2 1272.5 -8932.5 1277.5 -8932.5 {}
L 2 1275 -8935 1275 -8930 {}
L 2 1360 -8815 1360 -8790 {}
L 2 1360 -8850 1360 -8825 {}
L 2 1350 -8825 1370 -8825 {}
L 2 1350 -8815 1370 -8815 {}
L 2 1362.5 -8842.5 1367.5 -8842.5 {}
L 2 1365 -8845 1365 -8840 {}
L 2 1270 -8880 1270 -8850 {}
L 2 1270 -8970 1270 -8940 {}
L 2 1360 -8790 1360 -8710 {}
L 2 1270 -8820 1270 -8710 {}
L 2 1270 -8710 1360 -8710 {}
L 2 2035 -8860 2035 -8800 {}
L 2 2035 -8850 2050 -8850 {}
L 2 2050 -8860 2050 -8850 {}
L 2 2035 -8810 2050 -8810 {}
L 2 2050 -8810 2050 -8800 {}
L 2 2025 -8845 2025 -8815 {}
L 2 2025 -8830 2025 -8825 {}
L 2 2010 -8830 2017.5 -8830 {}
L 2 2010 -8830 2025 -8830 {}
L 2 2040 -8830 2050 -8830 {}
L 2 2035 -8835 2040 -8830 {}
L 2 2035 -8825 2040 -8830 {}
L 2 2050 -8900 2050 -8890 {}
L 2 2050 -8900 2057.5 -8902.5 {}
L 2 2042.5 -8907.5 2057.5 -8902.5 {}
L 2 2042.5 -8907.5 2057.5 -8912.5 {}
L 2 2042.5 -8917.5 2057.5 -8912.5 {}
L 2 2042.5 -8917.5 2057.5 -8922.5 {}
L 2 2042.5 -8927.5 2057.5 -8922.5 {}
L 2 2042.5 -8927.5 2057.5 -8932.5 {}
L 2 2042.5 -8937.5 2057.5 -8932.5 {}
L 2 2042.5 -8937.5 2050 -8940 {}
L 2 2050 -8950 2050 -8940 {}
L 2 2052.5 -8942.5 2057.5 -8942.5 {}
L 2 2055 -8945 2055 -8940 {}
L 2 2140 -8825 2140 -8800 {}
L 2 2140 -8860 2140 -8835 {}
L 2 2130 -8835 2150 -8835 {}
L 2 2130 -8825 2150 -8825 {}
L 2 2142.5 -8852.5 2147.5 -8852.5 {}
L 2 2145 -8855 2145 -8850 {}
L 2 2050 -8890 2050 -8860 {}
L 2 2050 -8980 2050 -8950 {}
L 2 2140 -8800 2140 -8720 {}
L 2 2050 -8830 2050 -8720 {}
L 2 2050 -8720 2140 -8720 {}
L 2 1360 -8430 1360 -8420 {}
L 2 1360 -8430 1367.5 -8432.5 {}
L 2 1352.5 -8437.5 1367.5 -8432.5 {}
L 2 1352.5 -8437.5 1367.5 -8442.5 {}
L 2 1352.5 -8447.5 1367.5 -8442.5 {}
L 2 1352.5 -8447.5 1367.5 -8452.5 {}
L 2 1352.5 -8457.5 1367.5 -8452.5 {}
L 2 1352.5 -8457.5 1367.5 -8462.5 {}
L 2 1352.5 -8467.5 1367.5 -8462.5 {}
L 2 1352.5 -8467.5 1360 -8470 {}
L 2 1360 -8480 1360 -8470 {}
L 2 1362.5 -8472.5 1367.5 -8472.5 {}
L 2 1365 -8475 1365 -8470 {}
L 2 1360 -6810 1360 -6800 {}
L 2 1360 -6810 1367.5 -6812.5 {}
L 2 1352.5 -6817.5 1367.5 -6812.5 {}
L 2 1352.5 -6817.5 1367.5 -6822.5 {}
L 2 1352.5 -6827.5 1367.5 -6822.5 {}
L 2 1352.5 -6827.5 1367.5 -6832.5 {}
L 2 1352.5 -6837.5 1367.5 -6832.5 {}
L 2 1352.5 -6837.5 1367.5 -6842.5 {}
L 2 1352.5 -6847.5 1367.5 -6842.5 {}
L 2 1352.5 -6847.5 1360 -6850 {}
L 2 1360 -6860 1360 -6850 {}
L 2 1362.5 -6852.5 1367.5 -6852.5 {}
L 2 1365 -6855 1365 -6850 {}
L 2 1280 -6860 1360 -6860 {}
L 2 1280 -6800 1360 -6800 {}
L 2 1360 -6320 1360 -6310 {}
L 2 1360 -6320 1367.5 -6322.5 {}
L 2 1352.5 -6327.5 1367.5 -6322.5 {}
L 2 1352.5 -6327.5 1367.5 -6332.5 {}
L 2 1352.5 -6337.5 1367.5 -6332.5 {}
L 2 1352.5 -6337.5 1367.5 -6342.5 {}
L 2 1352.5 -6347.5 1367.5 -6342.5 {}
L 2 1352.5 -6347.5 1367.5 -6352.5 {}
L 2 1352.5 -6357.5 1367.5 -6352.5 {}
L 2 1352.5 -6357.5 1360 -6360 {}
L 2 1360 -6370 1360 -6360 {}
L 2 1362.5 -6362.5 1367.5 -6362.5 {}
L 2 1365 -6365 1365 -6360 {}
L 2 1280 -6280 1360 -6310 {}
L 2 1280 -6400 1360 -6370 {}
L 2 725 -8850 725 -8790 {}
L 2 725 -8840 740 -8840 {}
L 2 740 -8850 740 -8840 {}
L 2 725 -8800 740 -8800 {}
L 2 740 -8800 740 -8790 {}
L 2 715 -8835 715 -8805 {}
L 2 715 -8820 715 -8815 {}
L 2 700 -8820 707.5 -8820 {}
L 2 700 -8820 715 -8820 {}
L 2 730 -8820 740 -8820 {}
L 2 725 -8825 730 -8820 {}
L 2 725 -8815 730 -8820 {}
L 2 740 -8890 740 -8880 {}
L 2 740 -8890 747.5 -8892.5 {}
L 2 732.5 -8897.5 747.5 -8892.5 {}
L 2 732.5 -8897.5 747.5 -8902.5 {}
L 2 732.5 -8907.5 747.5 -8902.5 {}
L 2 732.5 -8907.5 747.5 -8912.5 {}
L 2 732.5 -8917.5 747.5 -8912.5 {}
L 2 732.5 -8917.5 747.5 -8922.5 {}
L 2 732.5 -8927.5 747.5 -8922.5 {}
L 2 732.5 -8927.5 740 -8930 {}
L 2 740 -8940 740 -8930 {}
L 2 742.5 -8932.5 747.5 -8932.5 {}
L 2 745 -8935 745 -8930 {}
L 2 830 -8815 830 -8790 {}
L 2 830 -8850 830 -8825 {}
L 2 820 -8825 840 -8825 {}
L 2 820 -8815 840 -8815 {}
L 2 832.5 -8842.5 837.5 -8842.5 {}
L 2 835 -8845 835 -8840 {}
L 2 740 -8880 740 -8850 {}
L 2 740 -8970 740 -8940 {}
L 2 830 -8790 830 -8710 {}
L 2 740 -8820 740 -8710 {}
L 2 740 -8710 830 -8710 {}
L 2 725 -5790 725 -5730 {}
L 2 725 -5780 740 -5780 {}
L 2 740 -5790 740 -5780 {}
L 2 725 -5740 740 -5740 {}
L 2 740 -5740 740 -5730 {}
L 2 715 -5775 715 -5745 {}
L 2 715 -5760 715 -5755 {}
L 2 700 -5760 707.5 -5760 {}
L 2 700 -5760 715 -5760 {}
L 2 730 -5760 740 -5760 {}
L 2 725 -5765 730 -5760 {}
L 2 725 -5755 730 -5760 {}
L 2 740 -5830 740 -5820 {}
L 2 740 -5830 747.5 -5832.5 {}
L 2 732.5 -5837.5 747.5 -5832.5 {}
L 2 732.5 -5837.5 747.5 -5842.5 {}
L 2 732.5 -5847.5 747.5 -5842.5 {}
L 2 732.5 -5847.5 747.5 -5852.5 {}
L 2 732.5 -5857.5 747.5 -5852.5 {}
L 2 732.5 -5857.5 747.5 -5862.5 {}
L 2 732.5 -5867.5 747.5 -5862.5 {}
L 2 732.5 -5867.5 740 -5870 {}
L 2 740 -5880 740 -5870 {}
L 2 742.5 -5872.5 747.5 -5872.5 {}
L 2 745 -5875 745 -5870 {}
L 2 830 -5755 830 -5730 {}
L 2 830 -5790 830 -5765 {}
L 2 820 -5765 840 -5765 {}
L 2 820 -5755 840 -5755 {}
L 2 832.5 -5782.5 837.5 -5782.5 {}
L 2 835 -5785 835 -5780 {}
L 2 740 -5820 740 -5790 {}
L 2 740 -5910 740 -5880 {}
L 2 830 -5730 830 -5650 {}
L 2 740 -5760 740 -5650 {}
L 2 740 -5650 830 -5650 {}
L 2 880 -5790 888.75 -5790 {}
L 2 740 -5790 880 -5790 {}
L 2 1265 -5790 1265 -5730 {}
L 2 1265 -5780 1280 -5780 {}
L 2 1280 -5790 1280 -5780 {}
L 2 1265 -5740 1280 -5740 {}
L 2 1280 -5740 1280 -5730 {}
L 2 1255 -5775 1255 -5745 {}
L 2 1255 -5760 1255 -5755 {}
L 2 1240 -5760 1247.5 -5760 {}
L 2 1240 -5760 1255 -5760 {}
L 2 1270 -5760 1280 -5760 {}
L 2 1265 -5765 1270 -5760 {}
L 2 1265 -5755 1270 -5760 {}
L 2 1280 -5830 1280 -5820 {}
L 2 1280 -5830 1287.5 -5832.5 {}
L 2 1272.5 -5837.5 1287.5 -5832.5 {}
L 2 1272.5 -5837.5 1287.5 -5842.5 {}
L 2 1272.5 -5847.5 1287.5 -5842.5 {}
L 2 1272.5 -5847.5 1287.5 -5852.5 {}
L 2 1272.5 -5857.5 1287.5 -5852.5 {}
L 2 1272.5 -5857.5 1287.5 -5862.5 {}
L 2 1272.5 -5867.5 1287.5 -5862.5 {}
L 2 1272.5 -5867.5 1280 -5870 {}
L 2 1280 -5880 1280 -5870 {}
L 2 1282.5 -5872.5 1287.5 -5872.5 {}
L 2 1285 -5875 1285 -5870 {}
L 2 1370 -5755 1370 -5730 {}
L 2 1370 -5790 1370 -5765 {}
L 2 1360 -5765 1380 -5765 {}
L 2 1360 -5755 1380 -5755 {}
L 2 1372.5 -5782.5 1377.5 -5782.5 {}
L 2 1375 -5785 1375 -5780 {}
L 2 1420 -5790 1428.75 -5790 {}
L 2 1280 -5820 1280 -5790 {}
L 2 1280 -5910 1280 -5880 {}
L 2 1280 -5790 1420 -5790 {}
L 2 1370 -5730 1370 -5650 {}
L 2 1280 -5760 1280 -5650 {}
L 2 1280 -5650 1370 -5650 {}
L 2 2105 -5790 2105 -5730 {}
L 2 2105 -5780 2120 -5780 {}
L 2 2120 -5790 2120 -5780 {}
L 2 2105 -5740 2120 -5740 {}
L 2 2120 -5740 2120 -5730 {}
L 2 2095 -5775 2095 -5745 {}
L 2 2095 -5760 2095 -5755 {}
L 2 2080 -5760 2087.5 -5760 {}
L 2 2080 -5760 2095 -5760 {}
L 2 2110 -5760 2120 -5760 {}
L 2 2105 -5765 2110 -5760 {}
L 2 2105 -5755 2110 -5760 {}
L 2 2120 -5830 2120 -5820 {}
L 2 2120 -5830 2127.5 -5832.5 {}
L 2 2112.5 -5837.5 2127.5 -5832.5 {}
L 2 2112.5 -5837.5 2127.5 -5842.5 {}
L 2 2112.5 -5847.5 2127.5 -5842.5 {}
L 2 2112.5 -5847.5 2127.5 -5852.5 {}
L 2 2112.5 -5857.5 2127.5 -5852.5 {}
L 2 2112.5 -5857.5 2127.5 -5862.5 {}
L 2 2112.5 -5867.5 2127.5 -5862.5 {}
L 2 2112.5 -5867.5 2120 -5870 {}
L 2 2120 -5880 2120 -5870 {}
L 2 2122.5 -5872.5 2127.5 -5872.5 {}
L 2 2125 -5875 2125 -5870 {}
L 2 2210 -5755 2210 -5730 {}
L 2 2210 -5790 2210 -5765 {}
L 2 2200 -5765 2220 -5765 {}
L 2 2200 -5755 2220 -5755 {}
L 2 2212.5 -5782.5 2217.5 -5782.5 {}
L 2 2215 -5785 2215 -5780 {}
L 2 2260 -5790 2268.75 -5790 {}
L 2 2120 -5820 2120 -5790 {}
L 2 2120 -5910 2120 -5880 {}
L 2 2120 -5790 2260 -5790 {}
L 2 2210 -5730 2210 -5650 {}
L 2 2120 -5760 2120 -5650 {}
L 2 2120 -5650 2210 -5650 {}
L 2 1770 -5760 2080 -5760 {}
L 2 1690 -5910 2120 -5910 {}
L 2 1690 -5650 2120 -5650 {}
L 2 1255 -8020 1255 -7960 {}
L 2 1255 -8010 1270 -8010 {}
L 2 1270 -8020 1270 -8010 {}
L 2 1255 -7970 1270 -7970 {}
L 2 1270 -7970 1270 -7960 {}
L 2 1245 -8005 1245 -7975 {}
L 2 1245 -7990 1245 -7985 {}
L 2 1230 -7990 1237.5 -7990 {}
L 2 1230 -7990 1245 -7990 {}
L 2 1260 -7990 1270 -7990 {}
L 2 1255 -7995 1260 -7990 {}
L 2 1255 -7985 1260 -7990 {}
L 2 1270 -8060 1270 -8050 {}
L 2 1270 -8060 1277.5 -8062.5 {}
L 2 1262.5 -8067.5 1277.5 -8062.5 {}
L 2 1262.5 -8067.5 1277.5 -8072.5 {}
L 2 1262.5 -8077.5 1277.5 -8072.5 {}
L 2 1262.5 -8077.5 1277.5 -8082.5 {}
L 2 1262.5 -8087.5 1277.5 -8082.5 {}
L 2 1262.5 -8087.5 1277.5 -8092.5 {}
L 2 1262.5 -8097.5 1277.5 -8092.5 {}
L 2 1262.5 -8097.5 1270 -8100 {}
L 2 1270 -8110 1270 -8100 {}
L 2 1272.5 -8102.5 1277.5 -8102.5 {}
L 2 1275 -8105 1275 -8100 {}
L 2 1360 -7985 1360 -7960 {}
L 2 1360 -8020 1360 -7995 {}
L 2 1350 -7995 1370 -7995 {}
L 2 1350 -7985 1370 -7985 {}
L 2 1362.5 -8012.5 1367.5 -8012.5 {}
L 2 1365 -8015 1365 -8010 {}
L 2 1270 -8050 1270 -8020 {}
L 2 1270 -8140 1270 -8110 {}
L 2 1360 -7960 1360 -7880 {}
L 2 1270 -7990 1270 -7880 {}
L 2 1270 -7880 1360 -7880 {}
L 2 2035 -8030 2035 -7970 {}
L 2 2035 -8020 2050 -8020 {}
L 2 2050 -8030 2050 -8020 {}
L 2 2035 -7980 2050 -7980 {}
L 2 2050 -7980 2050 -7970 {}
L 2 2025 -8015 2025 -7985 {}
L 2 2025 -8000 2025 -7995 {}
L 2 2010 -8000 2017.5 -8000 {}
L 2 2010 -8000 2025 -8000 {}
L 2 2040 -8000 2050 -8000 {}
L 2 2035 -8005 2040 -8000 {}
L 2 2035 -7995 2040 -8000 {}
L 2 2050 -8070 2050 -8060 {}
L 2 2050 -8070 2057.5 -8072.5 {}
L 2 2042.5 -8077.5 2057.5 -8072.5 {}
L 2 2042.5 -8077.5 2057.5 -8082.5 {}
L 2 2042.5 -8087.5 2057.5 -8082.5 {}
L 2 2042.5 -8087.5 2057.5 -8092.5 {}
L 2 2042.5 -8097.5 2057.5 -8092.5 {}
L 2 2042.5 -8097.5 2057.5 -8102.5 {}
L 2 2042.5 -8107.5 2057.5 -8102.5 {}
L 2 2042.5 -8107.5 2050 -8110 {}
L 2 2050 -8120 2050 -8110 {}
L 2 2052.5 -8112.5 2057.5 -8112.5 {}
L 2 2055 -8115 2055 -8110 {}
L 2 2140 -7995 2140 -7970 {}
L 2 2140 -8030 2140 -8005 {}
L 2 2130 -8005 2150 -8005 {}
L 2 2130 -7995 2150 -7995 {}
L 2 2142.5 -8022.5 2147.5 -8022.5 {}
L 2 2145 -8025 2145 -8020 {}
L 2 2050 -8060 2050 -8030 {}
L 2 2050 -8150 2050 -8120 {}
L 2 2140 -7970 2140 -7890 {}
L 2 2050 -8000 2050 -7890 {}
L 2 2050 -7890 2140 -7890 {}
L 2 725 -8020 725 -7960 {}
L 2 725 -8010 740 -8010 {}
L 2 740 -8020 740 -8010 {}
L 2 725 -7970 740 -7970 {}
L 2 740 -7970 740 -7960 {}
L 2 715 -8005 715 -7975 {}
L 2 715 -7990 715 -7985 {}
L 2 700 -7990 707.5 -7990 {}
L 2 700 -7990 715 -7990 {}
L 2 730 -7990 740 -7990 {}
L 2 725 -7995 730 -7990 {}
L 2 725 -7985 730 -7990 {}
L 2 740 -8060 740 -8050 {}
L 2 740 -8060 747.5 -8062.5 {}
L 2 732.5 -8067.5 747.5 -8062.5 {}
L 2 732.5 -8067.5 747.5 -8072.5 {}
L 2 732.5 -8077.5 747.5 -8072.5 {}
L 2 732.5 -8077.5 747.5 -8082.5 {}
L 2 732.5 -8087.5 747.5 -8082.5 {}
L 2 732.5 -8087.5 747.5 -8092.5 {}
L 2 732.5 -8097.5 747.5 -8092.5 {}
L 2 732.5 -8097.5 740 -8100 {}
L 2 740 -8110 740 -8100 {}
L 2 742.5 -8102.5 747.5 -8102.5 {}
L 2 745 -8105 745 -8100 {}
L 2 830 -7985 830 -7960 {}
L 2 830 -8020 830 -7995 {}
L 2 820 -7995 840 -7995 {}
L 2 820 -7985 840 -7985 {}
L 2 832.5 -8012.5 837.5 -8012.5 {}
L 2 835 -8015 835 -8010 {}
L 2 740 -8050 740 -8020 {}
L 2 740 -8140 740 -8110 {}
L 2 830 -7960 830 -7880 {}
L 2 740 -7990 740 -7880 {}
L 2 740 -7880 830 -7880 {}
L 2 1795 -9320 1795 -9260 {}
L 2 1795 -9310 1810 -9310 {}
L 2 1810 -9320 1810 -9310 {}
L 2 1795 -9270 1810 -9270 {}
L 2 1810 -9270 1810 -9260 {}
L 2 1785 -9305 1785 -9275 {}
L 2 1785 -9290 1785 -9285 {}
L 2 1770 -9290 1777.5 -9290 {}
L 2 1770 -9290 1785 -9290 {}
L 2 1800 -9290 1810 -9290 {}
L 2 1795 -9295 1800 -9290 {}
L 2 1795 -9285 1800 -9290 {}
L 2 1810 -9360 1810 -9350 {}
L 2 1810 -9360 1817.5 -9362.5 {}
L 2 1802.5 -9367.5 1817.5 -9362.5 {}
L 2 1802.5 -9367.5 1817.5 -9372.5 {}
L 2 1802.5 -9377.5 1817.5 -9372.5 {}
L 2 1802.5 -9377.5 1817.5 -9382.5 {}
L 2 1802.5 -9387.5 1817.5 -9382.5 {}
L 2 1802.5 -9387.5 1817.5 -9392.5 {}
L 2 1802.5 -9397.5 1817.5 -9392.5 {}
L 2 1802.5 -9397.5 1810 -9400 {}
L 2 1810 -9410 1810 -9400 {}
L 2 1812.5 -9402.5 1817.5 -9402.5 {}
L 2 1815 -9405 1815 -9400 {}
L 2 1900 -9285 1900 -9260 {}
L 2 1900 -9320 1900 -9295 {}
L 2 1890 -9295 1910 -9295 {}
L 2 1890 -9285 1910 -9285 {}
L 2 1902.5 -9312.5 1907.5 -9312.5 {}
L 2 1905 -9315 1905 -9310 {}
L 2 1810 -9350 1810 -9320 {}
L 2 1810 -9440 1810 -9410 {}
L 2 1900 -9260 1900 -9180 {}
L 2 1810 -9290 1810 -9180 {}
L 2 1810 -9180 1900 -9180 {}
L 2 725 -9320 725 -9260 {}
L 2 725 -9310 740 -9310 {}
L 2 740 -9320 740 -9310 {}
L 2 725 -9270 740 -9270 {}
L 2 740 -9270 740 -9260 {}
L 2 715 -9305 715 -9275 {}
L 2 715 -9290 715 -9285 {}
L 2 700 -9290 707.5 -9290 {}
L 2 700 -9290 715 -9290 {}
L 2 730 -9290 740 -9290 {}
L 2 725 -9295 730 -9290 {}
L 2 725 -9285 730 -9290 {}
L 2 740 -9360 740 -9350 {}
L 2 740 -9360 747.5 -9362.5 {}
L 2 732.5 -9367.5 747.5 -9362.5 {}
L 2 732.5 -9367.5 747.5 -9372.5 {}
L 2 732.5 -9377.5 747.5 -9372.5 {}
L 2 732.5 -9377.5 747.5 -9382.5 {}
L 2 732.5 -9387.5 747.5 -9382.5 {}
L 2 732.5 -9387.5 747.5 -9392.5 {}
L 2 732.5 -9397.5 747.5 -9392.5 {}
L 2 732.5 -9397.5 740 -9400 {}
L 2 740 -9410 740 -9400 {}
L 2 742.5 -9402.5 747.5 -9402.5 {}
L 2 745 -9405 745 -9400 {}
L 2 830 -9285 830 -9260 {}
L 2 830 -9320 830 -9295 {}
L 2 820 -9295 840 -9295 {}
L 2 820 -9285 840 -9285 {}
L 2 832.5 -9312.5 837.5 -9312.5 {}
L 2 835 -9315 835 -9310 {}
L 2 740 -9350 740 -9320 {}
L 2 740 -9440 740 -9410 {}
L 2 830 -9260 830 -9180 {}
L 2 740 -9290 740 -9180 {}
L 2 740 -9180 830 -9180 {}
L 2 1572.5 -9252.5 1577.5 -9252.5 {}
L 2 1575 -9255 1575 -9250 {}
L 2 1570 -9260 1570 -9200 {}
L 2 1570 -9200 1570 -9180 {}
L 2 1570 -9440 1570 -9260 {}
L 2 2255 -9320 2255 -9260 {}
L 2 2255 -9310 2270 -9310 {}
L 2 2270 -9320 2270 -9310 {}
L 2 2255 -9270 2270 -9270 {}
L 2 2270 -9270 2270 -9260 {}
L 2 2245 -9305 2245 -9275 {}
L 2 2245 -9290 2245 -9285 {}
L 2 2230 -9290 2237.5 -9290 {}
L 2 2230 -9290 2245 -9290 {}
L 2 2260 -9290 2270 -9290 {}
L 2 2255 -9295 2260 -9290 {}
L 2 2255 -9285 2260 -9290 {}
L 2 2270 -9360 2270 -9350 {}
L 2 2270 -9360 2277.5 -9362.5 {}
L 2 2262.5 -9367.5 2277.5 -9362.5 {}
L 2 2262.5 -9367.5 2277.5 -9372.5 {}
L 2 2262.5 -9377.5 2277.5 -9372.5 {}
L 2 2262.5 -9377.5 2277.5 -9382.5 {}
L 2 2262.5 -9387.5 2277.5 -9382.5 {}
L 2 2262.5 -9387.5 2277.5 -9392.5 {}
L 2 2262.5 -9397.5 2277.5 -9392.5 {}
L 2 2262.5 -9397.5 2270 -9400 {}
L 2 2270 -9410 2270 -9400 {}
L 2 2272.5 -9402.5 2277.5 -9402.5 {}
L 2 2275 -9405 2275 -9400 {}
L 2 2270 -9350 2270 -9320 {}
L 2 2270 -9440 2270 -9410 {}
L 2 2270 -9290 2270 -9180 {}
L 2 2270 -9180 2360 -9180 {}
L 2 2032.5 -9252.5 2037.5 -9252.5 {}
L 2 2035 -9255 2035 -9250 {}
L 2 2030 -9260 2030 -9200 {}
L 2 2030 -9200 2030 -9180 {}
L 2 2030 -9440 2030 -9260 {}
L 2 1300 -5440 1430 -5440 {}
L 2 1860 -5440 1990 -5440 {}
L 2 2430 -5470 2560 -5470 {}
L 2 520 -7300 760 -7300 {}
L 2 1060 -7300 1300 -7300 {}
L 2 2190 -7300 2500 -7370 {}
L 2 1300 -4630 1300 -4620 {}
L 2 1300 -4630 1307.5 -4632.5 {}
L 2 1292.5 -4637.5 1307.5 -4632.5 {}
L 2 1292.5 -4637.5 1307.5 -4642.5 {}
L 2 1292.5 -4647.5 1307.5 -4642.5 {}
L 2 1292.5 -4647.5 1307.5 -4652.5 {}
L 2 1292.5 -4657.5 1307.5 -4652.5 {}
L 2 1292.5 -4657.5 1307.5 -4662.5 {}
L 2 1292.5 -4667.5 1307.5 -4662.5 {}
L 2 1292.5 -4667.5 1300 -4670 {}
L 2 1300 -4680 1300 -4670 {}
L 2 1302.5 -4672.5 1307.5 -4672.5 {}
L 2 1305 -4675 1305 -4670 {}
L 2 1170 -4730 1170 -4710 {}
L 2 1160 -4730 1180 -4730 {}
L 2 1300 -4710 1300 -4680 {}
L 2 1060 -4710 1300 -4710 {}
L 2 1060 -4710 1060 -4530 {}
L 2 1300 -4620 1300 -4590 {}
L 2 2400 -4660 2400 -4650 {}
L 2 2400 -4660 2407.5 -4662.5 {}
L 2 2392.5 -4667.5 2407.5 -4662.5 {}
L 2 2392.5 -4667.5 2407.5 -4672.5 {}
L 2 2392.5 -4677.5 2407.5 -4672.5 {}
L 2 2392.5 -4677.5 2407.5 -4682.5 {}
L 2 2392.5 -4687.5 2407.5 -4682.5 {}
L 2 2392.5 -4687.5 2407.5 -4692.5 {}
L 2 2392.5 -4697.5 2407.5 -4692.5 {}
L 2 2392.5 -4697.5 2400 -4700 {}
L 2 2400 -4710 2400 -4700 {}
L 2 2402.5 -4702.5 2407.5 -4702.5 {}
L 2 2405 -4705 2405 -4700 {}
L 2 2270 -4760 2270 -4740 {}
L 2 2260 -4760 2280 -4760 {}
L 2 2400 -4740 2400 -4710 {}
L 2 2160 -4740 2400 -4740 {}
L 2 2160 -4740 2160 -4530 {}
L 2 2400 -4650 2400 -4590 {}
L 2 1840 -4630 1840 -4620 {}
L 2 1840 -4630 1847.5 -4632.5 {}
L 2 1832.5 -4637.5 1847.5 -4632.5 {}
L 2 1832.5 -4637.5 1847.5 -4642.5 {}
L 2 1832.5 -4647.5 1847.5 -4642.5 {}
L 2 1832.5 -4647.5 1847.5 -4652.5 {}
L 2 1832.5 -4657.5 1847.5 -4652.5 {}
L 2 1832.5 -4657.5 1847.5 -4662.5 {}
L 2 1832.5 -4667.5 1847.5 -4662.5 {}
L 2 1832.5 -4667.5 1840 -4670 {}
L 2 1840 -4680 1840 -4670 {}
L 2 1842.5 -4672.5 1847.5 -4672.5 {}
L 2 1845 -4675 1845 -4670 {}
L 2 1710 -4730 1710 -4710 {}
L 2 1700 -4730 1720 -4730 {}
L 2 1840 -4710 1840 -4680 {}
L 2 1600 -4710 1840 -4710 {}
L 2 1600 -4710 1600 -4530 {}
L 2 1840 -4620 1840 -4590 {}
L 2 1360 -3770 1360 -3760 {}
L 2 1360 -3770 1367.5 -3772.5 {}
L 2 1352.5 -3777.5 1367.5 -3772.5 {}
L 2 1352.5 -3777.5 1367.5 -3782.5 {}
L 2 1352.5 -3787.5 1367.5 -3782.5 {}
L 2 1352.5 -3787.5 1367.5 -3792.5 {}
L 2 1352.5 -3797.5 1367.5 -3792.5 {}
L 2 1352.5 -3797.5 1367.5 -3802.5 {}
L 2 1352.5 -3807.5 1367.5 -3802.5 {}
L 2 1352.5 -3807.5 1360 -3810 {}
L 2 1360 -3820 1360 -3810 {}
L 2 1362.5 -3812.5 1367.5 -3812.5 {}
L 2 1365 -3815 1365 -3810 {}
L 2 1900 -3800 1900 -3760 {}
L 2 1360 -4150 1360 -4140 {}
L 2 1360 -4150 1367.5 -4152.5 {}
L 2 1352.5 -4157.5 1367.5 -4152.5 {}
L 2 1352.5 -4157.5 1367.5 -4162.5 {}
L 2 1352.5 -4167.5 1367.5 -4162.5 {}
L 2 1352.5 -4167.5 1367.5 -4172.5 {}
L 2 1352.5 -4177.5 1367.5 -4172.5 {}
L 2 1352.5 -4177.5 1367.5 -4182.5 {}
L 2 1352.5 -4187.5 1367.5 -4182.5 {}
L 2 1352.5 -4187.5 1360 -4190 {}
L 2 1360 -4200 1360 -4190 {}
L 2 1362.5 -4192.5 1367.5 -4192.5 {}
L 2 1365 -4195 1365 -4190 {}
L 2 1360 -4210 1360 -4200 {}
L 2 1780 -4200 1900 -4200 {}
L 2 1780 -4140 1900 -4140 {}
L 2 1780 -4150 1780 -4140 {}
L 2 1780 -4150 1787.5 -4152.5 {}
L 2 1772.5 -4157.5 1787.5 -4152.5 {}
L 2 1772.5 -4157.5 1787.5 -4162.5 {}
L 2 1772.5 -4167.5 1787.5 -4162.5 {}
L 2 1772.5 -4167.5 1787.5 -4172.5 {}
L 2 1772.5 -4177.5 1787.5 -4172.5 {}
L 2 1772.5 -4177.5 1787.5 -4182.5 {}
L 2 1772.5 -4187.5 1787.5 -4182.5 {}
L 2 1772.5 -4187.5 1780 -4190 {}
L 2 1780 -4200 1780 -4190 {}
L 2 1782.5 -4192.5 1787.5 -4192.5 {}
L 2 1785 -4195 1785 -4190 {}
L 2 1360 -3090 1360 -2990 {}
L 2 1250 -3090 1250 -2990 {}
L 2 1470 -3090 1470 -2990 {}
L 2 1900 -3090 1900 -2990 {}
L 2 1790 -3090 1790 -2990 {}
L 2 2010 -3090 2010 -2990 {}
L 2 2430 -3190 2430 -2990 {}
L 2 2320 -3190 2320 -2990 {}
L 2 2540 -3190 2540 -2990 {}
L 2 1360 -1160 1360 -1060 {}
L 2 1250 -1160 1250 -1060 {}
L 2 1470 -1160 1470 -1060 {}
L 2 1250 -1010 1250 -1000 {}
L 2 1250 -1010 1257.5 -1012.5 {}
L 2 1242.5 -1017.5 1257.5 -1012.5 {}
L 2 1242.5 -1017.5 1257.5 -1022.5 {}
L 2 1242.5 -1027.5 1257.5 -1022.5 {}
L 2 1242.5 -1027.5 1257.5 -1032.5 {}
L 2 1242.5 -1037.5 1257.5 -1032.5 {}
L 2 1242.5 -1037.5 1257.5 -1042.5 {}
L 2 1242.5 -1047.5 1257.5 -1042.5 {}
L 2 1242.5 -1047.5 1250 -1050 {}
L 2 1250 -1060 1250 -1050 {}
L 2 1252.5 -1052.5 1257.5 -1052.5 {}
L 2 1255 -1055 1255 -1050 {}
L 2 1360 -1010 1360 -1000 {}
L 2 1360 -1010 1367.5 -1012.5 {}
L 2 1352.5 -1017.5 1367.5 -1012.5 {}
L 2 1352.5 -1017.5 1367.5 -1022.5 {}
L 2 1352.5 -1027.5 1367.5 -1022.5 {}
L 2 1352.5 -1027.5 1367.5 -1032.5 {}
L 2 1352.5 -1037.5 1367.5 -1032.5 {}
L 2 1352.5 -1037.5 1367.5 -1042.5 {}
L 2 1352.5 -1047.5 1367.5 -1042.5 {}
L 2 1352.5 -1047.5 1360 -1050 {}
L 2 1360 -1060 1360 -1050 {}
L 2 1362.5 -1052.5 1367.5 -1052.5 {}
L 2 1365 -1055 1365 -1050 {}
L 2 1470 -1010 1470 -1000 {}
L 2 1470 -1010 1477.5 -1012.5 {}
L 2 1462.5 -1017.5 1477.5 -1012.5 {}
L 2 1462.5 -1017.5 1477.5 -1022.5 {}
L 2 1462.5 -1027.5 1477.5 -1022.5 {}
L 2 1462.5 -1027.5 1477.5 -1032.5 {}
L 2 1462.5 -1037.5 1477.5 -1032.5 {}
L 2 1462.5 -1037.5 1477.5 -1042.5 {}
L 2 1462.5 -1047.5 1477.5 -1042.5 {}
L 2 1462.5 -1047.5 1470 -1050 {}
L 2 1470 -1060 1470 -1050 {}
L 2 1472.5 -1052.5 1477.5 -1052.5 {}
L 2 1475 -1055 1475 -1050 {}
L 2 1360 -1000 1360 -970 {}
L 2 1250 -1000 1250 -970 {}
L 2 1470 -1000 1470 -970 {}
L 2 1900 -1160 1900 -1110 {}
L 2 1790 -1160 1790 -1110 {}
L 2 2010 -1160 2010 -1110 {}
L 2 1790 -1060 1790 -1050 {}
L 2 1790 -1060 1797.5 -1062.5 {}
L 2 1782.5 -1067.5 1797.5 -1062.5 {}
L 2 1782.5 -1067.5 1797.5 -1072.5 {}
L 2 1782.5 -1077.5 1797.5 -1072.5 {}
L 2 1782.5 -1077.5 1797.5 -1082.5 {}
L 2 1782.5 -1087.5 1797.5 -1082.5 {}
L 2 1782.5 -1087.5 1797.5 -1092.5 {}
L 2 1782.5 -1097.5 1797.5 -1092.5 {}
L 2 1782.5 -1097.5 1790 -1100 {}
L 2 1790 -1110 1790 -1100 {}
L 2 1792.5 -1102.5 1797.5 -1102.5 {}
L 2 1795 -1105 1795 -1100 {}
L 2 1900 -1060 1900 -1050 {}
L 2 1900 -1060 1907.5 -1062.5 {}
L 2 1892.5 -1067.5 1907.5 -1062.5 {}
L 2 1892.5 -1067.5 1907.5 -1072.5 {}
L 2 1892.5 -1077.5 1907.5 -1072.5 {}
L 2 1892.5 -1077.5 1907.5 -1082.5 {}
L 2 1892.5 -1087.5 1907.5 -1082.5 {}
L 2 1892.5 -1087.5 1907.5 -1092.5 {}
L 2 1892.5 -1097.5 1907.5 -1092.5 {}
L 2 1892.5 -1097.5 1900 -1100 {}
L 2 1900 -1110 1900 -1100 {}
L 2 1902.5 -1102.5 1907.5 -1102.5 {}
L 2 1905 -1105 1905 -1100 {}
L 2 2010 -1060 2010 -1050 {}
L 2 2010 -1060 2017.5 -1062.5 {}
L 2 2002.5 -1067.5 2017.5 -1062.5 {}
L 2 2002.5 -1067.5 2017.5 -1072.5 {}
L 2 2002.5 -1077.5 2017.5 -1072.5 {}
L 2 2002.5 -1077.5 2017.5 -1082.5 {}
L 2 2002.5 -1087.5 2017.5 -1082.5 {}
L 2 2002.5 -1087.5 2017.5 -1092.5 {}
L 2 2002.5 -1097.5 2017.5 -1092.5 {}
L 2 2002.5 -1097.5 2010 -1100 {}
L 2 2010 -1110 2010 -1100 {}
L 2 2012.5 -1102.5 2017.5 -1102.5 {}
L 2 2015 -1105 2015 -1100 {}
L 2 1900 -1050 1900 -970 {}
L 2 1790 -1050 1790 -970 {}
L 2 2010 -1050 2010 -970 {}
L 2 635 -2730 635 -2670 {}
L 2 635 -2720 650 -2720 {}
L 2 650 -2730 650 -2720 {}
L 2 635 -2680 650 -2680 {}
L 2 650 -2680 650 -2670 {}
L 2 625 -2715 625 -2685 {}
L 2 625 -2700 625 -2695 {}
L 2 610 -2700 617.5 -2700 {}
L 2 610 -2700 625 -2700 {}
L 2 640 -2700 650 -2700 {}
L 2 635 -2705 640 -2700 {}
L 2 635 -2695 640 -2700 {}
L 2 1215 -2730 1215 -2670 {}
L 2 1215 -2720 1230 -2720 {}
L 2 1230 -2730 1230 -2720 {}
L 2 1215 -2680 1230 -2680 {}
L 2 1230 -2680 1230 -2670 {}
L 2 1205 -2715 1205 -2685 {}
L 2 1205 -2700 1205 -2695 {}
L 2 1190 -2700 1197.5 -2700 {}
L 2 1190 -2700 1205 -2700 {}
L 2 1220 -2700 1230 -2700 {}
L 2 1215 -2705 1220 -2700 {}
L 2 1215 -2695 1220 -2700 {}
L 2 1255 -9320 1255 -9260 {}
L 2 1255 -9310 1270 -9310 {}
L 2 1270 -9320 1270 -9310 {}
L 2 1255 -9270 1270 -9270 {}
L 2 1270 -9270 1270 -9260 {}
L 2 1245 -9305 1245 -9275 {}
L 2 1245 -9290 1245 -9285 {}
L 2 1230 -9290 1237.5 -9290 {}
L 2 1230 -9290 1245 -9290 {}
L 2 1260 -9290 1270 -9290 {}
L 2 1255 -9295 1260 -9290 {}
L 2 1255 -9285 1260 -9290 {}
L 2 1270 -9360 1270 -9350 {}
L 2 1270 -9360 1277.5 -9362.5 {}
L 2 1262.5 -9367.5 1277.5 -9362.5 {}
L 2 1262.5 -9367.5 1277.5 -9372.5 {}
L 2 1262.5 -9377.5 1277.5 -9372.5 {}
L 2 1262.5 -9377.5 1277.5 -9382.5 {}
L 2 1262.5 -9387.5 1277.5 -9382.5 {}
L 2 1262.5 -9387.5 1277.5 -9392.5 {}
L 2 1262.5 -9397.5 1277.5 -9392.5 {}
L 2 1262.5 -9397.5 1270 -9400 {}
L 2 1270 -9410 1270 -9400 {}
L 2 1272.5 -9402.5 1277.5 -9402.5 {}
L 2 1275 -9405 1275 -9400 {}
L 2 1360 -9285 1360 -9260 {}
L 2 1360 -9320 1360 -9295 {}
L 2 1350 -9295 1370 -9295 {}
L 2 1350 -9285 1370 -9285 {}
L 2 1362.5 -9312.5 1367.5 -9312.5 {}
L 2 1365 -9315 1365 -9310 {}
L 2 1270 -9350 1270 -9320 {}
L 2 1270 -9440 1270 -9410 {}
L 2 1360 -9260 1360 -9180 {}
L 2 1270 -9290 1270 -9180 {}
L 2 1270 -9180 1360 -9180 {}
L 2 1360 -780 1360 -680 {}
L 2 1250 -780 1250 -680 {}
L 2 1470 -780 1470 -680 {}
L 2 1250 -630 1250 -620 {}
L 2 1250 -630 1257.5 -632.5 {}
L 2 1242.5 -637.5 1257.5 -632.5 {}
L 2 1242.5 -637.5 1257.5 -642.5 {}
L 2 1242.5 -647.5 1257.5 -642.5 {}
L 2 1242.5 -647.5 1257.5 -652.5 {}
L 2 1242.5 -657.5 1257.5 -652.5 {}
L 2 1242.5 -657.5 1257.5 -662.5 {}
L 2 1242.5 -667.5 1257.5 -662.5 {}
L 2 1242.5 -667.5 1250 -670 {}
L 2 1250 -680 1250 -670 {}
L 2 1252.5 -672.5 1257.5 -672.5 {}
L 2 1255 -675 1255 -670 {}
L 2 1360 -630 1360 -620 {}
L 2 1360 -630 1367.5 -632.5 {}
L 2 1352.5 -637.5 1367.5 -632.5 {}
L 2 1352.5 -637.5 1367.5 -642.5 {}
L 2 1352.5 -647.5 1367.5 -642.5 {}
L 2 1352.5 -647.5 1367.5 -652.5 {}
L 2 1352.5 -657.5 1367.5 -652.5 {}
L 2 1352.5 -657.5 1367.5 -662.5 {}
L 2 1352.5 -667.5 1367.5 -662.5 {}
L 2 1352.5 -667.5 1360 -670 {}
L 2 1360 -680 1360 -670 {}
L 2 1362.5 -672.5 1367.5 -672.5 {}
L 2 1365 -675 1365 -670 {}
L 2 1470 -630 1470 -620 {}
L 2 1470 -630 1477.5 -632.5 {}
L 2 1462.5 -637.5 1477.5 -632.5 {}
L 2 1462.5 -637.5 1477.5 -642.5 {}
L 2 1462.5 -647.5 1477.5 -642.5 {}
L 2 1462.5 -647.5 1477.5 -652.5 {}
L 2 1462.5 -657.5 1477.5 -652.5 {}
L 2 1462.5 -657.5 1477.5 -662.5 {}
L 2 1462.5 -667.5 1477.5 -662.5 {}
L 2 1462.5 -667.5 1470 -670 {}
L 2 1470 -680 1470 -670 {}
L 2 1472.5 -672.5 1477.5 -672.5 {}
L 2 1475 -675 1475 -670 {}
L 2 1900 -780 1900 -730 {}
L 2 1790 -780 1790 -730 {}
L 2 2010 -780 2010 -730 {}
L 2 1790 -680 1790 -670 {}
L 2 1790 -680 1797.5 -682.5 {}
L 2 1782.5 -687.5 1797.5 -682.5 {}
L 2 1782.5 -687.5 1797.5 -692.5 {}
L 2 1782.5 -697.5 1797.5 -692.5 {}
L 2 1782.5 -697.5 1797.5 -702.5 {}
L 2 1782.5 -707.5 1797.5 -702.5 {}
L 2 1782.5 -707.5 1797.5 -712.5 {}
L 2 1782.5 -717.5 1797.5 -712.5 {}
L 2 1782.5 -717.5 1790 -720 {}
L 2 1790 -730 1790 -720 {}
L 2 1792.5 -722.5 1797.5 -722.5 {}
L 2 1795 -725 1795 -720 {}
L 2 1900 -680 1900 -670 {}
L 2 1900 -680 1907.5 -682.5 {}
L 2 1892.5 -687.5 1907.5 -682.5 {}
L 2 1892.5 -687.5 1907.5 -692.5 {}
L 2 1892.5 -697.5 1907.5 -692.5 {}
L 2 1892.5 -697.5 1907.5 -702.5 {}
L 2 1892.5 -707.5 1907.5 -702.5 {}
L 2 1892.5 -707.5 1907.5 -712.5 {}
L 2 1892.5 -717.5 1907.5 -712.5 {}
L 2 1892.5 -717.5 1900 -720 {}
L 2 1900 -730 1900 -720 {}
L 2 1902.5 -722.5 1907.5 -722.5 {}
L 2 1905 -725 1905 -720 {}
L 2 2010 -680 2010 -670 {}
L 2 2010 -680 2017.5 -682.5 {}
L 2 2002.5 -687.5 2017.5 -682.5 {}
L 2 2002.5 -687.5 2017.5 -692.5 {}
L 2 2002.5 -697.5 2017.5 -692.5 {}
L 2 2002.5 -697.5 2017.5 -702.5 {}
L 2 2002.5 -707.5 2017.5 -702.5 {}
L 2 2002.5 -707.5 2017.5 -712.5 {}
L 2 2002.5 -717.5 2017.5 -712.5 {}
L 2 2002.5 -717.5 2010 -720 {}
L 2 2010 -730 2010 -720 {}
L 2 2012.5 -722.5 2017.5 -722.5 {}
L 2 2015 -725 2015 -720 {}
L 2 1900 -670 1900 -590 {}
L 2 1790 -670 1790 -590 {}
L 2 2010 -670 2010 -590 {}
L 2 600 -2450 720 -2450 {}
L 2 1220 -2360 1340 -2360 {}
L 2 740 -2230 740 -2110 {}
L 2 1280 -2200 1280 -2080 {}
L 2 2280 -2120 2410 -2120 {}
L 2 2360 -3610 2440 -3440 {}
L 2 1900 -3610 1900 -3440 {}
L 2 1760 -1400 1880 -1400 {}
L 2 680 -1450 680 -1440 {}
L 2 680 -1450 687.5 -1452.5 {}
L 2 672.5 -1457.5 687.5 -1452.5 {}
L 2 672.5 -1457.5 687.5 -1462.5 {}
L 2 672.5 -1467.5 687.5 -1462.5 {}
L 2 672.5 -1467.5 687.5 -1472.5 {}
L 2 672.5 -1477.5 687.5 -1472.5 {}
L 2 672.5 -1477.5 687.5 -1482.5 {}
L 2 672.5 -1487.5 687.5 -1482.5 {}
L 2 672.5 -1487.5 680 -1490 {}
L 2 680 -1500 680 -1490 {}
L 2 682.5 -1492.5 687.5 -1492.5 {}
L 2 685 -1495 685 -1490 {}
L 2 800 -1450 800 -1440 {}
L 2 800 -1450 807.5 -1452.5 {}
L 2 792.5 -1457.5 807.5 -1452.5 {}
L 2 792.5 -1457.5 807.5 -1462.5 {}
L 2 792.5 -1467.5 807.5 -1462.5 {}
L 2 792.5 -1467.5 807.5 -1472.5 {}
L 2 792.5 -1477.5 807.5 -1472.5 {}
L 2 792.5 -1477.5 807.5 -1482.5 {}
L 2 792.5 -1487.5 807.5 -1482.5 {}
L 2 792.5 -1487.5 800 -1490 {}
L 2 800 -1500 800 -1490 {}
L 2 802.5 -1492.5 807.5 -1492.5 {}
L 2 805 -1495 805 -1490 {}
L 2 1220 -1450 1220 -1440 {}
L 2 1220 -1450 1227.5 -1452.5 {}
L 2 1212.5 -1457.5 1227.5 -1452.5 {}
L 2 1212.5 -1457.5 1227.5 -1462.5 {}
L 2 1212.5 -1467.5 1227.5 -1462.5 {}
L 2 1212.5 -1467.5 1227.5 -1472.5 {}
L 2 1212.5 -1477.5 1227.5 -1472.5 {}
L 2 1212.5 -1477.5 1227.5 -1482.5 {}
L 2 1212.5 -1487.5 1227.5 -1482.5 {}
L 2 1212.5 -1487.5 1220 -1490 {}
L 2 1220 -1500 1220 -1490 {}
L 2 1222.5 -1492.5 1227.5 -1492.5 {}
L 2 1225 -1495 1225 -1490 {}
L 2 1340 -1450 1340 -1440 {}
L 2 1340 -1450 1347.5 -1452.5 {}
L 2 1332.5 -1457.5 1347.5 -1452.5 {}
L 2 1332.5 -1457.5 1347.5 -1462.5 {}
L 2 1332.5 -1467.5 1347.5 -1462.5 {}
L 2 1332.5 -1467.5 1347.5 -1472.5 {}
L 2 1332.5 -1477.5 1347.5 -1472.5 {}
L 2 1332.5 -1477.5 1347.5 -1482.5 {}
L 2 1332.5 -1487.5 1347.5 -1482.5 {}
L 2 1332.5 -1487.5 1340 -1490 {}
L 2 1340 -1500 1340 -1490 {}
L 2 1342.5 -1492.5 1347.5 -1492.5 {}
L 2 1345 -1495 1345 -1490 {}
L 2 1560 -185 1560 -160 {}
L 2 1560 -220 1560 -195 {}
L 2 1550 -195 1570 -195 {}
L 2 1550 -185 1570 -185 {}
L 2 1562.5 -212.5 1567.5 -212.5 {}
L 2 1565 -215 1565 -210 {}
L 2 1560 -160 1560 -80 {}
L 2 1230 -100 1230 -80 {}
L 2 1470 -190 1470 -80 {}
L 2 1470 -80 1560 -80 {}
L 2 1230 -80 1470 -80 {}
L 2 1470 -220 1610 -220 {}
L 2 740 -1800 740 -1680 {}
L 2 1200 -1850 1200 -1730 {}
L 2 1060 -5090 1060 -4910 {}
L 2 2520 -4880 2520 -4830 {}
L 2 2360 -1760 2610 -1760 {}
L 2 2430 -365 2430 -340 {}
L 2 2430 -400 2430 -375 {}
L 2 2420 -375 2440 -375 {}
L 2 2420 -365 2440 -365 {}
L 2 2432.5 -392.5 2437.5 -392.5 {}
L 2 2435 -395 2435 -390 {}
L 2 2430 -340 2430 -260 {}
L 2 2100 -280 2100 -260 {}
L 2 2340 -370 2340 -260 {}
L 2 2340 -260 2430 -260 {}
L 2 2100 -260 2340 -260 {}
L 2 2340 -400 2480 -400 {}
L 2 760 -4630 760 -4620 {}
L 2 760 -4630 767.5 -4632.5 {}
L 2 752.5 -4637.5 767.5 -4632.5 {}
L 2 752.5 -4637.5 767.5 -4642.5 {}
L 2 752.5 -4647.5 767.5 -4642.5 {}
L 2 752.5 -4647.5 767.5 -4652.5 {}
L 2 752.5 -4657.5 767.5 -4652.5 {}
L 2 752.5 -4657.5 767.5 -4662.5 {}
L 2 752.5 -4667.5 767.5 -4662.5 {}
L 2 752.5 -4667.5 760 -4670 {}
L 2 760 -4680 760 -4670 {}
L 2 762.5 -4672.5 767.5 -4672.5 {}
L 2 765 -4675 765 -4670 {}
L 2 630 -4730 630 -4710 {}
L 2 620 -4730 640 -4730 {}
L 2 760 -4710 760 -4680 {}
L 2 520 -4710 760 -4710 {}
L 2 520 -4710 520 -4530 {}
L 2 760 -4620 760 -4590 {}
L 2 610 -7700 610 -7590 {}
L 2 1240 -7700 1320 -7700 {}
L 2 1860 -7700 1940 -7700 {}
L 2 2400 -7700 2530 -7700 {}
L 2 2110 -7700 2190 -7700 {}
L 4 1032.5 -8782.5 1037.5 -8782.5 {}
L 4 1035 -8785 1035 -8780 {}
L 4 1030 -8790 1030 -8730 {}
L 4 1140 -8710 1140 -8697.5 {}
L 4 1135 -8697.5 1145 -8697.5 {}
L 4 1140 -8692.5 1145 -8697.5 {}
L 4 1135 -8697.5 1140 -8692.5 {}
L 4 1140 -8990 1140 -8970 {}
L 4 1130 -8990 1150 -8990 {}
L 4 1572.5 -8782.5 1577.5 -8782.5 {}
L 4 1575 -8785 1575 -8780 {}
L 4 1570 -8790 1570 -8730 {}
L 4 1680 -8710 1680 -8697.5 {}
L 4 1675 -8697.5 1685 -8697.5 {}
L 4 1680 -8692.5 1685 -8697.5 {}
L 4 1675 -8697.5 1680 -8692.5 {}
L 4 1680 -8990 1680 -8970 {}
L 4 1670 -8990 1690 -8990 {}
L 4 502.5 -8782.5 507.5 -8782.5 {}
L 4 505 -8785 505 -8780 {}
L 4 500 -8790 500 -8730 {}
L 4 610 -8710 610 -8697.5 {}
L 4 605 -8697.5 615 -8697.5 {}
L 4 610 -8692.5 615 -8697.5 {}
L 4 605 -8697.5 610 -8692.5 {}
L 4 610 -8990 610 -8970 {}
L 4 600 -8990 620 -8990 {}
L 4 725 -8390 725 -8330 {}
L 4 725 -8380 740 -8380 {}
L 4 740 -8390 740 -8380 {}
L 4 725 -8340 740 -8340 {}
L 4 740 -8340 740 -8330 {}
L 4 715 -8375 715 -8345 {}
L 4 715 -8360 715 -8355 {}
L 4 700 -8360 707.5 -8360 {}
L 4 700 -8360 715 -8360 {}
L 4 730 -8360 740 -8360 {}
L 4 725 -8365 730 -8360 {}
L 4 725 -8355 730 -8360 {}
L 4 740 -8430 740 -8420 {}
L 4 740 -8430 747.5 -8432.5 {}
L 4 732.5 -8437.5 747.5 -8432.5 {}
L 4 732.5 -8437.5 747.5 -8442.5 {}
L 4 732.5 -8447.5 747.5 -8442.5 {}
L 4 732.5 -8447.5 747.5 -8452.5 {}
L 4 732.5 -8457.5 747.5 -8452.5 {}
L 4 732.5 -8457.5 747.5 -8462.5 {}
L 4 732.5 -8467.5 747.5 -8462.5 {}
L 4 732.5 -8467.5 740 -8470 {}
L 4 740 -8480 740 -8470 {}
L 4 742.5 -8472.5 747.5 -8472.5 {}
L 4 745 -8475 745 -8470 {}
L 4 830 -8355 830 -8330 {}
L 4 830 -8390 830 -8365 {}
L 4 820 -8365 840 -8365 {}
L 4 820 -8355 840 -8355 {}
L 4 832.5 -8382.5 837.5 -8382.5 {}
L 4 835 -8385 835 -8380 {}
L 4 502.5 -8322.5 507.5 -8322.5 {}
L 4 505 -8325 505 -8320 {}
L 4 500 -8330 500 -8270 {}
L 4 610 -8250 610 -8237.5 {}
L 4 605 -8237.5 615 -8237.5 {}
L 4 610 -8232.5 615 -8237.5 {}
L 4 605 -8237.5 610 -8232.5 {}
L 4 610 -8530 610 -8510 {}
L 4 600 -8530 620 -8530 {}
L 4 1265 -8390 1265 -8330 {}
L 4 1265 -8380 1280 -8380 {}
L 4 1280 -8390 1280 -8380 {}
L 4 1265 -8340 1280 -8340 {}
L 4 1280 -8340 1280 -8330 {}
L 4 1255 -8375 1255 -8345 {}
L 4 1255 -8360 1255 -8355 {}
L 4 1240 -8360 1247.5 -8360 {}
L 4 1240 -8360 1255 -8360 {}
L 4 1270 -8360 1280 -8360 {}
L 4 1265 -8365 1270 -8360 {}
L 4 1265 -8355 1270 -8360 {}
L 4 1370 -8355 1370 -8330 {}
L 4 1370 -8390 1370 -8365 {}
L 4 1360 -8365 1380 -8365 {}
L 4 1360 -8355 1380 -8355 {}
L 4 1372.5 -8382.5 1377.5 -8382.5 {}
L 4 1375 -8385 1375 -8380 {}
L 4 1042.5 -8322.5 1047.5 -8322.5 {}
L 4 1045 -8325 1045 -8320 {}
L 4 1040 -8330 1040 -8270 {}
L 4 1150 -8250 1150 -8237.5 {}
L 4 1145 -8237.5 1155 -8237.5 {}
L 4 1150 -8232.5 1155 -8237.5 {}
L 4 1145 -8237.5 1150 -8232.5 {}
L 4 1150 -8530 1150 -8510 {}
L 4 1140 -8530 1160 -8530 {}
L 4 725 -6770 725 -6710 {}
L 4 725 -6760 740 -6760 {}
L 4 740 -6770 740 -6760 {}
L 4 725 -6720 740 -6720 {}
L 4 740 -6720 740 -6710 {}
L 4 715 -6755 715 -6725 {}
L 4 715 -6740 715 -6735 {}
L 4 700 -6740 707.5 -6740 {}
L 4 700 -6740 715 -6740 {}
L 4 730 -6740 740 -6740 {}
L 4 725 -6745 730 -6740 {}
L 4 725 -6735 730 -6740 {}
L 4 740 -6810 740 -6800 {}
L 4 740 -6810 747.5 -6812.5 {}
L 4 732.5 -6817.5 747.5 -6812.5 {}
L 4 732.5 -6817.5 747.5 -6822.5 {}
L 4 732.5 -6827.5 747.5 -6822.5 {}
L 4 732.5 -6827.5 747.5 -6832.5 {}
L 4 732.5 -6837.5 747.5 -6832.5 {}
L 4 732.5 -6837.5 747.5 -6842.5 {}
L 4 732.5 -6847.5 747.5 -6842.5 {}
L 4 732.5 -6847.5 740 -6850 {}
L 4 740 -6860 740 -6850 {}
L 4 742.5 -6852.5 747.5 -6852.5 {}
L 4 745 -6855 745 -6850 {}
L 4 830 -6735 830 -6710 {}
L 4 830 -6770 830 -6745 {}
L 4 820 -6745 840 -6745 {}
L 4 820 -6735 840 -6735 {}
L 4 832.5 -6762.5 837.5 -6762.5 {}
L 4 835 -6765 835 -6760 {}
L 4 502.5 -6702.5 507.5 -6702.5 {}
L 4 505 -6705 505 -6700 {}
L 4 500 -6710 500 -6650 {}
L 4 610 -6630 610 -6617.5 {}
L 4 605 -6617.5 615 -6617.5 {}
L 4 610 -6612.5 615 -6617.5 {}
L 4 605 -6617.5 610 -6612.5 {}
L 4 610 -6910 610 -6890 {}
L 4 600 -6910 620 -6910 {}
L 4 1265 -6770 1265 -6710 {}
L 4 1265 -6760 1280 -6760 {}
L 4 1280 -6770 1280 -6760 {}
L 4 1265 -6720 1280 -6720 {}
L 4 1280 -6720 1280 -6710 {}
L 4 1255 -6755 1255 -6725 {}
L 4 1255 -6740 1255 -6735 {}
L 4 1240 -6740 1247.5 -6740 {}
L 4 1240 -6740 1255 -6740 {}
L 4 1270 -6740 1280 -6740 {}
L 4 1265 -6745 1270 -6740 {}
L 4 1265 -6735 1270 -6740 {}
L 4 1370 -6735 1370 -6710 {}
L 4 1370 -6770 1370 -6745 {}
L 4 1360 -6745 1380 -6745 {}
L 4 1360 -6735 1380 -6735 {}
L 4 1372.5 -6762.5 1377.5 -6762.5 {}
L 4 1375 -6765 1375 -6760 {}
L 4 1042.5 -6702.5 1047.5 -6702.5 {}
L 4 1045 -6705 1045 -6700 {}
L 4 1040 -6710 1040 -6650 {}
L 4 1150 -6630 1150 -6617.5 {}
L 4 1145 -6617.5 1155 -6617.5 {}
L 4 1150 -6612.5 1155 -6617.5 {}
L 4 1145 -6617.5 1150 -6612.5 {}
L 4 1150 -6910 1150 -6890 {}
L 4 1140 -6910 1160 -6910 {}
L 4 725 -6280 725 -6220 {}
L 4 725 -6270 740 -6270 {}
L 4 740 -6280 740 -6270 {}
L 4 725 -6230 740 -6230 {}
L 4 740 -6230 740 -6220 {}
L 4 715 -6265 715 -6235 {}
L 4 715 -6250 715 -6245 {}
L 4 700 -6250 707.5 -6250 {}
L 4 700 -6250 715 -6250 {}
L 4 730 -6250 740 -6250 {}
L 4 725 -6255 730 -6250 {}
L 4 725 -6245 730 -6250 {}
L 4 740 -6320 740 -6310 {}
L 4 740 -6320 747.5 -6322.5 {}
L 4 732.5 -6327.5 747.5 -6322.5 {}
L 4 732.5 -6327.5 747.5 -6332.5 {}
L 4 732.5 -6337.5 747.5 -6332.5 {}
L 4 732.5 -6337.5 747.5 -6342.5 {}
L 4 732.5 -6347.5 747.5 -6342.5 {}
L 4 732.5 -6347.5 747.5 -6352.5 {}
L 4 732.5 -6357.5 747.5 -6352.5 {}
L 4 732.5 -6357.5 740 -6360 {}
L 4 740 -6370 740 -6360 {}
L 4 742.5 -6362.5 747.5 -6362.5 {}
L 4 745 -6365 745 -6360 {}
L 4 830 -6245 830 -6220 {}
L 4 830 -6280 830 -6255 {}
L 4 820 -6255 840 -6255 {}
L 4 820 -6245 840 -6245 {}
L 4 832.5 -6272.5 837.5 -6272.5 {}
L 4 835 -6275 835 -6270 {}
L 4 502.5 -6212.5 507.5 -6212.5 {}
L 4 505 -6215 505 -6210 {}
L 4 500 -6220 500 -6160 {}
L 4 610 -6140 610 -6127.5 {}
L 4 605 -6127.5 615 -6127.5 {}
L 4 610 -6122.5 615 -6127.5 {}
L 4 605 -6127.5 610 -6122.5 {}
L 4 610 -6420 610 -6400 {}
L 4 600 -6420 620 -6420 {}
L 4 1265 -6280 1265 -6220 {}
L 4 1265 -6270 1280 -6270 {}
L 4 1280 -6280 1280 -6270 {}
L 4 1265 -6230 1280 -6230 {}
L 4 1280 -6230 1280 -6220 {}
L 4 1255 -6265 1255 -6235 {}
L 4 1255 -6250 1255 -6245 {}
L 4 1240 -6250 1247.5 -6250 {}
L 4 1240 -6250 1255 -6250 {}
L 4 1270 -6250 1280 -6250 {}
L 4 1265 -6255 1270 -6250 {}
L 4 1265 -6245 1270 -6250 {}
L 4 1370 -6245 1370 -6220 {}
L 4 1370 -6280 1370 -6255 {}
L 4 1360 -6255 1380 -6255 {}
L 4 1360 -6245 1380 -6245 {}
L 4 1372.5 -6272.5 1377.5 -6272.5 {}
L 4 1375 -6275 1375 -6270 {}
L 4 1042.5 -6212.5 1047.5 -6212.5 {}
L 4 1045 -6215 1045 -6210 {}
L 4 1040 -6220 1040 -6160 {}
L 4 1150 -6140 1150 -6127.5 {}
L 4 1145 -6127.5 1155 -6127.5 {}
L 4 1150 -6122.5 1155 -6127.5 {}
L 4 1145 -6127.5 1150 -6122.5 {}
L 4 1150 -6420 1150 -6400 {}
L 4 1140 -6420 1160 -6420 {}
L 4 502.5 -5722.5 507.5 -5722.5 {}
L 4 505 -5725 505 -5720 {}
L 4 500 -5730 500 -5670 {}
L 4 610 -5650 610 -5637.5 {}
L 4 605 -5637.5 615 -5637.5 {}
L 4 610 -5632.5 615 -5637.5 {}
L 4 605 -5637.5 610 -5632.5 {}
L 4 610 -5930 610 -5910 {}
L 4 600 -5930 620 -5930 {}
L 4 1692.5 -5722.5 1697.5 -5722.5 {}
L 4 1695 -5725 1695 -5720 {}
L 4 1690 -5730 1690 -5670 {}
L 4 1800 -5650 1800 -5637.5 {}
L 4 1795 -5637.5 1805 -5637.5 {}
L 4 1800 -5632.5 1805 -5637.5 {}
L 4 1795 -5637.5 1800 -5632.5 {}
L 4 1800 -5930 1800 -5910 {}
L 4 1790 -5930 1810 -5930 {}
L 4 1042.5 -5722.5 1047.5 -5722.5 {}
L 4 1045 -5725 1045 -5720 {}
L 4 1040 -5730 1040 -5670 {}
L 4 1150 -5650 1150 -5637.5 {}
L 4 1145 -5637.5 1155 -5637.5 {}
L 4 1150 -5632.5 1155 -5637.5 {}
L 4 1145 -5637.5 1150 -5632.5 {}
L 4 1150 -5930 1150 -5910 {}
L 4 1140 -5930 1160 -5930 {}
L 4 1032.5 -7952.5 1037.5 -7952.5 {}
L 4 1035 -7955 1035 -7950 {}
L 4 1030 -7960 1030 -7900 {}
L 4 1140 -7880 1140 -7867.5 {}
L 4 1135 -7867.5 1145 -7867.5 {}
L 4 1140 -7862.5 1145 -7867.5 {}
L 4 1135 -7867.5 1140 -7862.5 {}
L 4 1140 -8160 1140 -8140 {}
L 4 1130 -8160 1150 -8160 {}
L 4 502.5 -7952.5 507.5 -7952.5 {}
L 4 505 -7955 505 -7950 {}
L 4 500 -7960 500 -7900 {}
L 4 610 -7880 610 -7867.5 {}
L 4 605 -7867.5 615 -7867.5 {}
L 4 610 -7862.5 615 -7867.5 {}
L 4 605 -7867.5 610 -7862.5 {}
L 4 610 -8160 610 -8140 {}
L 4 600 -8160 620 -8160 {}
L 4 1755 -8020 1755 -7960 {}
L 4 1755 -8010 1770 -8010 {}
L 4 1770 -8020 1770 -8010 {}
L 4 1755 -7970 1770 -7970 {}
L 4 1770 -7970 1770 -7960 {}
L 4 1745 -8005 1745 -7975 {}
L 4 1745 -7990 1745 -7985 {}
L 4 1730 -7990 1737.5 -7990 {}
L 4 1730 -7990 1745 -7990 {}
L 4 1760 -7990 1770 -7990 {}
L 4 1755 -7995 1760 -7990 {}
L 4 1755 -7985 1760 -7990 {}
L 4 1770 -8060 1770 -8050 {}
L 4 1770 -8060 1777.5 -8062.5 {}
L 4 1762.5 -8067.5 1777.5 -8062.5 {}
L 4 1762.5 -8067.5 1777.5 -8072.5 {}
L 4 1762.5 -8077.5 1777.5 -8072.5 {}
L 4 1762.5 -8077.5 1777.5 -8082.5 {}
L 4 1762.5 -8087.5 1777.5 -8082.5 {}
L 4 1762.5 -8087.5 1777.5 -8092.5 {}
L 4 1762.5 -8097.5 1777.5 -8092.5 {}
L 4 1762.5 -8097.5 1770 -8100 {}
L 4 1770 -8110 1770 -8100 {}
L 4 1772.5 -8102.5 1777.5 -8102.5 {}
L 4 1775 -8105 1775 -8100 {}
L 4 1860 -7985 1860 -7960 {}
L 4 1860 -8020 1860 -7995 {}
L 4 1850 -7995 1870 -7995 {}
L 4 1850 -7985 1870 -7985 {}
L 4 1862.5 -8012.5 1867.5 -8012.5 {}
L 4 1865 -8015 1865 -8010 {}
L 4 1532.5 -7952.5 1537.5 -7952.5 {}
L 4 1535 -7955 1535 -7950 {}
L 4 1530 -7960 1530 -7900 {}
L 4 1640 -7880 1640 -7867.5 {}
L 4 1635 -7867.5 1645 -7867.5 {}
L 4 1640 -7862.5 1645 -7867.5 {}
L 4 1635 -7867.5 1640 -7862.5 {}
L 4 1640 -8160 1640 -8140 {}
L 4 1630 -8160 1650 -8160 {}
L 4 1680 -9180 1680 -9167.5 {}
L 4 1675 -9167.5 1685 -9167.5 {}
L 4 1680 -9162.5 1685 -9167.5 {}
L 4 1675 -9167.5 1680 -9162.5 {}
L 4 1680 -9460 1680 -9440 {}
L 4 1670 -9460 1690 -9460 {}
L 4 502.5 -9252.5 507.5 -9252.5 {}
L 4 505 -9255 505 -9250 {}
L 4 500 -9260 500 -9200 {}
L 4 610 -9180 610 -9167.5 {}
L 4 605 -9167.5 615 -9167.5 {}
L 4 610 -9162.5 615 -9167.5 {}
L 4 605 -9167.5 610 -9162.5 {}
L 4 610 -9460 610 -9440 {}
L 4 600 -9460 620 -9460 {}
L 4 2140 -9180 2140 -9167.5 {}
L 4 2135 -9167.5 2145 -9167.5 {}
L 4 2140 -9162.5 2145 -9167.5 {}
L 4 2135 -9167.5 2140 -9162.5 {}
L 4 2140 -9460 2140 -9440 {}
L 4 2130 -9460 2150 -9460 {}
L 4 2360 -9285 2360 -9260 {}
L 4 2360 -9320 2360 -9295 {}
L 4 2350 -9295 2370 -9295 {}
L 4 2350 -9285 2370 -9285 {}
L 4 2362.5 -9312.5 2367.5 -9312.5 {}
L 4 2365 -9315 2365 -9310 {}
L 4 745 -5350 745 -5290 {}
L 4 745 -5340 760 -5340 {}
L 4 760 -5350 760 -5340 {}
L 4 745 -5300 760 -5300 {}
L 4 760 -5300 760 -5290 {}
L 4 735 -5335 735 -5305 {}
L 4 735 -5320 735 -5315 {}
L 4 720 -5320 727.5 -5320 {}
L 4 720 -5320 735 -5320 {}
L 4 750 -5320 760 -5320 {}
L 4 745 -5325 750 -5320 {}
L 4 745 -5315 750 -5320 {}
L 4 760 -5390 760 -5380 {}
L 4 760 -5390 767.5 -5392.5 {}
L 4 752.5 -5397.5 767.5 -5392.5 {}
L 4 752.5 -5397.5 767.5 -5402.5 {}
L 4 752.5 -5407.5 767.5 -5402.5 {}
L 4 752.5 -5407.5 767.5 -5412.5 {}
L 4 752.5 -5417.5 767.5 -5412.5 {}
L 4 752.5 -5417.5 767.5 -5422.5 {}
L 4 752.5 -5427.5 767.5 -5422.5 {}
L 4 752.5 -5427.5 760 -5430 {}
L 4 760 -5440 760 -5430 {}
L 4 762.5 -5432.5 767.5 -5432.5 {}
L 4 765 -5435 765 -5430 {}
L 4 850 -5315 850 -5290 {}
L 4 850 -5350 850 -5325 {}
L 4 840 -5325 860 -5325 {}
L 4 840 -5315 860 -5315 {}
L 4 852.5 -5342.5 857.5 -5342.5 {}
L 4 855 -5345 855 -5340 {}
L 4 522.5 -5282.5 527.5 -5282.5 {}
L 4 525 -5285 525 -5280 {}
L 4 520 -5290 520 -5230 {}
L 4 630 -5210 630 -5197.5 {}
L 4 625 -5197.5 635 -5197.5 {}
L 4 630 -5192.5 635 -5197.5 {}
L 4 625 -5197.5 630 -5192.5 {}
L 4 630 -5490 630 -5470 {}
L 4 620 -5490 640 -5490 {}
L 4 1285 -5350 1285 -5290 {}
L 4 1285 -5340 1300 -5340 {}
L 4 1300 -5350 1300 -5340 {}
L 4 1285 -5300 1300 -5300 {}
L 4 1300 -5300 1300 -5290 {}
L 4 1275 -5335 1275 -5305 {}
L 4 1275 -5320 1275 -5315 {}
L 4 1260 -5320 1267.5 -5320 {}
L 4 1260 -5320 1275 -5320 {}
L 4 1290 -5320 1300 -5320 {}
L 4 1285 -5325 1290 -5320 {}
L 4 1285 -5315 1290 -5320 {}
L 4 1300 -5390 1300 -5380 {}
L 4 1300 -5390 1307.5 -5392.5 {}
L 4 1292.5 -5397.5 1307.5 -5392.5 {}
L 4 1292.5 -5397.5 1307.5 -5402.5 {}
L 4 1292.5 -5407.5 1307.5 -5402.5 {}
L 4 1292.5 -5407.5 1307.5 -5412.5 {}
L 4 1292.5 -5417.5 1307.5 -5412.5 {}
L 4 1292.5 -5417.5 1307.5 -5422.5 {}
L 4 1292.5 -5427.5 1307.5 -5422.5 {}
L 4 1292.5 -5427.5 1300 -5430 {}
L 4 1300 -5440 1300 -5430 {}
L 4 1302.5 -5432.5 1307.5 -5432.5 {}
L 4 1305 -5435 1305 -5430 {}
L 4 1390 -5315 1390 -5290 {}
L 4 1390 -5350 1390 -5325 {}
L 4 1380 -5325 1400 -5325 {}
L 4 1380 -5315 1400 -5315 {}
L 4 1392.5 -5342.5 1397.5 -5342.5 {}
L 4 1395 -5345 1395 -5340 {}
L 4 1062.5 -5282.5 1067.5 -5282.5 {}
L 4 1065 -5285 1065 -5280 {}
L 4 1060 -5290 1060 -5230 {}
L 4 1170 -5210 1170 -5197.5 {}
L 4 1165 -5197.5 1175 -5197.5 {}
L 4 1170 -5192.5 1175 -5197.5 {}
L 4 1165 -5197.5 1170 -5192.5 {}
L 4 1170 -5490 1170 -5470 {}
L 4 1160 -5490 1180 -5490 {}
L 4 1845 -5350 1845 -5290 {}
L 4 1845 -5340 1860 -5340 {}
L 4 1860 -5350 1860 -5340 {}
L 4 1845 -5300 1860 -5300 {}
L 4 1860 -5300 1860 -5290 {}
L 4 1835 -5335 1835 -5305 {}
L 4 1835 -5320 1835 -5315 {}
L 4 1820 -5320 1827.5 -5320 {}
L 4 1820 -5320 1835 -5320 {}
L 4 1850 -5320 1860 -5320 {}
L 4 1845 -5325 1850 -5320 {}
L 4 1845 -5315 1850 -5320 {}
L 4 1860 -5390 1860 -5380 {}
L 4 1860 -5390 1867.5 -5392.5 {}
L 4 1852.5 -5397.5 1867.5 -5392.5 {}
L 4 1852.5 -5397.5 1867.5 -5402.5 {}
L 4 1852.5 -5407.5 1867.5 -5402.5 {}
L 4 1852.5 -5407.5 1867.5 -5412.5 {}
L 4 1852.5 -5417.5 1867.5 -5412.5 {}
L 4 1852.5 -5417.5 1867.5 -5422.5 {}
L 4 1852.5 -5427.5 1867.5 -5422.5 {}
L 4 1852.5 -5427.5 1860 -5430 {}
L 4 1860 -5440 1860 -5430 {}
L 4 1862.5 -5432.5 1867.5 -5432.5 {}
L 4 1865 -5435 1865 -5430 {}
L 4 1950 -5315 1950 -5290 {}
L 4 1950 -5350 1950 -5325 {}
L 4 1940 -5325 1960 -5325 {}
L 4 1940 -5315 1960 -5315 {}
L 4 1952.5 -5342.5 1957.5 -5342.5 {}
L 4 1955 -5345 1955 -5340 {}
L 4 1622.5 -5282.5 1627.5 -5282.5 {}
L 4 1625 -5285 1625 -5280 {}
L 4 1620 -5290 1620 -5230 {}
L 4 1730 -5210 1730 -5197.5 {}
L 4 1725 -5197.5 1735 -5197.5 {}
L 4 1730 -5192.5 1735 -5197.5 {}
L 4 1725 -5197.5 1730 -5192.5 {}
L 4 1730 -5490 1730 -5470 {}
L 4 1720 -5490 1740 -5490 {}
L 4 2415 -5350 2415 -5290 {}
L 4 2415 -5340 2430 -5340 {}
L 4 2430 -5350 2430 -5340 {}
L 4 2415 -5300 2430 -5300 {}
L 4 2430 -5300 2430 -5290 {}
L 4 2405 -5335 2405 -5305 {}
L 4 2405 -5320 2405 -5315 {}
L 4 2390 -5320 2397.5 -5320 {}
L 4 2390 -5320 2405 -5320 {}
L 4 2420 -5320 2430 -5320 {}
L 4 2415 -5325 2420 -5320 {}
L 4 2415 -5315 2420 -5320 {}
L 4 2430 -5390 2430 -5380 {}
L 4 2430 -5390 2437.5 -5392.5 {}
L 4 2422.5 -5397.5 2437.5 -5392.5 {}
L 4 2422.5 -5397.5 2437.5 -5402.5 {}
L 4 2422.5 -5407.5 2437.5 -5402.5 {}
L 4 2422.5 -5407.5 2437.5 -5412.5 {}
L 4 2422.5 -5417.5 2437.5 -5412.5 {}
L 4 2422.5 -5417.5 2437.5 -5422.5 {}
L 4 2422.5 -5427.5 2437.5 -5422.5 {}
L 4 2422.5 -5427.5 2430 -5430 {}
L 4 2430 -5440 2430 -5430 {}
L 4 2432.5 -5432.5 2437.5 -5432.5 {}
L 4 2435 -5435 2435 -5430 {}
L 4 2520 -5315 2520 -5290 {}
L 4 2520 -5350 2520 -5325 {}
L 4 2510 -5325 2530 -5325 {}
L 4 2510 -5315 2530 -5315 {}
L 4 2522.5 -5342.5 2527.5 -5342.5 {}
L 4 2525 -5345 2525 -5340 {}
L 4 2192.5 -5282.5 2197.5 -5282.5 {}
L 4 2195 -5285 2195 -5280 {}
L 4 2190 -5290 2190 -5230 {}
L 4 2300 -5210 2300 -5197.5 {}
L 4 2295 -5197.5 2305 -5197.5 {}
L 4 2300 -5192.5 2305 -5197.5 {}
L 4 2295 -5197.5 2300 -5192.5 {}
L 4 2300 -5490 2300 -5470 {}
L 4 2290 -5490 2310 -5490 {}
L 4 745 -7180 745 -7120 {}
L 4 745 -7170 760 -7170 {}
L 4 760 -7180 760 -7170 {}
L 4 745 -7130 760 -7130 {}
L 4 760 -7130 760 -7120 {}
L 4 735 -7165 735 -7135 {}
L 4 735 -7150 735 -7145 {}
L 4 720 -7150 727.5 -7150 {}
L 4 720 -7150 735 -7150 {}
L 4 750 -7150 760 -7150 {}
L 4 745 -7155 750 -7150 {}
L 4 745 -7145 750 -7150 {}
L 4 760 -7220 760 -7210 {}
L 4 760 -7220 767.5 -7222.5 {}
L 4 752.5 -7227.5 767.5 -7222.5 {}
L 4 752.5 -7227.5 767.5 -7232.5 {}
L 4 752.5 -7237.5 767.5 -7232.5 {}
L 4 752.5 -7237.5 767.5 -7242.5 {}
L 4 752.5 -7247.5 767.5 -7242.5 {}
L 4 752.5 -7247.5 767.5 -7252.5 {}
L 4 752.5 -7257.5 767.5 -7252.5 {}
L 4 752.5 -7257.5 760 -7260 {}
L 4 760 -7270 760 -7260 {}
L 4 762.5 -7262.5 767.5 -7262.5 {}
L 4 765 -7265 765 -7260 {}
L 4 850 -7145 850 -7120 {}
L 4 850 -7180 850 -7155 {}
L 4 840 -7155 860 -7155 {}
L 4 840 -7145 860 -7145 {}
L 4 852.5 -7172.5 857.5 -7172.5 {}
L 4 855 -7175 855 -7170 {}
L 4 522.5 -7112.5 527.5 -7112.5 {}
L 4 525 -7115 525 -7110 {}
L 4 520 -7120 520 -7060 {}
L 4 630 -7040 630 -7027.5 {}
L 4 625 -7027.5 635 -7027.5 {}
L 4 630 -7022.5 635 -7027.5 {}
L 4 625 -7027.5 630 -7022.5 {}
L 4 630 -7320 630 -7300 {}
L 4 620 -7320 640 -7320 {}
L 4 1285 -7180 1285 -7120 {}
L 4 1285 -7170 1300 -7170 {}
L 4 1300 -7180 1300 -7170 {}
L 4 1285 -7130 1300 -7130 {}
L 4 1300 -7130 1300 -7120 {}
L 4 1275 -7165 1275 -7135 {}
L 4 1275 -7150 1275 -7145 {}
L 4 1260 -7150 1267.5 -7150 {}
L 4 1260 -7150 1275 -7150 {}
L 4 1290 -7150 1300 -7150 {}
L 4 1285 -7155 1290 -7150 {}
L 4 1285 -7145 1290 -7150 {}
L 4 1300 -7220 1300 -7210 {}
L 4 1300 -7220 1307.5 -7222.5 {}
L 4 1292.5 -7227.5 1307.5 -7222.5 {}
L 4 1292.5 -7227.5 1307.5 -7232.5 {}
L 4 1292.5 -7237.5 1307.5 -7232.5 {}
L 4 1292.5 -7237.5 1307.5 -7242.5 {}
L 4 1292.5 -7247.5 1307.5 -7242.5 {}
L 4 1292.5 -7247.5 1307.5 -7252.5 {}
L 4 1292.5 -7257.5 1307.5 -7252.5 {}
L 4 1292.5 -7257.5 1300 -7260 {}
L 4 1300 -7270 1300 -7260 {}
L 4 1302.5 -7262.5 1307.5 -7262.5 {}
L 4 1305 -7265 1305 -7260 {}
L 4 1390 -7145 1390 -7120 {}
L 4 1390 -7180 1390 -7155 {}
L 4 1380 -7155 1400 -7155 {}
L 4 1380 -7145 1400 -7145 {}
L 4 1392.5 -7172.5 1397.5 -7172.5 {}
L 4 1395 -7175 1395 -7170 {}
L 4 1062.5 -7112.5 1067.5 -7112.5 {}
L 4 1065 -7115 1065 -7110 {}
L 4 1060 -7120 1060 -7060 {}
L 4 1170 -7040 1170 -7027.5 {}
L 4 1165 -7027.5 1175 -7027.5 {}
L 4 1170 -7022.5 1175 -7027.5 {}
L 4 1165 -7027.5 1170 -7022.5 {}
L 4 1170 -7320 1170 -7300 {}
L 4 1160 -7320 1180 -7320 {}
L 4 2415 -7180 2415 -7120 {}
L 4 2415 -7170 2430 -7170 {}
L 4 2430 -7180 2430 -7170 {}
L 4 2415 -7130 2430 -7130 {}
L 4 2430 -7130 2430 -7120 {}
L 4 2405 -7165 2405 -7135 {}
L 4 2405 -7150 2405 -7145 {}
L 4 2390 -7150 2397.5 -7150 {}
L 4 2390 -7150 2405 -7150 {}
L 4 2420 -7150 2430 -7150 {}
L 4 2415 -7155 2420 -7150 {}
L 4 2415 -7145 2420 -7150 {}
L 4 2430 -7220 2430 -7210 {}
L 4 2430 -7220 2437.5 -7222.5 {}
L 4 2422.5 -7227.5 2437.5 -7222.5 {}
L 4 2422.5 -7227.5 2437.5 -7232.5 {}
L 4 2422.5 -7237.5 2437.5 -7232.5 {}
L 4 2422.5 -7237.5 2437.5 -7242.5 {}
L 4 2422.5 -7247.5 2437.5 -7242.5 {}
L 4 2422.5 -7247.5 2437.5 -7252.5 {}
L 4 2422.5 -7257.5 2437.5 -7252.5 {}
L 4 2422.5 -7257.5 2430 -7260 {}
L 4 2430 -7270 2430 -7260 {}
L 4 2432.5 -7262.5 2437.5 -7262.5 {}
L 4 2435 -7265 2435 -7260 {}
L 4 2520 -7145 2520 -7120 {}
L 4 2520 -7180 2520 -7155 {}
L 4 2510 -7155 2530 -7155 {}
L 4 2510 -7145 2530 -7145 {}
L 4 2522.5 -7172.5 2527.5 -7172.5 {}
L 4 2525 -7175 2525 -7170 {}
L 4 2192.5 -7112.5 2197.5 -7112.5 {}
L 4 2195 -7115 2195 -7110 {}
L 4 2190 -7120 2190 -7060 {}
L 4 2300 -7040 2300 -7027.5 {}
L 4 2295 -7027.5 2305 -7027.5 {}
L 4 2300 -7022.5 2305 -7027.5 {}
L 4 2295 -7027.5 2300 -7022.5 {}
L 4 2300 -7320 2300 -7300 {}
L 4 2290 -7320 2310 -7320 {}
L 4 745 -4970 745 -4910 {}
L 4 745 -4960 760 -4960 {}
L 4 760 -4970 760 -4960 {}
L 4 745 -4920 760 -4920 {}
L 4 760 -4920 760 -4910 {}
L 4 735 -4955 735 -4925 {}
L 4 735 -4940 735 -4935 {}
L 4 720 -4940 727.5 -4940 {}
L 4 720 -4940 735 -4940 {}
L 4 750 -4940 760 -4940 {}
L 4 745 -4945 750 -4940 {}
L 4 745 -4935 750 -4940 {}
L 4 760 -5010 760 -5000 {}
L 4 760 -5010 767.5 -5012.5 {}
L 4 752.5 -5017.5 767.5 -5012.5 {}
L 4 752.5 -5017.5 767.5 -5022.5 {}
L 4 752.5 -5027.5 767.5 -5022.5 {}
L 4 752.5 -5027.5 767.5 -5032.5 {}
L 4 752.5 -5037.5 767.5 -5032.5 {}
L 4 752.5 -5037.5 767.5 -5042.5 {}
L 4 752.5 -5047.5 767.5 -5042.5 {}
L 4 752.5 -5047.5 760 -5050 {}
L 4 760 -5060 760 -5050 {}
L 4 762.5 -5052.5 767.5 -5052.5 {}
L 4 765 -5055 765 -5050 {}
L 4 850 -4935 850 -4910 {}
L 4 850 -4970 850 -4945 {}
L 4 840 -4945 860 -4945 {}
L 4 840 -4935 860 -4935 {}
L 4 852.5 -4962.5 857.5 -4962.5 {}
L 4 855 -4965 855 -4960 {}
L 4 522.5 -4902.5 527.5 -4902.5 {}
L 4 525 -4905 525 -4900 {}
L 4 520 -4910 520 -4850 {}
L 4 630 -4830 630 -4817.5 {}
L 4 625 -4817.5 635 -4817.5 {}
L 4 630 -4812.5 635 -4817.5 {}
L 4 625 -4817.5 630 -4812.5 {}
L 4 630 -5110 630 -5090 {}
L 4 620 -5110 640 -5110 {}
L 4 1285 -4590 1285 -4530 {}
L 4 1285 -4580 1300 -4580 {}
L 4 1300 -4590 1300 -4580 {}
L 4 1285 -4540 1300 -4540 {}
L 4 1300 -4540 1300 -4530 {}
L 4 1275 -4575 1275 -4545 {}
L 4 1275 -4560 1275 -4555 {}
L 4 1260 -4560 1267.5 -4560 {}
L 4 1260 -4560 1275 -4560 {}
L 4 1290 -4560 1300 -4560 {}
L 4 1285 -4565 1290 -4560 {}
L 4 1285 -4555 1290 -4560 {}
L 4 1390 -4555 1390 -4530 {}
L 4 1390 -4590 1390 -4565 {}
L 4 1380 -4565 1400 -4565 {}
L 4 1380 -4555 1400 -4555 {}
L 4 1392.5 -4582.5 1397.5 -4582.5 {}
L 4 1395 -4585 1395 -4580 {}
L 4 1062.5 -4522.5 1067.5 -4522.5 {}
L 4 1065 -4525 1065 -4520 {}
L 4 1060 -4530 1060 -4470 {}
L 4 1170 -4450 1170 -4437.5 {}
L 4 1165 -4437.5 1175 -4437.5 {}
L 4 1170 -4432.5 1175 -4437.5 {}
L 4 1165 -4437.5 1170 -4432.5 {}
L 4 2385 -4590 2385 -4530 {}
L 4 2385 -4580 2400 -4580 {}
L 4 2400 -4590 2400 -4580 {}
L 4 2385 -4540 2400 -4540 {}
L 4 2400 -4540 2400 -4530 {}
L 4 2375 -4575 2375 -4545 {}
L 4 2375 -4560 2375 -4555 {}
L 4 2360 -4560 2367.5 -4560 {}
L 4 2360 -4560 2375 -4560 {}
L 4 2390 -4560 2400 -4560 {}
L 4 2385 -4565 2390 -4560 {}
L 4 2385 -4555 2390 -4560 {}
L 4 2490 -4555 2490 -4530 {}
L 4 2490 -4590 2490 -4565 {}
L 4 2480 -4565 2500 -4565 {}
L 4 2480 -4555 2500 -4555 {}
L 4 2492.5 -4582.5 2497.5 -4582.5 {}
L 4 2495 -4585 2495 -4580 {}
L 4 2162.5 -4522.5 2167.5 -4522.5 {}
L 4 2165 -4525 2165 -4520 {}
L 4 2160 -4530 2160 -4470 {}
L 4 2270 -4450 2270 -4437.5 {}
L 4 2265 -4437.5 2275 -4437.5 {}
L 4 2270 -4432.5 2275 -4437.5 {}
L 4 2265 -4437.5 2270 -4432.5 {}
L 4 1825 -4590 1825 -4530 {}
L 4 1825 -4580 1840 -4580 {}
L 4 1840 -4590 1840 -4580 {}
L 4 1825 -4540 1840 -4540 {}
L 4 1840 -4540 1840 -4530 {}
L 4 1815 -4575 1815 -4545 {}
L 4 1815 -4560 1815 -4555 {}
L 4 1800 -4560 1807.5 -4560 {}
L 4 1800 -4560 1815 -4560 {}
L 4 1830 -4560 1840 -4560 {}
L 4 1825 -4565 1830 -4560 {}
L 4 1825 -4555 1830 -4560 {}
L 4 1930 -4555 1930 -4530 {}
L 4 1930 -4590 1930 -4565 {}
L 4 1920 -4565 1940 -4565 {}
L 4 1920 -4555 1940 -4555 {}
L 4 1932.5 -4582.5 1937.5 -4582.5 {}
L 4 1935 -4585 1935 -4580 {}
L 4 1602.5 -4522.5 1607.5 -4522.5 {}
L 4 1605 -4525 1605 -4520 {}
L 4 1600 -4530 1600 -4470 {}
L 4 1710 -4450 1710 -4437.5 {}
L 4 1705 -4437.5 1715 -4437.5 {}
L 4 1710 -4432.5 1715 -4437.5 {}
L 4 1705 -4437.5 1710 -4432.5 {}
L 4 820 -3770 820 -3760 {}
L 4 820 -3770 827.5 -3772.5 {}
L 4 812.5 -3777.5 827.5 -3772.5 {}
L 4 812.5 -3777.5 827.5 -3782.5 {}
L 4 812.5 -3787.5 827.5 -3782.5 {}
L 4 812.5 -3787.5 827.5 -3792.5 {}
L 4 812.5 -3797.5 827.5 -3792.5 {}
L 4 812.5 -3797.5 827.5 -3802.5 {}
L 4 812.5 -3807.5 827.5 -3802.5 {}
L 4 812.5 -3807.5 820 -3810 {}
L 4 820 -3820 820 -3810 {}
L 4 822.5 -3812.5 827.5 -3812.5 {}
L 4 825 -3815 825 -3810 {}
L 4 820 -3710 820 -3700 {}
L 4 820 -3710 827.5 -3712.5 {}
L 4 812.5 -3717.5 827.5 -3712.5 {}
L 4 812.5 -3717.5 827.5 -3722.5 {}
L 4 812.5 -3727.5 827.5 -3722.5 {}
L 4 812.5 -3727.5 827.5 -3732.5 {}
L 4 812.5 -3737.5 827.5 -3732.5 {}
L 4 812.5 -3737.5 827.5 -3742.5 {}
L 4 812.5 -3747.5 827.5 -3742.5 {}
L 4 812.5 -3747.5 820 -3750 {}
L 4 820 -3760 820 -3750 {}
L 4 822.5 -3752.5 827.5 -3752.5 {}
L 4 825 -3755 825 -3750 {}
L 4 1360 -3710 1360 -3700 {}
L 4 1360 -3710 1367.5 -3712.5 {}
L 4 1352.5 -3717.5 1367.5 -3712.5 {}
L 4 1352.5 -3717.5 1367.5 -3722.5 {}
L 4 1352.5 -3727.5 1367.5 -3722.5 {}
L 4 1352.5 -3727.5 1367.5 -3732.5 {}
L 4 1352.5 -3737.5 1367.5 -3732.5 {}
L 4 1352.5 -3737.5 1367.5 -3742.5 {}
L 4 1352.5 -3747.5 1367.5 -3742.5 {}
L 4 1352.5 -3747.5 1360 -3750 {}
L 4 1360 -3760 1360 -3750 {}
L 4 1362.5 -3752.5 1367.5 -3752.5 {}
L 4 1365 -3755 1365 -3750 {}
L 4 1900 -3810 1900 -3800 {}
L 4 1900 -3810 1907.5 -3812.5 {}
L 4 1892.5 -3817.5 1907.5 -3812.5 {}
L 4 1892.5 -3817.5 1907.5 -3822.5 {}
L 4 1892.5 -3827.5 1907.5 -3822.5 {}
L 4 1892.5 -3827.5 1907.5 -3832.5 {}
L 4 1892.5 -3837.5 1907.5 -3832.5 {}
L 4 1892.5 -3837.5 1907.5 -3842.5 {}
L 4 1892.5 -3847.5 1907.5 -3842.5 {}
L 4 1892.5 -3847.5 1900 -3850 {}
L 4 1900 -3860 1900 -3850 {}
L 4 1902.5 -3852.5 1907.5 -3852.5 {}
L 4 1905 -3855 1905 -3850 {}
L 4 1900 -3710 1900 -3700 {}
L 4 1900 -3710 1907.5 -3712.5 {}
L 4 1892.5 -3717.5 1907.5 -3712.5 {}
L 4 1892.5 -3717.5 1907.5 -3722.5 {}
L 4 1892.5 -3727.5 1907.5 -3722.5 {}
L 4 1892.5 -3727.5 1907.5 -3732.5 {}
L 4 1892.5 -3737.5 1907.5 -3732.5 {}
L 4 1892.5 -3737.5 1907.5 -3742.5 {}
L 4 1892.5 -3747.5 1907.5 -3742.5 {}
L 4 1892.5 -3747.5 1900 -3750 {}
L 4 1900 -3760 1900 -3750 {}
L 4 1902.5 -3752.5 1907.5 -3752.5 {}
L 4 1905 -3755 1905 -3750 {}
L 4 820 -4090 820 -4080 {}
L 4 820 -4090 827.5 -4092.5 {}
L 4 812.5 -4097.5 827.5 -4092.5 {}
L 4 812.5 -4097.5 827.5 -4102.5 {}
L 4 812.5 -4107.5 827.5 -4102.5 {}
L 4 812.5 -4107.5 827.5 -4112.5 {}
L 4 812.5 -4117.5 827.5 -4112.5 {}
L 4 812.5 -4117.5 827.5 -4122.5 {}
L 4 812.5 -4127.5 827.5 -4122.5 {}
L 4 812.5 -4127.5 820 -4130 {}
L 4 820 -4140 820 -4130 {}
L 4 822.5 -4132.5 827.5 -4132.5 {}
L 4 825 -4135 825 -4130 {}
L 4 820 -4150 820 -4140 {}
L 4 820 -4150 827.5 -4152.5 {}
L 4 812.5 -4157.5 827.5 -4152.5 {}
L 4 812.5 -4157.5 827.5 -4162.5 {}
L 4 812.5 -4167.5 827.5 -4162.5 {}
L 4 812.5 -4167.5 827.5 -4172.5 {}
L 4 812.5 -4177.5 827.5 -4172.5 {}
L 4 812.5 -4177.5 827.5 -4182.5 {}
L 4 812.5 -4187.5 827.5 -4182.5 {}
L 4 812.5 -4187.5 820 -4190 {}
L 4 820 -4200 820 -4190 {}
L 4 822.5 -4192.5 827.5 -4192.5 {}
L 4 825 -4195 825 -4190 {}
L 4 820 -4210 820 -4200 {}
L 4 820 -4210 827.5 -4212.5 {}
L 4 812.5 -4217.5 827.5 -4212.5 {}
L 4 812.5 -4217.5 827.5 -4222.5 {}
L 4 812.5 -4227.5 827.5 -4222.5 {}
L 4 812.5 -4227.5 827.5 -4232.5 {}
L 4 812.5 -4237.5 827.5 -4232.5 {}
L 4 812.5 -4237.5 827.5 -4242.5 {}
L 4 812.5 -4247.5 827.5 -4242.5 {}
L 4 812.5 -4247.5 820 -4250 {}
L 4 820 -4260 820 -4250 {}
L 4 822.5 -4252.5 827.5 -4252.5 {}
L 4 825 -4255 825 -4250 {}
L 4 1360 -4090 1360 -4080 {}
L 4 1360 -4090 1367.5 -4092.5 {}
L 4 1352.5 -4097.5 1367.5 -4092.5 {}
L 4 1352.5 -4097.5 1367.5 -4102.5 {}
L 4 1352.5 -4107.5 1367.5 -4102.5 {}
L 4 1352.5 -4107.5 1367.5 -4112.5 {}
L 4 1352.5 -4117.5 1367.5 -4112.5 {}
L 4 1352.5 -4117.5 1367.5 -4122.5 {}
L 4 1352.5 -4127.5 1367.5 -4122.5 {}
L 4 1352.5 -4127.5 1360 -4130 {}
L 4 1360 -4140 1360 -4130 {}
L 4 1362.5 -4132.5 1367.5 -4132.5 {}
L 4 1365 -4135 1365 -4130 {}
L 4 1360 -4210 1367.5 -4212.5 {}
L 4 1352.5 -4217.5 1367.5 -4212.5 {}
L 4 1352.5 -4217.5 1367.5 -4222.5 {}
L 4 1352.5 -4227.5 1367.5 -4222.5 {}
L 4 1352.5 -4227.5 1367.5 -4232.5 {}
L 4 1352.5 -4237.5 1367.5 -4232.5 {}
L 4 1352.5 -4237.5 1367.5 -4242.5 {}
L 4 1352.5 -4247.5 1367.5 -4242.5 {}
L 4 1352.5 -4247.5 1360 -4250 {}
L 4 1360 -4260 1360 -4250 {}
L 4 1362.5 -4252.5 1367.5 -4252.5 {}
L 4 1365 -4255 1365 -4250 {}
L 4 1900 -4090 1900 -4080 {}
L 4 1900 -4090 1907.5 -4092.5 {}
L 4 1892.5 -4097.5 1907.5 -4092.5 {}
L 4 1892.5 -4097.5 1907.5 -4102.5 {}
L 4 1892.5 -4107.5 1907.5 -4102.5 {}
L 4 1892.5 -4107.5 1907.5 -4112.5 {}
L 4 1892.5 -4117.5 1907.5 -4112.5 {}
L 4 1892.5 -4117.5 1907.5 -4122.5 {}
L 4 1892.5 -4127.5 1907.5 -4122.5 {}
L 4 1892.5 -4127.5 1900 -4130 {}
L 4 1900 -4140 1900 -4130 {}
L 4 1902.5 -4132.5 1907.5 -4132.5 {}
L 4 1905 -4135 1905 -4130 {}
L 4 1900 -4210 1900 -4200 {}
L 4 1900 -4210 1907.5 -4212.5 {}
L 4 1892.5 -4217.5 1907.5 -4212.5 {}
L 4 1892.5 -4217.5 1907.5 -4222.5 {}
L 4 1892.5 -4227.5 1907.5 -4222.5 {}
L 4 1892.5 -4227.5 1907.5 -4232.5 {}
L 4 1892.5 -4237.5 1907.5 -4232.5 {}
L 4 1892.5 -4237.5 1907.5 -4242.5 {}
L 4 1892.5 -4247.5 1907.5 -4242.5 {}
L 4 1892.5 -4247.5 1900 -4250 {}
L 4 1900 -4260 1900 -4250 {}
L 4 1902.5 -4252.5 1907.5 -4252.5 {}
L 4 1905 -4255 1905 -4250 {}
L 4 710 -2940 710 -2930 {}
L 4 710 -2940 717.5 -2942.5 {}
L 4 702.5 -2947.5 717.5 -2942.5 {}
L 4 702.5 -2947.5 717.5 -2952.5 {}
L 4 702.5 -2957.5 717.5 -2952.5 {}
L 4 702.5 -2957.5 717.5 -2962.5 {}
L 4 702.5 -2967.5 717.5 -2962.5 {}
L 4 702.5 -2967.5 717.5 -2972.5 {}
L 4 702.5 -2977.5 717.5 -2972.5 {}
L 4 702.5 -2977.5 710 -2980 {}
L 4 710 -2990 710 -2980 {}
L 4 712.5 -2982.5 717.5 -2982.5 {}
L 4 715 -2985 715 -2980 {}
L 4 820 -2940 820 -2930 {}
L 4 820 -2940 827.5 -2942.5 {}
L 4 812.5 -2947.5 827.5 -2942.5 {}
L 4 812.5 -2947.5 827.5 -2952.5 {}
L 4 812.5 -2957.5 827.5 -2952.5 {}
L 4 812.5 -2957.5 827.5 -2962.5 {}
L 4 812.5 -2967.5 827.5 -2962.5 {}
L 4 812.5 -2967.5 827.5 -2972.5 {}
L 4 812.5 -2977.5 827.5 -2972.5 {}
L 4 812.5 -2977.5 820 -2980 {}
L 4 820 -2990 820 -2980 {}
L 4 822.5 -2982.5 827.5 -2982.5 {}
L 4 825 -2985 825 -2980 {}
L 4 930 -2940 930 -2930 {}
L 4 930 -2940 937.5 -2942.5 {}
L 4 922.5 -2947.5 937.5 -2942.5 {}
L 4 922.5 -2947.5 937.5 -2952.5 {}
L 4 922.5 -2957.5 937.5 -2952.5 {}
L 4 922.5 -2957.5 937.5 -2962.5 {}
L 4 922.5 -2967.5 937.5 -2962.5 {}
L 4 922.5 -2967.5 937.5 -2972.5 {}
L 4 922.5 -2977.5 937.5 -2972.5 {}
L 4 922.5 -2977.5 930 -2980 {}
L 4 930 -2990 930 -2980 {}
L 4 932.5 -2982.5 937.5 -2982.5 {}
L 4 935 -2985 935 -2980 {}
L 4 1250 -2940 1250 -2930 {}
L 4 1250 -2940 1257.5 -2942.5 {}
L 4 1242.5 -2947.5 1257.5 -2942.5 {}
L 4 1242.5 -2947.5 1257.5 -2952.5 {}
L 4 1242.5 -2957.5 1257.5 -2952.5 {}
L 4 1242.5 -2957.5 1257.5 -2962.5 {}
L 4 1242.5 -2967.5 1257.5 -2962.5 {}
L 4 1242.5 -2967.5 1257.5 -2972.5 {}
L 4 1242.5 -2977.5 1257.5 -2972.5 {}
L 4 1242.5 -2977.5 1250 -2980 {}
L 4 1250 -2990 1250 -2980 {}
L 4 1252.5 -2982.5 1257.5 -2982.5 {}
L 4 1255 -2985 1255 -2980 {}
L 4 1360 -2940 1360 -2930 {}
L 4 1360 -2940 1367.5 -2942.5 {}
L 4 1352.5 -2947.5 1367.5 -2942.5 {}
L 4 1352.5 -2947.5 1367.5 -2952.5 {}
L 4 1352.5 -2957.5 1367.5 -2952.5 {}
L 4 1352.5 -2957.5 1367.5 -2962.5 {}
L 4 1352.5 -2967.5 1367.5 -2962.5 {}
L 4 1352.5 -2967.5 1367.5 -2972.5 {}
L 4 1352.5 -2977.5 1367.5 -2972.5 {}
L 4 1352.5 -2977.5 1360 -2980 {}
L 4 1360 -2990 1360 -2980 {}
L 4 1362.5 -2982.5 1367.5 -2982.5 {}
L 4 1365 -2985 1365 -2980 {}
L 4 1470 -2940 1470 -2930 {}
L 4 1470 -2940 1477.5 -2942.5 {}
L 4 1462.5 -2947.5 1477.5 -2942.5 {}
L 4 1462.5 -2947.5 1477.5 -2952.5 {}
L 4 1462.5 -2957.5 1477.5 -2952.5 {}
L 4 1462.5 -2957.5 1477.5 -2962.5 {}
L 4 1462.5 -2967.5 1477.5 -2962.5 {}
L 4 1462.5 -2967.5 1477.5 -2972.5 {}
L 4 1462.5 -2977.5 1477.5 -2972.5 {}
L 4 1462.5 -2977.5 1470 -2980 {}
L 4 1470 -2990 1470 -2980 {}
L 4 1472.5 -2982.5 1477.5 -2982.5 {}
L 4 1475 -2985 1475 -2980 {}
L 4 1790 -2940 1790 -2930 {}
L 4 1790 -2940 1797.5 -2942.5 {}
L 4 1782.5 -2947.5 1797.5 -2942.5 {}
L 4 1782.5 -2947.5 1797.5 -2952.5 {}
L 4 1782.5 -2957.5 1797.5 -2952.5 {}
L 4 1782.5 -2957.5 1797.5 -2962.5 {}
L 4 1782.5 -2967.5 1797.5 -2962.5 {}
L 4 1782.5 -2967.5 1797.5 -2972.5 {}
L 4 1782.5 -2977.5 1797.5 -2972.5 {}
L 4 1782.5 -2977.5 1790 -2980 {}
L 4 1790 -2990 1790 -2980 {}
L 4 1792.5 -2982.5 1797.5 -2982.5 {}
L 4 1795 -2985 1795 -2980 {}
L 4 1900 -2940 1900 -2930 {}
L 4 1900 -2940 1907.5 -2942.5 {}
L 4 1892.5 -2947.5 1907.5 -2942.5 {}
L 4 1892.5 -2947.5 1907.5 -2952.5 {}
L 4 1892.5 -2957.5 1907.5 -2952.5 {}
L 4 1892.5 -2957.5 1907.5 -2962.5 {}
L 4 1892.5 -2967.5 1907.5 -2962.5 {}
L 4 1892.5 -2967.5 1907.5 -2972.5 {}
L 4 1892.5 -2977.5 1907.5 -2972.5 {}
L 4 1892.5 -2977.5 1900 -2980 {}
L 4 1900 -2990 1900 -2980 {}
L 4 1902.5 -2982.5 1907.5 -2982.5 {}
L 4 1905 -2985 1905 -2980 {}
L 4 2010 -2940 2010 -2930 {}
L 4 2010 -2940 2017.5 -2942.5 {}
L 4 2002.5 -2947.5 2017.5 -2942.5 {}
L 4 2002.5 -2947.5 2017.5 -2952.5 {}
L 4 2002.5 -2957.5 2017.5 -2952.5 {}
L 4 2002.5 -2957.5 2017.5 -2962.5 {}
L 4 2002.5 -2967.5 2017.5 -2962.5 {}
L 4 2002.5 -2967.5 2017.5 -2972.5 {}
L 4 2002.5 -2977.5 2017.5 -2972.5 {}
L 4 2002.5 -2977.5 2010 -2980 {}
L 4 2010 -2990 2010 -2980 {}
L 4 2012.5 -2982.5 2017.5 -2982.5 {}
L 4 2015 -2985 2015 -2980 {}
L 4 2320 -2940 2320 -2930 {}
L 4 2320 -2940 2327.5 -2942.5 {}
L 4 2312.5 -2947.5 2327.5 -2942.5 {}
L 4 2312.5 -2947.5 2327.5 -2952.5 {}
L 4 2312.5 -2957.5 2327.5 -2952.5 {}
L 4 2312.5 -2957.5 2327.5 -2962.5 {}
L 4 2312.5 -2967.5 2327.5 -2962.5 {}
L 4 2312.5 -2967.5 2327.5 -2972.5 {}
L 4 2312.5 -2977.5 2327.5 -2972.5 {}
L 4 2312.5 -2977.5 2320 -2980 {}
L 4 2320 -2990 2320 -2980 {}
L 4 2322.5 -2982.5 2327.5 -2982.5 {}
L 4 2325 -2985 2325 -2980 {}
L 4 2430 -2940 2430 -2930 {}
L 4 2430 -2940 2437.5 -2942.5 {}
L 4 2422.5 -2947.5 2437.5 -2942.5 {}
L 4 2422.5 -2947.5 2437.5 -2952.5 {}
L 4 2422.5 -2957.5 2437.5 -2952.5 {}
L 4 2422.5 -2957.5 2437.5 -2962.5 {}
L 4 2422.5 -2967.5 2437.5 -2962.5 {}
L 4 2422.5 -2967.5 2437.5 -2972.5 {}
L 4 2422.5 -2977.5 2437.5 -2972.5 {}
L 4 2422.5 -2977.5 2430 -2980 {}
L 4 2430 -2990 2430 -2980 {}
L 4 2432.5 -2982.5 2437.5 -2982.5 {}
L 4 2435 -2985 2435 -2980 {}
L 4 2540 -2940 2540 -2930 {}
L 4 2540 -2940 2547.5 -2942.5 {}
L 4 2532.5 -2947.5 2547.5 -2942.5 {}
L 4 2532.5 -2947.5 2547.5 -2952.5 {}
L 4 2532.5 -2957.5 2547.5 -2952.5 {}
L 4 2532.5 -2957.5 2547.5 -2962.5 {}
L 4 2532.5 -2967.5 2547.5 -2962.5 {}
L 4 2532.5 -2967.5 2547.5 -2972.5 {}
L 4 2532.5 -2977.5 2547.5 -2972.5 {}
L 4 2532.5 -2977.5 2540 -2980 {}
L 4 2540 -2990 2540 -2980 {}
L 4 2542.5 -2982.5 2547.5 -2982.5 {}
L 4 2545 -2985 2545 -2980 {}
L 4 2500 -4090 2500 -4080 {}
L 4 2500 -4090 2507.5 -4092.5 {}
L 4 2492.5 -4097.5 2507.5 -4092.5 {}
L 4 2492.5 -4097.5 2507.5 -4102.5 {}
L 4 2492.5 -4107.5 2507.5 -4102.5 {}
L 4 2492.5 -4107.5 2507.5 -4112.5 {}
L 4 2492.5 -4117.5 2507.5 -4112.5 {}
L 4 2492.5 -4117.5 2507.5 -4122.5 {}
L 4 2492.5 -4127.5 2507.5 -4122.5 {}
L 4 2492.5 -4127.5 2500 -4130 {}
L 4 2500 -4140 2500 -4130 {}
L 4 2502.5 -4132.5 2507.5 -4132.5 {}
L 4 2505 -4135 2505 -4130 {}
L 4 2500 -4210 2500 -4200 {}
L 4 2500 -4210 2507.5 -4212.5 {}
L 4 2492.5 -4217.5 2507.5 -4212.5 {}
L 4 2492.5 -4217.5 2507.5 -4222.5 {}
L 4 2492.5 -4227.5 2507.5 -4222.5 {}
L 4 2492.5 -4227.5 2507.5 -4232.5 {}
L 4 2492.5 -4237.5 2507.5 -4232.5 {}
L 4 2492.5 -4237.5 2507.5 -4242.5 {}
L 4 2492.5 -4247.5 2507.5 -4242.5 {}
L 4 2492.5 -4247.5 2500 -4250 {}
L 4 2500 -4260 2500 -4250 {}
L 4 2502.5 -4252.5 2507.5 -4252.5 {}
L 4 2505 -4255 2505 -4250 {}
L 4 710 -1010 710 -1000 {}
L 4 710 -1010 717.5 -1012.5 {}
L 4 702.5 -1017.5 717.5 -1012.5 {}
L 4 702.5 -1017.5 717.5 -1022.5 {}
L 4 702.5 -1027.5 717.5 -1022.5 {}
L 4 702.5 -1027.5 717.5 -1032.5 {}
L 4 702.5 -1037.5 717.5 -1032.5 {}
L 4 702.5 -1037.5 717.5 -1042.5 {}
L 4 702.5 -1047.5 717.5 -1042.5 {}
L 4 702.5 -1047.5 710 -1050 {}
L 4 710 -1060 710 -1050 {}
L 4 712.5 -1052.5 717.5 -1052.5 {}
L 4 715 -1055 715 -1050 {}
L 4 820 -1010 820 -1000 {}
L 4 820 -1010 827.5 -1012.5 {}
L 4 812.5 -1017.5 827.5 -1012.5 {}
L 4 812.5 -1017.5 827.5 -1022.5 {}
L 4 812.5 -1027.5 827.5 -1022.5 {}
L 4 812.5 -1027.5 827.5 -1032.5 {}
L 4 812.5 -1037.5 827.5 -1032.5 {}
L 4 812.5 -1037.5 827.5 -1042.5 {}
L 4 812.5 -1047.5 827.5 -1042.5 {}
L 4 812.5 -1047.5 820 -1050 {}
L 4 820 -1060 820 -1050 {}
L 4 822.5 -1052.5 827.5 -1052.5 {}
L 4 825 -1055 825 -1050 {}
L 4 930 -1010 930 -1000 {}
L 4 930 -1010 937.5 -1012.5 {}
L 4 922.5 -1017.5 937.5 -1012.5 {}
L 4 922.5 -1017.5 937.5 -1022.5 {}
L 4 922.5 -1027.5 937.5 -1022.5 {}
L 4 922.5 -1027.5 937.5 -1032.5 {}
L 4 922.5 -1037.5 937.5 -1032.5 {}
L 4 922.5 -1037.5 937.5 -1042.5 {}
L 4 922.5 -1047.5 937.5 -1042.5 {}
L 4 922.5 -1047.5 930 -1050 {}
L 4 930 -1060 930 -1050 {}
L 4 932.5 -1052.5 937.5 -1052.5 {}
L 4 935 -1055 935 -1050 {}
L 4 710 -920 710 -910 {}
L 4 710 -920 717.5 -922.5 {}
L 4 702.5 -927.5 717.5 -922.5 {}
L 4 702.5 -927.5 717.5 -932.5 {}
L 4 702.5 -937.5 717.5 -932.5 {}
L 4 702.5 -937.5 717.5 -942.5 {}
L 4 702.5 -947.5 717.5 -942.5 {}
L 4 702.5 -947.5 717.5 -952.5 {}
L 4 702.5 -957.5 717.5 -952.5 {}
L 4 702.5 -957.5 710 -960 {}
L 4 710 -970 710 -960 {}
L 4 712.5 -962.5 717.5 -962.5 {}
L 4 715 -965 715 -960 {}
L 4 820 -920 820 -910 {}
L 4 820 -920 827.5 -922.5 {}
L 4 812.5 -927.5 827.5 -922.5 {}
L 4 812.5 -927.5 827.5 -932.5 {}
L 4 812.5 -937.5 827.5 -932.5 {}
L 4 812.5 -937.5 827.5 -942.5 {}
L 4 812.5 -947.5 827.5 -942.5 {}
L 4 812.5 -947.5 827.5 -952.5 {}
L 4 812.5 -957.5 827.5 -952.5 {}
L 4 812.5 -957.5 820 -960 {}
L 4 820 -970 820 -960 {}
L 4 822.5 -962.5 827.5 -962.5 {}
L 4 825 -965 825 -960 {}
L 4 930 -920 930 -910 {}
L 4 930 -920 937.5 -922.5 {}
L 4 922.5 -927.5 937.5 -922.5 {}
L 4 922.5 -927.5 937.5 -932.5 {}
L 4 922.5 -937.5 937.5 -932.5 {}
L 4 922.5 -937.5 937.5 -942.5 {}
L 4 922.5 -947.5 937.5 -942.5 {}
L 4 922.5 -947.5 937.5 -952.5 {}
L 4 922.5 -957.5 937.5 -952.5 {}
L 4 922.5 -957.5 930 -960 {}
L 4 930 -970 930 -960 {}
L 4 932.5 -962.5 937.5 -962.5 {}
L 4 935 -965 935 -960 {}
L 4 1250 -920 1250 -910 {}
L 4 1250 -920 1257.5 -922.5 {}
L 4 1242.5 -927.5 1257.5 -922.5 {}
L 4 1242.5 -927.5 1257.5 -932.5 {}
L 4 1242.5 -937.5 1257.5 -932.5 {}
L 4 1242.5 -937.5 1257.5 -942.5 {}
L 4 1242.5 -947.5 1257.5 -942.5 {}
L 4 1242.5 -947.5 1257.5 -952.5 {}
L 4 1242.5 -957.5 1257.5 -952.5 {}
L 4 1242.5 -957.5 1250 -960 {}
L 4 1250 -970 1250 -960 {}
L 4 1252.5 -962.5 1257.5 -962.5 {}
L 4 1255 -965 1255 -960 {}
L 4 1360 -920 1360 -910 {}
L 4 1360 -920 1367.5 -922.5 {}
L 4 1352.5 -927.5 1367.5 -922.5 {}
L 4 1352.5 -927.5 1367.5 -932.5 {}
L 4 1352.5 -937.5 1367.5 -932.5 {}
L 4 1352.5 -937.5 1367.5 -942.5 {}
L 4 1352.5 -947.5 1367.5 -942.5 {}
L 4 1352.5 -947.5 1367.5 -952.5 {}
L 4 1352.5 -957.5 1367.5 -952.5 {}
L 4 1352.5 -957.5 1360 -960 {}
L 4 1360 -970 1360 -960 {}
L 4 1362.5 -962.5 1367.5 -962.5 {}
L 4 1365 -965 1365 -960 {}
L 4 1470 -920 1470 -910 {}
L 4 1470 -920 1477.5 -922.5 {}
L 4 1462.5 -927.5 1477.5 -922.5 {}
L 4 1462.5 -927.5 1477.5 -932.5 {}
L 4 1462.5 -937.5 1477.5 -932.5 {}
L 4 1462.5 -937.5 1477.5 -942.5 {}
L 4 1462.5 -947.5 1477.5 -942.5 {}
L 4 1462.5 -947.5 1477.5 -952.5 {}
L 4 1462.5 -957.5 1477.5 -952.5 {}
L 4 1462.5 -957.5 1470 -960 {}
L 4 1470 -970 1470 -960 {}
L 4 1472.5 -962.5 1477.5 -962.5 {}
L 4 1475 -965 1475 -960 {}
L 4 1790 -920 1790 -910 {}
L 4 1790 -920 1797.5 -922.5 {}
L 4 1782.5 -927.5 1797.5 -922.5 {}
L 4 1782.5 -927.5 1797.5 -932.5 {}
L 4 1782.5 -937.5 1797.5 -932.5 {}
L 4 1782.5 -937.5 1797.5 -942.5 {}
L 4 1782.5 -947.5 1797.5 -942.5 {}
L 4 1782.5 -947.5 1797.5 -952.5 {}
L 4 1782.5 -957.5 1797.5 -952.5 {}
L 4 1782.5 -957.5 1790 -960 {}
L 4 1790 -970 1790 -960 {}
L 4 1792.5 -962.5 1797.5 -962.5 {}
L 4 1795 -965 1795 -960 {}
L 4 1900 -920 1900 -910 {}
L 4 1900 -920 1907.5 -922.5 {}
L 4 1892.5 -927.5 1907.5 -922.5 {}
L 4 1892.5 -927.5 1907.5 -932.5 {}
L 4 1892.5 -937.5 1907.5 -932.5 {}
L 4 1892.5 -937.5 1907.5 -942.5 {}
L 4 1892.5 -947.5 1907.5 -942.5 {}
L 4 1892.5 -947.5 1907.5 -952.5 {}
L 4 1892.5 -957.5 1907.5 -952.5 {}
L 4 1892.5 -957.5 1900 -960 {}
L 4 1900 -970 1900 -960 {}
L 4 1902.5 -962.5 1907.5 -962.5 {}
L 4 1905 -965 1905 -960 {}
L 4 2010 -920 2010 -910 {}
L 4 2010 -920 2017.5 -922.5 {}
L 4 2002.5 -927.5 2017.5 -922.5 {}
L 4 2002.5 -927.5 2017.5 -932.5 {}
L 4 2002.5 -937.5 2017.5 -932.5 {}
L 4 2002.5 -937.5 2017.5 -942.5 {}
L 4 2002.5 -947.5 2017.5 -942.5 {}
L 4 2002.5 -947.5 2017.5 -952.5 {}
L 4 2002.5 -957.5 2017.5 -952.5 {}
L 4 2002.5 -957.5 2010 -960 {}
L 4 2010 -970 2010 -960 {}
L 4 2012.5 -962.5 2017.5 -962.5 {}
L 4 2015 -965 2015 -960 {}
L 4 1865 -2730 1865 -2670 {}
L 4 1865 -2720 1880 -2720 {}
L 4 1880 -2730 1880 -2720 {}
L 4 1865 -2680 1880 -2680 {}
L 4 1880 -2680 1880 -2670 {}
L 4 1855 -2715 1855 -2685 {}
L 4 1855 -2700 1855 -2695 {}
L 4 1840 -2700 1847.5 -2700 {}
L 4 1840 -2700 1855 -2700 {}
L 4 1870 -2700 1880 -2700 {}
L 4 1865 -2705 1870 -2700 {}
L 4 1865 -2695 1870 -2700 {}
L 4 1140 -9180 1140 -9167.5 {}
L 4 1135 -9167.5 1145 -9167.5 {}
L 4 1140 -9162.5 1145 -9167.5 {}
L 4 1135 -9167.5 1140 -9162.5 {}
L 4 1140 -9460 1140 -9440 {}
L 4 1130 -9460 1150 -9460 {}
L 4 1032.5 -9252.5 1037.5 -9252.5 {}
L 4 1035 -9255 1035 -9250 {}
L 4 1030 -9260 1030 -9200 {}
L 4 710 -630 710 -620 {}
L 4 710 -630 717.5 -632.5 {}
L 4 702.5 -637.5 717.5 -632.5 {}
L 4 702.5 -637.5 717.5 -642.5 {}
L 4 702.5 -647.5 717.5 -642.5 {}
L 4 702.5 -647.5 717.5 -652.5 {}
L 4 702.5 -657.5 717.5 -652.5 {}
L 4 702.5 -657.5 717.5 -662.5 {}
L 4 702.5 -667.5 717.5 -662.5 {}
L 4 702.5 -667.5 710 -670 {}
L 4 710 -680 710 -670 {}
L 4 712.5 -672.5 717.5 -672.5 {}
L 4 715 -675 715 -670 {}
L 4 820 -630 820 -620 {}
L 4 820 -630 827.5 -632.5 {}
L 4 812.5 -637.5 827.5 -632.5 {}
L 4 812.5 -637.5 827.5 -642.5 {}
L 4 812.5 -647.5 827.5 -642.5 {}
L 4 812.5 -647.5 827.5 -652.5 {}
L 4 812.5 -657.5 827.5 -652.5 {}
L 4 812.5 -657.5 827.5 -662.5 {}
L 4 812.5 -667.5 827.5 -662.5 {}
L 4 812.5 -667.5 820 -670 {}
L 4 820 -680 820 -670 {}
L 4 822.5 -672.5 827.5 -672.5 {}
L 4 825 -675 825 -670 {}
L 4 930 -630 930 -620 {}
L 4 930 -630 937.5 -632.5 {}
L 4 922.5 -637.5 937.5 -632.5 {}
L 4 922.5 -637.5 937.5 -642.5 {}
L 4 922.5 -647.5 937.5 -642.5 {}
L 4 922.5 -647.5 937.5 -652.5 {}
L 4 922.5 -657.5 937.5 -652.5 {}
L 4 922.5 -657.5 937.5 -662.5 {}
L 4 922.5 -667.5 937.5 -662.5 {}
L 4 922.5 -667.5 930 -670 {}
L 4 930 -680 930 -670 {}
L 4 932.5 -672.5 937.5 -672.5 {}
L 4 935 -675 935 -670 {}
L 4 710 -570 710 -560 {}
L 4 710 -570 717.5 -572.5 {}
L 4 702.5 -577.5 717.5 -572.5 {}
L 4 702.5 -577.5 717.5 -582.5 {}
L 4 702.5 -587.5 717.5 -582.5 {}
L 4 702.5 -587.5 717.5 -592.5 {}
L 4 702.5 -597.5 717.5 -592.5 {}
L 4 702.5 -597.5 717.5 -602.5 {}
L 4 702.5 -607.5 717.5 -602.5 {}
L 4 702.5 -607.5 710 -610 {}
L 4 710 -620 710 -610 {}
L 4 712.5 -612.5 717.5 -612.5 {}
L 4 715 -615 715 -610 {}
L 4 820 -570 820 -560 {}
L 4 820 -570 827.5 -572.5 {}
L 4 812.5 -577.5 827.5 -572.5 {}
L 4 812.5 -577.5 827.5 -582.5 {}
L 4 812.5 -587.5 827.5 -582.5 {}
L 4 812.5 -587.5 827.5 -592.5 {}
L 4 812.5 -597.5 827.5 -592.5 {}
L 4 812.5 -597.5 827.5 -602.5 {}
L 4 812.5 -607.5 827.5 -602.5 {}
L 4 812.5 -607.5 820 -610 {}
L 4 820 -620 820 -610 {}
L 4 822.5 -612.5 827.5 -612.5 {}
L 4 825 -615 825 -610 {}
L 4 930 -570 930 -560 {}
L 4 930 -570 937.5 -572.5 {}
L 4 922.5 -577.5 937.5 -572.5 {}
L 4 922.5 -577.5 937.5 -582.5 {}
L 4 922.5 -587.5 937.5 -582.5 {}
L 4 922.5 -587.5 937.5 -592.5 {}
L 4 922.5 -597.5 937.5 -592.5 {}
L 4 922.5 -597.5 937.5 -602.5 {}
L 4 922.5 -607.5 937.5 -602.5 {}
L 4 922.5 -607.5 930 -610 {}
L 4 930 -620 930 -610 {}
L 4 932.5 -612.5 937.5 -612.5 {}
L 4 935 -615 935 -610 {}
L 4 1250 -570 1250 -560 {}
L 4 1250 -570 1257.5 -572.5 {}
L 4 1242.5 -577.5 1257.5 -572.5 {}
L 4 1242.5 -577.5 1257.5 -582.5 {}
L 4 1242.5 -587.5 1257.5 -582.5 {}
L 4 1242.5 -587.5 1257.5 -592.5 {}
L 4 1242.5 -597.5 1257.5 -592.5 {}
L 4 1242.5 -597.5 1257.5 -602.5 {}
L 4 1242.5 -607.5 1257.5 -602.5 {}
L 4 1242.5 -607.5 1250 -610 {}
L 4 1250 -620 1250 -610 {}
L 4 1252.5 -612.5 1257.5 -612.5 {}
L 4 1255 -615 1255 -610 {}
L 4 1360 -570 1360 -560 {}
L 4 1360 -570 1367.5 -572.5 {}
L 4 1352.5 -577.5 1367.5 -572.5 {}
L 4 1352.5 -577.5 1367.5 -582.5 {}
L 4 1352.5 -587.5 1367.5 -582.5 {}
L 4 1352.5 -587.5 1367.5 -592.5 {}
L 4 1352.5 -597.5 1367.5 -592.5 {}
L 4 1352.5 -597.5 1367.5 -602.5 {}
L 4 1352.5 -607.5 1367.5 -602.5 {}
L 4 1352.5 -607.5 1360 -610 {}
L 4 1360 -620 1360 -610 {}
L 4 1362.5 -612.5 1367.5 -612.5 {}
L 4 1365 -615 1365 -610 {}
L 4 1470 -570 1470 -560 {}
L 4 1470 -570 1477.5 -572.5 {}
L 4 1462.5 -577.5 1477.5 -572.5 {}
L 4 1462.5 -577.5 1477.5 -582.5 {}
L 4 1462.5 -587.5 1477.5 -582.5 {}
L 4 1462.5 -587.5 1477.5 -592.5 {}
L 4 1462.5 -597.5 1477.5 -592.5 {}
L 4 1462.5 -597.5 1477.5 -602.5 {}
L 4 1462.5 -607.5 1477.5 -602.5 {}
L 4 1462.5 -607.5 1470 -610 {}
L 4 1470 -620 1470 -610 {}
L 4 1472.5 -612.5 1477.5 -612.5 {}
L 4 1475 -615 1475 -610 {}
L 4 1790 -540 1790 -530 {}
L 4 1790 -540 1797.5 -542.5 {}
L 4 1782.5 -547.5 1797.5 -542.5 {}
L 4 1782.5 -547.5 1797.5 -552.5 {}
L 4 1782.5 -557.5 1797.5 -552.5 {}
L 4 1782.5 -557.5 1797.5 -562.5 {}
L 4 1782.5 -567.5 1797.5 -562.5 {}
L 4 1782.5 -567.5 1797.5 -572.5 {}
L 4 1782.5 -577.5 1797.5 -572.5 {}
L 4 1782.5 -577.5 1790 -580 {}
L 4 1790 -590 1790 -580 {}
L 4 1792.5 -582.5 1797.5 -582.5 {}
L 4 1795 -585 1795 -580 {}
L 4 1900 -540 1900 -530 {}
L 4 1900 -540 1907.5 -542.5 {}
L 4 1892.5 -547.5 1907.5 -542.5 {}
L 4 1892.5 -547.5 1907.5 -552.5 {}
L 4 1892.5 -557.5 1907.5 -552.5 {}
L 4 1892.5 -557.5 1907.5 -562.5 {}
L 4 1892.5 -567.5 1907.5 -562.5 {}
L 4 1892.5 -567.5 1907.5 -572.5 {}
L 4 1892.5 -577.5 1907.5 -572.5 {}
L 4 1892.5 -577.5 1900 -580 {}
L 4 1900 -590 1900 -580 {}
L 4 1902.5 -582.5 1907.5 -582.5 {}
L 4 1905 -585 1905 -580 {}
L 4 2010 -540 2010 -530 {}
L 4 2010 -540 2017.5 -542.5 {}
L 4 2002.5 -547.5 2017.5 -542.5 {}
L 4 2002.5 -547.5 2017.5 -552.5 {}
L 4 2002.5 -557.5 2017.5 -552.5 {}
L 4 2002.5 -557.5 2017.5 -562.5 {}
L 4 2002.5 -567.5 2017.5 -562.5 {}
L 4 2002.5 -567.5 2017.5 -572.5 {}
L 4 2002.5 -577.5 2017.5 -572.5 {}
L 4 2002.5 -577.5 2010 -580 {}
L 4 2010 -590 2010 -580 {}
L 4 2012.5 -582.5 2017.5 -582.5 {}
L 4 2015 -585 2015 -580 {}
L 4 1760 -1320 1760 -1310 {}
L 4 1760 -1320 1767.5 -1322.5 {}
L 4 1752.5 -1327.5 1767.5 -1322.5 {}
L 4 1752.5 -1327.5 1767.5 -1332.5 {}
L 4 1752.5 -1337.5 1767.5 -1332.5 {}
L 4 1752.5 -1337.5 1767.5 -1342.5 {}
L 4 1752.5 -1347.5 1767.5 -1342.5 {}
L 4 1752.5 -1347.5 1767.5 -1352.5 {}
L 4 1752.5 -1357.5 1767.5 -1352.5 {}
L 4 1752.5 -1357.5 1760 -1360 {}
L 4 1760 -1370 1760 -1360 {}
L 4 1762.5 -1362.5 1767.5 -1362.5 {}
L 4 1765 -1365 1765 -1360 {}
L 4 1880 -1320 1880 -1310 {}
L 4 1880 -1320 1887.5 -1322.5 {}
L 4 1872.5 -1327.5 1887.5 -1322.5 {}
L 4 1872.5 -1327.5 1887.5 -1332.5 {}
L 4 1872.5 -1337.5 1887.5 -1332.5 {}
L 4 1872.5 -1337.5 1887.5 -1342.5 {}
L 4 1872.5 -1347.5 1887.5 -1342.5 {}
L 4 1872.5 -1347.5 1887.5 -1352.5 {}
L 4 1872.5 -1357.5 1887.5 -1352.5 {}
L 4 1872.5 -1357.5 1880 -1360 {}
L 4 1880 -1370 1880 -1360 {}
L 4 1882.5 -1362.5 1887.5 -1362.5 {}
L 4 1885 -1365 1885 -1360 {}
L 4 805 -220 805 -160 {}
L 4 805 -210 820 -210 {}
L 4 820 -220 820 -210 {}
L 4 805 -170 820 -170 {}
L 4 820 -170 820 -160 {}
L 4 795 -205 795 -175 {}
L 4 795 -190 795 -185 {}
L 4 780 -190 787.5 -190 {}
L 4 780 -190 795 -190 {}
L 4 810 -190 820 -190 {}
L 4 805 -195 810 -190 {}
L 4 805 -185 810 -190 {}
L 4 820 -260 820 -250 {}
L 4 820 -260 827.5 -262.5 {}
L 4 812.5 -267.5 827.5 -262.5 {}
L 4 812.5 -267.5 827.5 -272.5 {}
L 4 812.5 -277.5 827.5 -272.5 {}
L 4 812.5 -277.5 827.5 -282.5 {}
L 4 812.5 -287.5 827.5 -282.5 {}
L 4 812.5 -287.5 827.5 -292.5 {}
L 4 812.5 -297.5 827.5 -292.5 {}
L 4 812.5 -297.5 820 -300 {}
L 4 820 -310 820 -300 {}
L 4 822.5 -302.5 827.5 -302.5 {}
L 4 825 -305 825 -300 {}
L 4 910 -185 910 -160 {}
L 4 910 -220 910 -195 {}
L 4 900 -195 920 -195 {}
L 4 900 -185 920 -185 {}
L 4 912.5 -212.5 917.5 -212.5 {}
L 4 915 -215 915 -210 {}
L 4 582.5 -152.5 587.5 -152.5 {}
L 4 585 -155 585 -150 {}
L 4 580 -160 580 -100 {}
L 4 690 -80 690 -67.5 {}
L 4 685 -67.5 695 -67.5 {}
L 4 690 -62.5 695 -67.5 {}
L 4 685 -67.5 690 -62.5 {}
L 4 690 -360 690 -340 {}
L 4 680 -360 700 -360 {}
L 4 1455 -220 1455 -160 {}
L 4 1455 -210 1470 -210 {}
L 4 1470 -220 1470 -210 {}
L 4 1455 -170 1470 -170 {}
L 4 1470 -170 1470 -160 {}
L 4 1445 -205 1445 -175 {}
L 4 1445 -190 1445 -185 {}
L 4 1430 -190 1437.5 -190 {}
L 4 1430 -190 1445 -190 {}
L 4 1460 -190 1470 -190 {}
L 4 1455 -195 1460 -190 {}
L 4 1455 -185 1460 -190 {}
L 4 1470 -260 1470 -250 {}
L 4 1470 -260 1477.5 -262.5 {}
L 4 1462.5 -267.5 1477.5 -262.5 {}
L 4 1462.5 -267.5 1477.5 -272.5 {}
L 4 1462.5 -277.5 1477.5 -272.5 {}
L 4 1462.5 -277.5 1477.5 -282.5 {}
L 4 1462.5 -287.5 1477.5 -282.5 {}
L 4 1462.5 -287.5 1477.5 -292.5 {}
L 4 1462.5 -297.5 1477.5 -292.5 {}
L 4 1462.5 -297.5 1470 -300 {}
L 4 1470 -310 1470 -300 {}
L 4 1472.5 -302.5 1477.5 -302.5 {}
L 4 1475 -305 1475 -300 {}
L 4 1232.5 -152.5 1237.5 -152.5 {}
L 4 1235 -155 1235 -150 {}
L 4 1230 -160 1230 -100 {}
L 4 1340 -80 1340 -67.5 {}
L 4 1335 -67.5 1345 -67.5 {}
L 4 1340 -62.5 1345 -67.5 {}
L 4 1335 -67.5 1340 -62.5 {}
L 4 1340 -360 1340 -340 {}
L 4 1330 -360 1350 -360 {}
L 4 1285 -4970 1285 -4910 {}
L 4 1285 -4960 1300 -4960 {}
L 4 1300 -4970 1300 -4960 {}
L 4 1285 -4920 1300 -4920 {}
L 4 1300 -4920 1300 -4910 {}
L 4 1275 -4955 1275 -4925 {}
L 4 1275 -4940 1275 -4935 {}
L 4 1260 -4940 1267.5 -4940 {}
L 4 1260 -4940 1275 -4940 {}
L 4 1290 -4940 1300 -4940 {}
L 4 1285 -4945 1290 -4940 {}
L 4 1285 -4935 1290 -4940 {}
L 4 1300 -5010 1300 -5000 {}
L 4 1300 -5010 1307.5 -5012.5 {}
L 4 1292.5 -5017.5 1307.5 -5012.5 {}
L 4 1292.5 -5017.5 1307.5 -5022.5 {}
L 4 1292.5 -5027.5 1307.5 -5022.5 {}
L 4 1292.5 -5027.5 1307.5 -5032.5 {}
L 4 1292.5 -5037.5 1307.5 -5032.5 {}
L 4 1292.5 -5037.5 1307.5 -5042.5 {}
L 4 1292.5 -5047.5 1307.5 -5042.5 {}
L 4 1292.5 -5047.5 1300 -5050 {}
L 4 1300 -5060 1300 -5050 {}
L 4 1302.5 -5052.5 1307.5 -5052.5 {}
L 4 1305 -5055 1305 -5050 {}
L 4 1390 -4935 1390 -4910 {}
L 4 1390 -4970 1390 -4945 {}
L 4 1380 -4945 1400 -4945 {}
L 4 1380 -4935 1400 -4935 {}
L 4 1392.5 -4962.5 1397.5 -4962.5 {}
L 4 1395 -4965 1395 -4960 {}
L 4 1062.5 -4902.5 1067.5 -4902.5 {}
L 4 1065 -4905 1065 -4900 {}
L 4 1060 -4910 1060 -4850 {}
L 4 1170 -4830 1170 -4817.5 {}
L 4 1165 -4817.5 1175 -4817.5 {}
L 4 1170 -4812.5 1175 -4817.5 {}
L 4 1165 -4817.5 1170 -4812.5 {}
L 4 1170 -5110 1170 -5090 {}
L 4 1160 -5110 1180 -5110 {}
L 4 1845 -4970 1845 -4910 {}
L 4 1845 -4960 1860 -4960 {}
L 4 1860 -4970 1860 -4960 {}
L 4 1845 -4920 1860 -4920 {}
L 4 1860 -4920 1860 -4910 {}
L 4 1835 -4955 1835 -4925 {}
L 4 1835 -4940 1835 -4935 {}
L 4 1820 -4940 1827.5 -4940 {}
L 4 1820 -4940 1835 -4940 {}
L 4 1850 -4940 1860 -4940 {}
L 4 1845 -4945 1850 -4940 {}
L 4 1845 -4935 1850 -4940 {}
L 4 1860 -5010 1860 -5000 {}
L 4 1860 -5010 1867.5 -5012.5 {}
L 4 1852.5 -5017.5 1867.5 -5012.5 {}
L 4 1852.5 -5017.5 1867.5 -5022.5 {}
L 4 1852.5 -5027.5 1867.5 -5022.5 {}
L 4 1852.5 -5027.5 1867.5 -5032.5 {}
L 4 1852.5 -5037.5 1867.5 -5032.5 {}
L 4 1852.5 -5037.5 1867.5 -5042.5 {}
L 4 1852.5 -5047.5 1867.5 -5042.5 {}
L 4 1852.5 -5047.5 1860 -5050 {}
L 4 1860 -5060 1860 -5050 {}
L 4 1862.5 -5052.5 1867.5 -5052.5 {}
L 4 1865 -5055 1865 -5050 {}
L 4 1950 -4935 1950 -4910 {}
L 4 1950 -4970 1950 -4945 {}
L 4 1940 -4945 1960 -4945 {}
L 4 1940 -4935 1960 -4935 {}
L 4 1952.5 -4962.5 1957.5 -4962.5 {}
L 4 1955 -4965 1955 -4960 {}
L 4 1622.5 -4902.5 1627.5 -4902.5 {}
L 4 1625 -4905 1625 -4900 {}
L 4 1620 -4910 1620 -4850 {}
L 4 1730 -4830 1730 -4817.5 {}
L 4 1725 -4817.5 1735 -4817.5 {}
L 4 1730 -4812.5 1735 -4817.5 {}
L 4 1725 -4817.5 1730 -4812.5 {}
L 4 1730 -5110 1730 -5090 {}
L 4 1720 -5110 1740 -5110 {}
L 4 2415 -4970 2415 -4910 {}
L 4 2415 -4960 2430 -4960 {}
L 4 2430 -4970 2430 -4960 {}
L 4 2415 -4920 2430 -4920 {}
L 4 2430 -4920 2430 -4910 {}
L 4 2405 -4955 2405 -4925 {}
L 4 2405 -4940 2405 -4935 {}
L 4 2390 -4940 2397.5 -4940 {}
L 4 2390 -4940 2405 -4940 {}
L 4 2420 -4940 2430 -4940 {}
L 4 2415 -4945 2420 -4940 {}
L 4 2415 -4935 2420 -4940 {}
L 4 2430 -5010 2430 -5000 {}
L 4 2430 -5010 2437.5 -5012.5 {}
L 4 2422.5 -5017.5 2437.5 -5012.5 {}
L 4 2422.5 -5017.5 2437.5 -5022.5 {}
L 4 2422.5 -5027.5 2437.5 -5022.5 {}
L 4 2422.5 -5027.5 2437.5 -5032.5 {}
L 4 2422.5 -5037.5 2437.5 -5032.5 {}
L 4 2422.5 -5037.5 2437.5 -5042.5 {}
L 4 2422.5 -5047.5 2437.5 -5042.5 {}
L 4 2422.5 -5047.5 2430 -5050 {}
L 4 2430 -5060 2430 -5050 {}
L 4 2432.5 -5052.5 2437.5 -5052.5 {}
L 4 2435 -5055 2435 -5050 {}
L 4 2520 -4935 2520 -4910 {}
L 4 2520 -4970 2520 -4945 {}
L 4 2510 -4945 2530 -4945 {}
L 4 2510 -4935 2530 -4935 {}
L 4 2522.5 -4962.5 2527.5 -4962.5 {}
L 4 2525 -4965 2525 -4960 {}
L 4 2192.5 -4902.5 2197.5 -4902.5 {}
L 4 2195 -4905 2195 -4900 {}
L 4 2190 -4910 2190 -4850 {}
L 4 2300 -4830 2300 -4817.5 {}
L 4 2295 -4817.5 2305 -4817.5 {}
L 4 2300 -4812.5 2305 -4817.5 {}
L 4 2295 -4817.5 2300 -4812.5 {}
L 4 2300 -5110 2300 -5090 {}
L 4 2290 -5110 2310 -5110 {}
L 4 2015 -220 2015 -160 {}
L 4 2015 -210 2030 -210 {}
L 4 2030 -220 2030 -210 {}
L 4 2015 -170 2030 -170 {}
L 4 2030 -170 2030 -160 {}
L 4 2005 -205 2005 -175 {}
L 4 2005 -190 2005 -185 {}
L 4 1990 -190 1997.5 -190 {}
L 4 1990 -190 2005 -190 {}
L 4 2020 -190 2030 -190 {}
L 4 2015 -195 2020 -190 {}
L 4 2015 -185 2020 -190 {}
L 4 2030 -260 2030 -250 {}
L 4 2030 -260 2037.5 -262.5 {}
L 4 2022.5 -267.5 2037.5 -262.5 {}
L 4 2022.5 -267.5 2037.5 -272.5 {}
L 4 2022.5 -277.5 2037.5 -272.5 {}
L 4 2022.5 -277.5 2037.5 -282.5 {}
L 4 2022.5 -287.5 2037.5 -282.5 {}
L 4 2022.5 -287.5 2037.5 -292.5 {}
L 4 2022.5 -297.5 2037.5 -292.5 {}
L 4 2022.5 -297.5 2030 -300 {}
L 4 2030 -310 2030 -300 {}
L 4 2032.5 -302.5 2037.5 -302.5 {}
L 4 2035 -305 2035 -300 {}
L 4 1792.5 -152.5 1797.5 -152.5 {}
L 4 1795 -155 1795 -150 {}
L 4 1790 -160 1790 -100 {}
L 4 1900 -80 1900 -67.5 {}
L 4 1895 -67.5 1905 -67.5 {}
L 4 1900 -62.5 1905 -67.5 {}
L 4 1895 -67.5 1900 -62.5 {}
L 4 1900 -360 1900 -340 {}
L 4 1890 -360 1910 -360 {}
L 4 745 -4590 745 -4530 {}
L 4 745 -4580 760 -4580 {}
L 4 760 -4590 760 -4580 {}
L 4 745 -4540 760 -4540 {}
L 4 760 -4540 760 -4530 {}
L 4 735 -4575 735 -4545 {}
L 4 735 -4560 735 -4555 {}
L 4 720 -4560 727.5 -4560 {}
L 4 720 -4560 735 -4560 {}
L 4 750 -4560 760 -4560 {}
L 4 745 -4565 750 -4560 {}
L 4 745 -4555 750 -4560 {}
L 4 850 -4555 850 -4530 {}
L 4 850 -4590 850 -4565 {}
L 4 840 -4565 860 -4565 {}
L 4 840 -4555 860 -4555 {}
L 4 852.5 -4582.5 857.5 -4582.5 {}
L 4 855 -4585 855 -4580 {}
L 4 522.5 -4522.5 527.5 -4522.5 {}
L 4 525 -4525 525 -4520 {}
L 4 520 -4530 520 -4470 {}
L 4 630 -4450 630 -4437.5 {}
L 4 625 -4437.5 635 -4437.5 {}
L 4 630 -4432.5 635 -4437.5 {}
L 4 625 -4437.5 630 -4432.5 {}
L 4 420 -7540 420 -7530 {}
L 4 420 -7540 427.5 -7542.5 {}
L 4 412.5 -7547.5 427.5 -7542.5 {}
L 4 412.5 -7547.5 427.5 -7552.5 {}
L 4 412.5 -7557.5 427.5 -7552.5 {}
L 4 412.5 -7557.5 427.5 -7562.5 {}
L 4 412.5 -7567.5 427.5 -7562.5 {}
L 4 412.5 -7567.5 427.5 -7572.5 {}
L 4 412.5 -7577.5 427.5 -7572.5 {}
L 4 412.5 -7577.5 420 -7580 {}
L 4 420 -7590 420 -7580 {}
L 4 422.5 -7582.5 427.5 -7582.5 {}
L 4 425 -7585 425 -7580 {}
L 4 610 -7540 610 -7530 {}
L 4 610 -7540 617.5 -7542.5 {}
L 4 602.5 -7547.5 617.5 -7542.5 {}
L 4 602.5 -7547.5 617.5 -7552.5 {}
L 4 602.5 -7557.5 617.5 -7552.5 {}
L 4 602.5 -7557.5 617.5 -7562.5 {}
L 4 602.5 -7567.5 617.5 -7562.5 {}
L 4 602.5 -7567.5 617.5 -7572.5 {}
L 4 602.5 -7577.5 617.5 -7572.5 {}
L 4 602.5 -7577.5 610 -7580 {}
L 4 610 -7590 610 -7580 {}
L 4 612.5 -7582.5 617.5 -7582.5 {}
L 4 615 -7585 615 -7580 {}
L 4 800 -7540 800 -7530 {}
L 4 800 -7540 807.5 -7542.5 {}
L 4 792.5 -7547.5 807.5 -7542.5 {}
L 4 792.5 -7547.5 807.5 -7552.5 {}
L 4 792.5 -7557.5 807.5 -7552.5 {}
L 4 792.5 -7557.5 807.5 -7562.5 {}
L 4 792.5 -7567.5 807.5 -7562.5 {}
L 4 792.5 -7567.5 807.5 -7572.5 {}
L 4 792.5 -7577.5 807.5 -7572.5 {}
L 4 792.5 -7577.5 800 -7580 {}
L 4 800 -7590 800 -7580 {}
L 4 802.5 -7582.5 807.5 -7582.5 {}
L 4 805 -7585 805 -7580 {}
L 4 1050 -7540 1050 -7530 {}
L 4 1050 -7540 1057.5 -7542.5 {}
L 4 1042.5 -7547.5 1057.5 -7542.5 {}
L 4 1042.5 -7547.5 1057.5 -7552.5 {}
L 4 1042.5 -7557.5 1057.5 -7552.5 {}
L 4 1042.5 -7557.5 1057.5 -7562.5 {}
L 4 1042.5 -7567.5 1057.5 -7562.5 {}
L 4 1042.5 -7567.5 1057.5 -7572.5 {}
L 4 1042.5 -7577.5 1057.5 -7572.5 {}
L 4 1042.5 -7577.5 1050 -7580 {}
L 4 1050 -7590 1050 -7580 {}
L 4 1052.5 -7582.5 1057.5 -7582.5 {}
L 4 1055 -7585 1055 -7580 {}
L 4 1240 -7540 1240 -7530 {}
L 4 1240 -7540 1247.5 -7542.5 {}
L 4 1232.5 -7547.5 1247.5 -7542.5 {}
L 4 1232.5 -7547.5 1247.5 -7552.5 {}
L 4 1232.5 -7557.5 1247.5 -7552.5 {}
L 4 1232.5 -7557.5 1247.5 -7562.5 {}
L 4 1232.5 -7567.5 1247.5 -7562.5 {}
L 4 1232.5 -7567.5 1247.5 -7572.5 {}
L 4 1232.5 -7577.5 1247.5 -7572.5 {}
L 4 1232.5 -7577.5 1240 -7580 {}
L 4 1240 -7590 1240 -7580 {}
L 4 1242.5 -7582.5 1247.5 -7582.5 {}
L 4 1245 -7585 1245 -7580 {}
L 4 1530 -7540 1530 -7530 {}
L 4 1530 -7540 1537.5 -7542.5 {}
L 4 1522.5 -7547.5 1537.5 -7542.5 {}
L 4 1522.5 -7547.5 1537.5 -7552.5 {}
L 4 1522.5 -7557.5 1537.5 -7552.5 {}
L 4 1522.5 -7557.5 1537.5 -7562.5 {}
L 4 1522.5 -7567.5 1537.5 -7562.5 {}
L 4 1522.5 -7567.5 1537.5 -7572.5 {}
L 4 1522.5 -7577.5 1537.5 -7572.5 {}
L 4 1522.5 -7577.5 1530 -7580 {}
L 4 1530 -7590 1530 -7580 {}
L 4 1532.5 -7582.5 1537.5 -7582.5 {}
L 4 1535 -7585 1535 -7580 {}
L 4 1660 -7555 1660 -7530 {}
L 4 1660 -7590 1660 -7565 {}
L 4 1650 -7565 1670 -7565 {}
L 4 1650 -7555 1670 -7555 {}
L 4 1662.5 -7582.5 1667.5 -7582.5 {}
L 4 1665 -7585 1665 -7580 {}
L 4 1860 -7540 1860 -7530 {}
L 4 1860 -7540 1867.5 -7542.5 {}
L 4 1852.5 -7547.5 1867.5 -7542.5 {}
L 4 1852.5 -7547.5 1867.5 -7552.5 {}
L 4 1852.5 -7557.5 1867.5 -7552.5 {}
L 4 1852.5 -7557.5 1867.5 -7562.5 {}
L 4 1852.5 -7567.5 1867.5 -7562.5 {}
L 4 1852.5 -7567.5 1867.5 -7572.5 {}
L 4 1852.5 -7577.5 1867.5 -7572.5 {}
L 4 1852.5 -7577.5 1860 -7580 {}
L 4 1860 -7590 1860 -7580 {}
L 4 1862.5 -7582.5 1867.5 -7582.5 {}
L 4 1865 -7585 1865 -7580 {}
L 4 1990 -7555 1990 -7530 {}
L 4 1990 -7590 1990 -7565 {}
L 4 1980 -7565 2000 -7565 {}
L 4 1980 -7555 2000 -7555 {}
L 4 1992.5 -7582.5 1997.5 -7582.5 {}
L 4 1995 -7585 1995 -7580 {}
L 4 2400 -7540 2400 -7530 {}
L 4 2400 -7540 2407.5 -7542.5 {}
L 4 2392.5 -7547.5 2407.5 -7542.5 {}
L 4 2392.5 -7547.5 2407.5 -7552.5 {}
L 4 2392.5 -7557.5 2407.5 -7552.5 {}
L 4 2392.5 -7557.5 2407.5 -7562.5 {}
L 4 2392.5 -7567.5 2407.5 -7562.5 {}
L 4 2392.5 -7567.5 2407.5 -7572.5 {}
L 4 2392.5 -7577.5 2407.5 -7572.5 {}
L 4 2392.5 -7577.5 2400 -7580 {}
L 4 2400 -7590 2400 -7580 {}
L 4 2402.5 -7582.5 2407.5 -7582.5 {}
L 4 2405 -7585 2405 -7580 {}
L 4 2530 -7555 2530 -7530 {}
L 4 2530 -7590 2530 -7565 {}
L 4 2520 -7565 2540 -7565 {}
L 4 2520 -7555 2540 -7555 {}
L 4 2532.5 -7582.5 2537.5 -7582.5 {}
L 4 2535 -7585 2535 -7580 {}
L 4 2110 -7540 2110 -7530 {}
L 4 2110 -7540 2117.5 -7542.5 {}
L 4 2102.5 -7547.5 2117.5 -7542.5 {}
L 4 2102.5 -7547.5 2117.5 -7552.5 {}
L 4 2102.5 -7557.5 2117.5 -7552.5 {}
L 4 2102.5 -7557.5 2117.5 -7562.5 {}
L 4 2102.5 -7567.5 2117.5 -7562.5 {}
L 4 2102.5 -7567.5 2117.5 -7572.5 {}
L 4 2102.5 -7577.5 2117.5 -7572.5 {}
L 4 2102.5 -7577.5 2110 -7580 {}
L 4 2110 -7590 2110 -7580 {}
L 4 2112.5 -7582.5 2117.5 -7582.5 {}
L 4 2115 -7585 2115 -7580 {}
L 4 2240 -7555 2240 -7530 {}
L 4 2240 -7590 2240 -7565 {}
L 4 2230 -7565 2250 -7565 {}
L 4 2230 -7555 2250 -7555 {}
L 4 2242.5 -7582.5 2247.5 -7582.5 {}
L 4 2245 -7585 2245 -7580 {}
L 4 2380 -4150 2380 -4140 {}
L 4 2380 -4150 2387.5 -4152.5 {}
L 4 2372.5 -4157.5 2387.5 -4152.5 {}
L 4 2372.5 -4157.5 2387.5 -4162.5 {}
L 4 2372.5 -4167.5 2387.5 -4162.5 {}
L 4 2372.5 -4167.5 2387.5 -4172.5 {}
L 4 2372.5 -4177.5 2387.5 -4172.5 {}
L 4 2372.5 -4177.5 2387.5 -4182.5 {}
L 4 2372.5 -4187.5 2387.5 -4182.5 {}
L 4 2372.5 -4187.5 2380 -4190 {}
L 4 2380 -4200 2380 -4190 {}
L 4 2382.5 -4192.5 2387.5 -4192.5 {}
L 4 2385 -4195 2385 -4190 {}
L 5 1105 -8820 1110 -8820 {}
L 5 1410 -8850 1418.75 -8850 {}
L 5 1645 -8820 1650 -8820 {}
L 5 1950 -8850 1958.75 -8850 {}
L 5 575 -8820 580 -8820 {}
L 5 880 -8850 888.75 -8850 {}
L 5 575 -8360 580 -8360 {}
L 5 880 -8390 888.75 -8390 {}
L 5 1115 -8360 1120 -8360 {}
L 5 1420 -8390 1428.75 -8390 {}
L 5 575 -6740 580 -6740 {}
L 5 880 -6770 888.75 -6770 {}
L 5 1115 -6740 1120 -6740 {}
L 5 1420 -6770 1428.75 -6770 {}
L 5 575 -6250 580 -6250 {}
L 5 880 -6280 888.75 -6280 {}
L 5 1115 -6250 1120 -6250 {}
L 5 1420 -6280 1428.75 -6280 {}
L 5 575 -5760 580 -5760 {}
L 5 1765 -5760 1770 -5760 {}
L 5 1115 -5760 1120 -5760 {}
L 5 1105 -7990 1110 -7990 {}
L 5 1410 -8020 1418.75 -8020 {}
L 5 575 -7990 580 -7990 {}
L 5 880 -8020 888.75 -8020 {}
L 5 1605 -7990 1610 -7990 {}
L 5 1910 -8020 1918.75 -8020 {}
L 5 1645 -9290 1650 -9290 {}
L 5 1950 -9320 1958.75 -9320 {}
L 5 575 -9290 580 -9290 {}
L 5 880 -9320 888.75 -9320 {}
L 5 2105 -9290 2110 -9290 {}
L 5 2410 -9320 2418.75 -9320 {}
L 5 595 -5320 600 -5320 {}
L 5 900 -5350 908.75 -5350 {}
L 5 1135 -5320 1140 -5320 {}
L 5 1440 -5350 1448.75 -5350 {}
L 5 1695 -5320 1700 -5320 {}
L 5 2000 -5350 2008.75 -5350 {}
L 5 2265 -5320 2270 -5320 {}
L 5 2570 -5350 2578.75 -5350 {}
L 5 595 -7150 600 -7150 {}
L 5 900 -7180 908.75 -7180 {}
L 5 1135 -7150 1140 -7150 {}
L 5 1440 -7180 1448.75 -7180 {}
L 5 2265 -7150 2270 -7150 {}
L 5 2570 -7180 2578.75 -7180 {}
L 5 595 -4940 600 -4940 {}
L 5 900 -4970 908.75 -4970 {}
L 5 1135 -4560 1140 -4560 {}
L 5 1440 -4590 1448.75 -4590 {}
L 5 2235 -4560 2240 -4560 {}
L 5 2540 -4590 2548.75 -4590 {}
L 5 1675 -4560 1680 -4560 {}
L 5 1980 -4590 1988.75 -4590 {}
L 5 1105 -9290 1110 -9290 {}
L 5 1410 -9320 1418.75 -9320 {}
L 5 655 -190 660 -190 {}
L 5 960 -220 968.75 -220 {}
L 5 1305 -190 1310 -190 {}
L 5 1610 -220 1618.75 -220 {}
L 5 1135 -4940 1140 -4940 {}
L 5 1440 -4970 1448.75 -4970 {}
L 5 1695 -4940 1700 -4940 {}
L 5 2000 -4970 2008.75 -4970 {}
L 5 2265 -4940 2270 -4940 {}
L 5 2570 -4970 2578.75 -4970 {}
L 5 1865 -190 1870 -190 {}
L 5 2170 -220 2178.75 -220 {}
L 5 595 -4560 600 -4560 {}
L 5 900 -4590 908.75 -4590 {}
L 6 1110 -8820 1230 -8820 {}
L 6 1030 -8970 1270 -8970 {}
L 6 1270 -8850 1410 -8850 {}
L 6 1030 -8730 1030 -8710 {}
L 6 1030 -8970 1030 -8790 {}
L 6 1030 -8710 1270 -8710 {}
L 6 1650 -8820 1770 -8820 {}
L 6 1570 -8970 1810 -8970 {}
L 6 1810 -8850 1950 -8850 {}
L 6 1570 -8730 1570 -8710 {}
L 6 1570 -8970 1570 -8790 {}
L 6 1570 -8710 1810 -8710 {}
L 6 580 -8820 700 -8820 {}
L 6 500 -8970 740 -8970 {}
L 6 740 -8850 880 -8850 {}
L 6 500 -8730 500 -8710 {}
L 6 500 -8970 500 -8790 {}
L 6 500 -8710 740 -8710 {}
L 6 580 -8360 700 -8360 {}
L 6 740 -8420 740 -8390 {}
L 6 740 -8510 740 -8480 {}
L 6 500 -8510 740 -8510 {}
L 6 740 -8390 880 -8390 {}
L 6 830 -8330 830 -8250 {}
L 6 500 -8270 500 -8250 {}
L 6 500 -8510 500 -8330 {}
L 6 740 -8360 740 -8250 {}
L 6 740 -8250 830 -8250 {}
L 6 500 -8250 740 -8250 {}
L 6 1120 -8360 1240 -8360 {}
L 6 1280 -8420 1280 -8390 {}
L 6 1280 -8510 1280 -8480 {}
L 6 1040 -8510 1280 -8510 {}
L 6 1280 -8390 1420 -8390 {}
L 6 1370 -8330 1370 -8250 {}
L 6 1040 -8270 1040 -8250 {}
L 6 1040 -8510 1040 -8330 {}
L 6 1280 -8360 1280 -8250 {}
L 6 1280 -8250 1370 -8250 {}
L 6 1040 -8250 1280 -8250 {}
L 6 580 -6740 700 -6740 {}
L 6 740 -6800 740 -6770 {}
L 6 740 -6890 740 -6860 {}
L 6 500 -6890 740 -6890 {}
L 6 740 -6770 880 -6770 {}
L 6 830 -6710 830 -6630 {}
L 6 500 -6650 500 -6630 {}
L 6 500 -6890 500 -6710 {}
L 6 740 -6740 740 -6630 {}
L 6 740 -6630 830 -6630 {}
L 6 500 -6630 740 -6630 {}
L 6 1120 -6740 1240 -6740 {}
L 6 1280 -6800 1280 -6770 {}
L 6 1280 -6890 1280 -6860 {}
L 6 1040 -6890 1280 -6890 {}
L 6 1280 -6770 1420 -6770 {}
L 6 1370 -6710 1370 -6630 {}
L 6 1040 -6650 1040 -6630 {}
L 6 1040 -6890 1040 -6710 {}
L 6 1280 -6740 1280 -6630 {}
L 6 1280 -6630 1370 -6630 {}
L 6 1040 -6630 1280 -6630 {}
L 6 580 -6250 700 -6250 {}
L 6 740 -6310 740 -6280 {}
L 6 740 -6400 740 -6370 {}
L 6 500 -6400 740 -6400 {}
L 6 740 -6280 880 -6280 {}
L 6 830 -6220 830 -6140 {}
L 6 500 -6160 500 -6140 {}
L 6 500 -6400 500 -6220 {}
L 6 740 -6250 740 -6140 {}
L 6 740 -6140 830 -6140 {}
L 6 500 -6140 740 -6140 {}
L 6 1120 -6250 1240 -6250 {}
L 6 1040 -6400 1280 -6400 {}
L 6 1280 -6280 1420 -6280 {}
L 6 1370 -6220 1370 -6140 {}
L 6 1040 -6160 1040 -6140 {}
L 6 1040 -6400 1040 -6220 {}
L 6 1280 -6250 1280 -6140 {}
L 6 1280 -6140 1370 -6140 {}
L 6 1040 -6140 1280 -6140 {}
L 6 580 -5760 700 -5760 {}
L 6 500 -5910 740 -5910 {}
L 6 500 -5670 500 -5650 {}
L 6 500 -5910 500 -5730 {}
L 6 500 -5650 740 -5650 {}
L 6 1690 -5670 1690 -5650 {}
L 6 1690 -5910 1690 -5730 {}
L 6 1120 -5760 1240 -5760 {}
L 6 1040 -5670 1040 -5650 {}
L 6 1040 -5910 1040 -5730 {}
L 6 1110 -7990 1230 -7990 {}
L 6 1030 -8140 1270 -8140 {}
L 6 1270 -8020 1410 -8020 {}
L 6 1030 -7900 1030 -7880 {}
L 6 1030 -8140 1030 -7960 {}
L 6 1030 -7880 1270 -7880 {}
L 6 580 -7990 700 -7990 {}
L 6 500 -8140 740 -8140 {}
L 6 740 -8020 880 -8020 {}
L 6 500 -7900 500 -7880 {}
L 6 500 -8140 500 -7960 {}
L 6 500 -7880 740 -7880 {}
L 6 1610 -7990 1730 -7990 {}
L 6 1770 -8050 1770 -8020 {}
L 6 1770 -8140 1770 -8110 {}
L 6 1530 -8140 1770 -8140 {}
L 6 1770 -8020 1910 -8020 {}
L 6 1860 -7960 1860 -7880 {}
L 6 1530 -7900 1530 -7880 {}
L 6 1530 -8140 1530 -7960 {}
L 6 1770 -7990 1770 -7880 {}
L 6 1770 -7880 1860 -7880 {}
L 6 1530 -7880 1770 -7880 {}
L 6 1650 -9290 1770 -9290 {}
L 6 1570 -9440 1810 -9440 {}
L 6 1810 -9320 1950 -9320 {}
L 6 1570 -9180 1810 -9180 {}
L 6 580 -9290 700 -9290 {}
L 6 500 -9440 740 -9440 {}
L 6 740 -9320 880 -9320 {}
L 6 500 -9200 500 -9180 {}
L 6 500 -9440 500 -9260 {}
L 6 500 -9180 740 -9180 {}
L 6 2110 -9290 2230 -9290 {}
L 6 2030 -9440 2270 -9440 {}
L 6 2270 -9320 2410 -9320 {}
L 6 2030 -9180 2270 -9180 {}
L 6 2360 -9260 2360 -9180 {}
L 6 600 -5320 720 -5320 {}
L 6 760 -5380 760 -5350 {}
L 6 760 -5470 760 -5440 {}
L 6 520 -5470 760 -5470 {}
L 6 760 -5350 900 -5350 {}
L 6 850 -5290 850 -5210 {}
L 6 520 -5230 520 -5210 {}
L 6 520 -5470 520 -5290 {}
L 6 760 -5320 760 -5210 {}
L 6 760 -5210 850 -5210 {}
L 6 520 -5210 760 -5210 {}
L 6 1140 -5320 1260 -5320 {}
L 6 1300 -5380 1300 -5350 {}
L 6 1300 -5470 1300 -5440 {}
L 6 1060 -5470 1300 -5470 {}
L 6 1300 -5350 1440 -5350 {}
L 6 1390 -5290 1390 -5210 {}
L 6 1060 -5230 1060 -5210 {}
L 6 1060 -5470 1060 -5290 {}
L 6 1300 -5320 1300 -5210 {}
L 6 1300 -5210 1390 -5210 {}
L 6 1060 -5210 1300 -5210 {}
L 6 1700 -5320 1820 -5320 {}
L 6 1860 -5380 1860 -5350 {}
L 6 1860 -5470 1860 -5440 {}
L 6 1620 -5470 1860 -5470 {}
L 6 1860 -5350 2000 -5350 {}
L 6 1950 -5290 1950 -5210 {}
L 6 1620 -5230 1620 -5210 {}
L 6 1620 -5470 1620 -5290 {}
L 6 1860 -5320 1860 -5210 {}
L 6 1860 -5210 1950 -5210 {}
L 6 1620 -5210 1860 -5210 {}
L 6 2270 -5320 2390 -5320 {}
L 6 2430 -5380 2430 -5350 {}
L 6 2430 -5470 2430 -5440 {}
L 6 2190 -5470 2430 -5470 {}
L 6 2430 -5350 2570 -5350 {}
L 6 2520 -5290 2520 -5210 {}
L 6 2190 -5230 2190 -5210 {}
L 6 2190 -5470 2190 -5290 {}
L 6 2430 -5320 2430 -5210 {}
L 6 2430 -5210 2520 -5210 {}
L 6 2190 -5210 2430 -5210 {}
L 6 600 -7150 720 -7150 {}
L 6 760 -7210 760 -7180 {}
L 6 760 -7300 760 -7270 {}
L 6 760 -7180 900 -7180 {}
L 6 850 -7120 850 -7040 {}
L 6 520 -7060 520 -7040 {}
L 6 520 -7300 520 -7120 {}
L 6 760 -7150 760 -7040 {}
L 6 760 -7040 850 -7040 {}
L 6 520 -7040 760 -7040 {}
L 6 1140 -7150 1260 -7150 {}
L 6 1300 -7210 1300 -7180 {}
L 6 1300 -7300 1300 -7270 {}
L 6 1300 -7180 1440 -7180 {}
L 6 1390 -7120 1390 -7040 {}
L 6 1060 -7060 1060 -7040 {}
L 6 1060 -7300 1060 -7120 {}
L 6 1300 -7150 1300 -7040 {}
L 6 1300 -7040 1390 -7040 {}
L 6 1060 -7040 1300 -7040 {}
L 6 2270 -7150 2390 -7150 {}
L 6 2430 -7210 2430 -7180 {}
L 6 2430 -7300 2430 -7270 {}
L 6 2430 -7180 2570 -7180 {}
L 6 2520 -7120 2520 -7040 {}
L 6 2190 -7060 2190 -7040 {}
L 6 2190 -7300 2190 -7120 {}
L 6 2430 -7150 2430 -7040 {}
L 6 2430 -7040 2520 -7040 {}
L 6 2190 -7040 2430 -7040 {}
L 6 600 -4940 720 -4940 {}
L 6 760 -5000 760 -4970 {}
L 6 760 -5090 760 -5060 {}
L 6 760 -4970 900 -4970 {}
L 6 520 -4850 520 -4830 {}
L 6 760 -4940 760 -4830 {}
L 6 760 -4830 850 -4830 {}
L 6 520 -4830 760 -4830 {}
L 6 1140 -4560 1260 -4560 {}
L 6 1300 -4590 1440 -4590 {}
L 6 1390 -4530 1390 -4450 {}
L 6 1060 -4470 1060 -4450 {}
L 6 1300 -4560 1300 -4450 {}
L 6 1300 -4450 1390 -4450 {}
L 6 1060 -4450 1300 -4450 {}
L 6 2240 -4560 2360 -4560 {}
L 6 2400 -4590 2540 -4590 {}
L 6 2490 -4530 2490 -4450 {}
L 6 2160 -4470 2160 -4450 {}
L 6 2400 -4560 2400 -4450 {}
L 6 2400 -4450 2490 -4450 {}
L 6 2160 -4450 2400 -4450 {}
L 6 1680 -4560 1800 -4560 {}
L 6 1840 -4590 1980 -4590 {}
L 6 1930 -4530 1930 -4450 {}
L 6 1600 -4470 1600 -4450 {}
L 6 1840 -4560 1840 -4450 {}
L 6 1840 -4450 1930 -4450 {}
L 6 1600 -4450 1840 -4450 {}
L 6 690 -2790 690 -2610 {}
L 6 1230 -2790 1230 -2610 {}
L 6 1880 -2790 1880 -2730 {}
L 6 1880 -2670 1880 -2610 {}
L 6 1110 -9290 1230 -9290 {}
L 6 1030 -9440 1270 -9440 {}
L 6 1270 -9320 1410 -9320 {}
L 6 1030 -9180 1270 -9180 {}
L 6 1030 -9200 1030 -9180 {}
L 6 1030 -9440 1030 -9260 {}
L 6 660 -190 780 -190 {}
L 6 820 -250 820 -220 {}
L 6 820 -340 820 -310 {}
L 6 580 -340 820 -340 {}
L 6 820 -220 960 -220 {}
L 6 910 -160 910 -80 {}
L 6 580 -100 580 -80 {}
L 6 580 -340 580 -160 {}
L 6 820 -190 820 -80 {}
L 6 820 -80 910 -80 {}
L 6 580 -80 820 -80 {}
L 6 1310 -190 1430 -190 {}
L 6 1470 -250 1470 -220 {}
L 6 1470 -340 1470 -310 {}
L 6 1230 -340 1470 -340 {}
L 6 1230 -340 1230 -160 {}
L 6 1140 -4940 1260 -4940 {}
L 6 1300 -5000 1300 -4970 {}
L 6 1300 -5090 1300 -5060 {}
L 6 1300 -4970 1440 -4970 {}
L 6 1060 -4850 1060 -4830 {}
L 6 1300 -4940 1300 -4830 {}
L 6 1300 -4830 1390 -4830 {}
L 6 1060 -4830 1300 -4830 {}
L 6 1700 -4940 1820 -4940 {}
L 6 1860 -5000 1860 -4970 {}
L 6 1860 -5090 1860 -5060 {}
L 6 1860 -4970 2000 -4970 {}
L 6 1620 -4850 1620 -4830 {}
L 6 1860 -4940 1860 -4830 {}
L 6 1860 -4830 1950 -4830 {}
L 6 1620 -4830 1860 -4830 {}
L 6 2270 -4940 2390 -4940 {}
L 6 2430 -5000 2430 -4970 {}
L 6 2430 -5090 2430 -5060 {}
L 6 2430 -4970 2570 -4970 {}
L 6 2190 -4850 2190 -4830 {}
L 6 2430 -4940 2430 -4830 {}
L 6 2430 -4830 2520 -4830 {}
L 6 2190 -4830 2430 -4830 {}
L 6 1870 -190 1990 -190 {}
L 6 2030 -250 2030 -220 {}
L 6 2030 -340 2030 -310 {}
L 6 1790 -340 2030 -340 {}
L 6 1790 -340 1790 -160 {}
L 6 600 -4560 720 -4560 {}
L 6 760 -4590 900 -4590 {}
L 6 850 -4530 850 -4450 {}
L 6 520 -4470 520 -4450 {}
L 6 760 -4560 760 -4450 {}
L 6 760 -4450 850 -4450 {}
L 6 520 -4450 760 -4450 {}
L 9 0 -5570 2670 -5570 {dash=4}
L 9 0 -6100 2670 -6100 {dash=4}
L 9 0 -6580 2670 -6580 {dash=4}
L 9 0 -7770 2670 -7770 {dash=4}
L 9 0 -8600 2670 -8600 {dash=4}
L 9 0 -8210 2670 -8210 {dash=4}
L 9 0 -9050 2670 -9050 {dash=4}
L 9 0 -3660 2670 -3660 {dash=4}
L 9 0 -4040 2670 -4040 {dash=4}
L 9 0 -4390 2670 -4390 {dash=4}
L 9 0 -4800 2670 -4800 {dash=4}
L 9 0 -5170 2670 -5170 {dash=4}
L 9 0 -3240 2670 -3240 {dash=4}
L 9 0 -2860 2670 -2860 {dash=4}
L 9 0 -830 2670 -830 {dash=4}
L 9 0 -2540 2670 -2540 {dash=4}
L 9 0 -1600 2670 -1600 {dash=4}
L 9 0 -1230 2670 -1230 {dash=4}
L 9 0 -430 2670 -430 {dash=4}
L 9 0 0 2670 0 {dash=4}
L 9 0 -2310 2670 -2310 {dash=4}
L 9 0 -1940 2670 -1940 {dash=4}
L 9 0 -6990 2670 -6990 {dash=4}
L 9 0 -7420 2670 -7420 {dash=4}
B 1 1790 -7210 1820 -7060 {}
B 2 660 -8990 860 -8670 {}
B 2 1267.5 -8852.5 1272.5 -8847.5 {name=d dir=inout}
B 2 1227.5 -8822.5 1232.5 -8817.5 {name=g dir=in}
B 2 1267.5 -8792.5 1272.5 -8787.5 {name=s dir=inout}
B 2 1267.5 -8822.5 1272.5 -8817.5 {name=b dir=in}
B 2 1267.5 -8942.5 1272.5 -8937.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -8882.5 1272.5 -8877.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -8852.5 1362.5 -8847.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -8792.5 1362.5 -8787.5 {name=m dir=inout pinnumber=2}
B 2 2047.5 -8862.5 2052.5 -8857.5 {name=d dir=inout}
B 2 2007.5 -8832.5 2012.5 -8827.5 {name=g dir=in}
B 2 2047.5 -8802.5 2052.5 -8797.5 {name=s dir=inout}
B 2 2047.5 -8832.5 2052.5 -8827.5 {name=b dir=in}
B 2 2047.5 -8952.5 2052.5 -8947.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2047.5 -8892.5 2052.5 -8887.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2137.5 -8862.5 2142.5 -8857.5 {name=p dir=inout pinnumber=1}
B 2 2137.5 -8802.5 2142.5 -8797.5 {name=m dir=inout pinnumber=2}
B 2 1357.5 -8482.5 1362.5 -8477.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -8422.5 1362.5 -8417.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -6862.5 1362.5 -6857.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -6802.5 1362.5 -6797.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -6372.5 1362.5 -6367.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -6312.5 1362.5 -6307.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 660 -5940 900 -5620 {}
B 2 737.5 -8852.5 742.5 -8847.5 {name=d dir=inout}
B 2 737.5 -8792.5 742.5 -8787.5 {name=s dir=inout}
B 2 737.5 -8822.5 742.5 -8817.5 {name=b dir=in}
B 2 737.5 -8942.5 742.5 -8937.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -8882.5 742.5 -8877.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -8852.5 832.5 -8847.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -8792.5 832.5 -8787.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -5792.5 742.5 -5787.5 {name=d dir=inout}
B 2 737.5 -5732.5 742.5 -5727.5 {name=s dir=inout}
B 2 737.5 -5762.5 742.5 -5757.5 {name=b dir=in}
B 2 737.5 -5882.5 742.5 -5877.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -5822.5 742.5 -5817.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -5792.5 832.5 -5787.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -5732.5 832.5 -5727.5 {name=m dir=inout pinnumber=2}
B 2 878.75 -5791.25 881.25 -5788.75 {name=p dir=in}
B 2 1277.5 -5792.5 1282.5 -5787.5 {name=d dir=inout}
B 2 1237.5 -5762.5 1242.5 -5757.5 {name=g dir=in}
B 2 1277.5 -5732.5 1282.5 -5727.5 {name=s dir=inout}
B 2 1277.5 -5762.5 1282.5 -5757.5 {name=b dir=in}
B 2 1277.5 -5882.5 1282.5 -5877.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1277.5 -5822.5 1282.5 -5817.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1367.5 -5792.5 1372.5 -5787.5 {name=p dir=inout pinnumber=1}
B 2 1367.5 -5732.5 1372.5 -5727.5 {name=m dir=inout pinnumber=2}
B 2 1418.75 -5791.25 1421.25 -5788.75 {name=p dir=in}
B 2 2117.5 -5792.5 2122.5 -5787.5 {name=d dir=inout}
B 2 2077.5 -5762.5 2082.5 -5757.5 {name=g dir=in}
B 2 2117.5 -5732.5 2122.5 -5727.5 {name=s dir=inout}
B 2 2117.5 -5762.5 2122.5 -5757.5 {name=b dir=in}
B 2 2117.5 -5882.5 2122.5 -5877.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2117.5 -5822.5 2122.5 -5817.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2207.5 -5792.5 2212.5 -5787.5 {name=p dir=inout pinnumber=1}
B 2 2207.5 -5732.5 2212.5 -5727.5 {name=m dir=inout pinnumber=2}
B 2 2258.75 -5791.25 2261.25 -5788.75 {name=p dir=in}
B 2 660 -8160 860 -7840 {}
B 2 1267.5 -8022.5 1272.5 -8017.5 {name=d dir=inout}
B 2 1227.5 -7992.5 1232.5 -7987.5 {name=g dir=in}
B 2 1267.5 -7962.5 1272.5 -7957.5 {name=s dir=inout}
B 2 1267.5 -7992.5 1272.5 -7987.5 {name=b dir=in}
B 2 1267.5 -8112.5 1272.5 -8107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -8052.5 1272.5 -8047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -8022.5 1362.5 -8017.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -7962.5 1362.5 -7957.5 {name=m dir=inout pinnumber=2}
B 2 2047.5 -8032.5 2052.5 -8027.5 {name=d dir=inout}
B 2 2007.5 -8002.5 2012.5 -7997.5 {name=g dir=in}
B 2 2047.5 -7972.5 2052.5 -7967.5 {name=s dir=inout}
B 2 2047.5 -8002.5 2052.5 -7997.5 {name=b dir=in}
B 2 2047.5 -8122.5 2052.5 -8117.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2047.5 -8062.5 2052.5 -8057.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2137.5 -8032.5 2142.5 -8027.5 {name=p dir=inout pinnumber=1}
B 2 2137.5 -7972.5 2142.5 -7967.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -8022.5 742.5 -8017.5 {name=d dir=inout}
B 2 737.5 -7962.5 742.5 -7957.5 {name=s dir=inout}
B 2 737.5 -7992.5 742.5 -7987.5 {name=b dir=in}
B 2 737.5 -8112.5 742.5 -8107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -8052.5 742.5 -8047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -8022.5 832.5 -8017.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -7962.5 832.5 -7957.5 {name=m dir=inout pinnumber=2}
B 2 660 -9460 860 -9140 {}
B 2 1807.5 -9322.5 1812.5 -9317.5 {name=d dir=inout}
B 2 1767.5 -9292.5 1772.5 -9287.5 {name=g dir=in}
B 2 1807.5 -9262.5 1812.5 -9257.5 {name=s dir=inout}
B 2 1807.5 -9292.5 1812.5 -9287.5 {name=b dir=in}
B 2 1807.5 -9412.5 1812.5 -9407.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1807.5 -9352.5 1812.5 -9347.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -9322.5 1902.5 -9317.5 {name=p dir=inout pinnumber=1}
B 2 1897.5 -9262.5 1902.5 -9257.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -9322.5 742.5 -9317.5 {name=d dir=inout}
B 2 737.5 -9262.5 742.5 -9257.5 {name=s dir=inout}
B 2 737.5 -9292.5 742.5 -9287.5 {name=b dir=in}
B 2 737.5 -9412.5 742.5 -9407.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -9352.5 742.5 -9347.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -9322.5 832.5 -9317.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -9262.5 832.5 -9257.5 {name=m dir=inout pinnumber=2}
B 2 1530 -9450 1610 -9170 {}
B 2 1567.5 -9262.5 1572.5 -9257.5 {name=p dir=inout}
B 2 1567.5 -9202.5 1572.5 -9197.5 {name=m dir=inout}
B 2 2267.5 -9322.5 2272.5 -9317.5 {name=d dir=inout}
B 2 2227.5 -9292.5 2232.5 -9287.5 {name=g dir=in}
B 2 2267.5 -9262.5 2272.5 -9257.5 {name=s dir=inout}
B 2 2267.5 -9292.5 2272.5 -9287.5 {name=b dir=in}
B 2 2267.5 -9412.5 2272.5 -9407.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2267.5 -9352.5 2272.5 -9347.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2027.5 -9262.5 2032.5 -9257.5 {name=p dir=inout}
B 2 2027.5 -9202.5 2032.5 -9197.5 {name=m dir=inout}
B 2 2320 -9340 2390 -9160 {}
B 2 1670 -7240 1820 -7210 {}
B 2 1000 -4750 1340 -4600 {}
B 2 1297.5 -4682.5 1302.5 -4677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1297.5 -4622.5 1302.5 -4617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1167.5 -4712.5 1172.5 -4707.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 2397.5 -4712.5 2402.5 -4707.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2397.5 -4652.5 2402.5 -4647.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2267.5 -4742.5 2272.5 -4737.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1837.5 -4682.5 1842.5 -4677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1837.5 -4622.5 1842.5 -4617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1707.5 -4712.5 1712.5 -4707.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1357.5 -3822.5 1362.5 -3817.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -3762.5 1362.5 -3757.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -4142.5 1362.5 -4137.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -4202.5 1362.5 -4197.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -4142.5 1362.5 -4137.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -4202.5 1362.5 -4197.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1777.5 -4142.5 1782.5 -4137.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1777.5 -4202.5 1782.5 -4197.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1210 -3150 1500 -3080 {}
B 2 1210 -1070 1500 -990 {}
B 2 1247.5 -1062.5 1252.5 -1057.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1247.5 -1002.5 1252.5 -997.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -1062.5 1362.5 -1057.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -1002.5 1362.5 -997.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1467.5 -1062.5 1472.5 -1057.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1467.5 -1002.5 1472.5 -997.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1787.5 -1112.5 1792.5 -1107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1787.5 -1052.5 1792.5 -1047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -1112.5 1902.5 -1107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1897.5 -1052.5 1902.5 -1047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2007.5 -1112.5 2012.5 -1107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2007.5 -1052.5 2012.5 -1047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 647.5 -2732.5 652.5 -2727.5 {name=d dir=inout}
B 2 607.5 -2702.5 612.5 -2697.5 {name=g dir=in}
B 2 647.5 -2672.5 652.5 -2667.5 {name=s dir=inout}
B 2 647.5 -2702.5 652.5 -2697.5 {name=b dir=in}
B 2 1227.5 -2732.5 1232.5 -2727.5 {name=d dir=inout}
B 2 1187.5 -2702.5 1192.5 -2697.5 {name=g dir=in}
B 2 1227.5 -2672.5 1232.5 -2667.5 {name=s dir=inout}
B 2 1227.5 -2702.5 1232.5 -2697.5 {name=b dir=in}
B 2 1267.5 -9322.5 1272.5 -9317.5 {name=d dir=inout}
B 2 1227.5 -9292.5 1232.5 -9287.5 {name=g dir=in}
B 2 1267.5 -9262.5 1272.5 -9257.5 {name=s dir=inout}
B 2 1267.5 -9292.5 1272.5 -9287.5 {name=b dir=in}
B 2 1267.5 -9412.5 1272.5 -9407.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -9352.5 1272.5 -9347.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -9322.5 1362.5 -9317.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -9262.5 1362.5 -9257.5 {name=m dir=inout pinnumber=2}
B 2 1210 -690 1500 -610 {}
B 2 1247.5 -682.5 1252.5 -677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1247.5 -622.5 1252.5 -617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -682.5 1362.5 -677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -622.5 1362.5 -617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1467.5 -682.5 1472.5 -677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1467.5 -622.5 1472.5 -617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1787.5 -732.5 1792.5 -727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1787.5 -672.5 1792.5 -667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -732.5 1902.5 -727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1897.5 -672.5 1902.5 -667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2007.5 -732.5 2012.5 -727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2007.5 -672.5 2012.5 -667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 677.5 -1502.5 682.5 -1497.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 677.5 -1442.5 682.5 -1437.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 797.5 -1502.5 802.5 -1497.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1217.5 -1502.5 1222.5 -1497.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1217.5 -1442.5 1222.5 -1437.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1337.5 -1502.5 1342.5 -1497.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1337.5 -1442.5 1342.5 -1437.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1557.5 -222.5 1562.5 -217.5 {name=p dir=inout pinnumber=1}
B 2 1557.5 -162.5 1562.5 -157.5 {name=m dir=inout pinnumber=2}
B 2 2427.5 -402.5 2432.5 -397.5 {name=p dir=inout pinnumber=1}
B 2 2427.5 -342.5 2432.5 -337.5 {name=m dir=inout pinnumber=2}
B 2 757.5 -4682.5 762.5 -4677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 757.5 -4622.5 762.5 -4617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 627.5 -4712.5 632.5 -4707.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1027.5 -8792.5 1032.5 -8787.5 {name=p dir=inout}
B 5 1027.5 -8732.5 1032.5 -8727.5 {name=m dir=inout}
B 5 1108.75 -8821.25 1111.25 -8818.75 {name=p dir=out}
B 5 1137.5 -8712.5 1142.5 -8707.5 {name=p dir=inout goto=0}
B 5 1137.5 -8972.5 1142.5 -8967.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -8851.25 1411.25 -8848.75 {name=p dir=in}
B 5 1567.5 -8792.5 1572.5 -8787.5 {name=p dir=inout}
B 5 1567.5 -8732.5 1572.5 -8727.5 {name=m dir=inout}
B 5 1648.75 -8821.25 1651.25 -8818.75 {name=p dir=out}
B 5 1677.5 -8712.5 1682.5 -8707.5 {name=p dir=inout goto=0}
B 5 1677.5 -8972.5 1682.5 -8967.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1948.75 -8851.25 1951.25 -8848.75 {name=p dir=in}
B 5 697.5 -8822.5 702.5 -8817.5 {name=g dir=in}
B 5 497.5 -8792.5 502.5 -8787.5 {name=p dir=inout}
B 5 497.5 -8732.5 502.5 -8727.5 {name=m dir=inout}
B 5 578.75 -8821.25 581.25 -8818.75 {name=p dir=out}
B 5 607.5 -8712.5 612.5 -8707.5 {name=p dir=inout goto=0}
B 5 607.5 -8972.5 612.5 -8967.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -8851.25 881.25 -8848.75 {name=p dir=in}
B 5 737.5 -8392.5 742.5 -8387.5 {name=d dir=inout}
B 5 697.5 -8362.5 702.5 -8357.5 {name=g dir=in}
B 5 737.5 -8332.5 742.5 -8327.5 {name=s dir=inout}
B 5 737.5 -8362.5 742.5 -8357.5 {name=b dir=in}
B 5 737.5 -8482.5 742.5 -8477.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -8422.5 742.5 -8417.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -8392.5 832.5 -8387.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -8332.5 832.5 -8327.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -8332.5 502.5 -8327.5 {name=p dir=inout}
B 5 497.5 -8272.5 502.5 -8267.5 {name=m dir=inout}
B 5 578.75 -8361.25 581.25 -8358.75 {name=p dir=out}
B 5 607.5 -8252.5 612.5 -8247.5 {name=p dir=inout goto=0}
B 5 607.5 -8512.5 612.5 -8507.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -8391.25 881.25 -8388.75 {name=p dir=in}
B 5 1277.5 -8392.5 1282.5 -8387.5 {name=d dir=inout}
B 5 1237.5 -8362.5 1242.5 -8357.5 {name=g dir=in}
B 5 1277.5 -8332.5 1282.5 -8327.5 {name=s dir=inout}
B 5 1277.5 -8362.5 1282.5 -8357.5 {name=b dir=in}
B 5 1367.5 -8392.5 1372.5 -8387.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -8332.5 1372.5 -8327.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -8332.5 1042.5 -8327.5 {name=p dir=inout}
B 5 1037.5 -8272.5 1042.5 -8267.5 {name=m dir=inout}
B 5 1118.75 -8361.25 1121.25 -8358.75 {name=p dir=out}
B 5 1147.5 -8252.5 1152.5 -8247.5 {name=p dir=inout goto=0}
B 5 1147.5 -8512.5 1152.5 -8507.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -8391.25 1421.25 -8388.75 {name=p dir=in}
B 5 737.5 -6772.5 742.5 -6767.5 {name=d dir=inout}
B 5 697.5 -6742.5 702.5 -6737.5 {name=g dir=in}
B 5 737.5 -6712.5 742.5 -6707.5 {name=s dir=inout}
B 5 737.5 -6742.5 742.5 -6737.5 {name=b dir=in}
B 5 737.5 -6862.5 742.5 -6857.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -6802.5 742.5 -6797.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -6772.5 832.5 -6767.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -6712.5 832.5 -6707.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -6712.5 502.5 -6707.5 {name=p dir=inout}
B 5 497.5 -6652.5 502.5 -6647.5 {name=m dir=inout}
B 5 578.75 -6741.25 581.25 -6738.75 {name=p dir=out}
B 5 607.5 -6632.5 612.5 -6627.5 {name=p dir=inout goto=0}
B 5 607.5 -6892.5 612.5 -6887.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -6771.25 881.25 -6768.75 {name=p dir=in}
B 5 1277.5 -6772.5 1282.5 -6767.5 {name=d dir=inout}
B 5 1237.5 -6742.5 1242.5 -6737.5 {name=g dir=in}
B 5 1277.5 -6712.5 1282.5 -6707.5 {name=s dir=inout}
B 5 1277.5 -6742.5 1282.5 -6737.5 {name=b dir=in}
B 5 1367.5 -6772.5 1372.5 -6767.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -6712.5 1372.5 -6707.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -6712.5 1042.5 -6707.5 {name=p dir=inout}
B 5 1037.5 -6652.5 1042.5 -6647.5 {name=m dir=inout}
B 5 1118.75 -6741.25 1121.25 -6738.75 {name=p dir=out}
B 5 1147.5 -6632.5 1152.5 -6627.5 {name=p dir=inout goto=0}
B 5 1147.5 -6892.5 1152.5 -6887.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -6771.25 1421.25 -6768.75 {name=p dir=in}
B 5 737.5 -6282.5 742.5 -6277.5 {name=d dir=inout}
B 5 697.5 -6252.5 702.5 -6247.5 {name=g dir=in}
B 5 737.5 -6222.5 742.5 -6217.5 {name=s dir=inout}
B 5 737.5 -6252.5 742.5 -6247.5 {name=b dir=in}
B 5 737.5 -6372.5 742.5 -6367.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -6312.5 742.5 -6307.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -6282.5 832.5 -6277.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -6222.5 832.5 -6217.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -6222.5 502.5 -6217.5 {name=p dir=inout}
B 5 497.5 -6162.5 502.5 -6157.5 {name=m dir=inout}
B 5 578.75 -6251.25 581.25 -6248.75 {name=p dir=out}
B 5 607.5 -6142.5 612.5 -6137.5 {name=p dir=inout goto=0}
B 5 607.5 -6402.5 612.5 -6397.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -6281.25 881.25 -6278.75 {name=p dir=in}
B 5 1277.5 -6282.5 1282.5 -6277.5 {name=d dir=inout}
B 5 1237.5 -6252.5 1242.5 -6247.5 {name=g dir=in}
B 5 1277.5 -6222.5 1282.5 -6217.5 {name=s dir=inout}
B 5 1277.5 -6252.5 1282.5 -6247.5 {name=b dir=in}
B 5 1367.5 -6282.5 1372.5 -6277.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -6222.5 1372.5 -6217.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -6222.5 1042.5 -6217.5 {name=p dir=inout}
B 5 1037.5 -6162.5 1042.5 -6157.5 {name=m dir=inout}
B 5 1118.75 -6251.25 1121.25 -6248.75 {name=p dir=out}
B 5 1147.5 -6142.5 1152.5 -6137.5 {name=p dir=inout goto=0}
B 5 1147.5 -6402.5 1152.5 -6397.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -6281.25 1421.25 -6278.75 {name=p dir=in}
B 5 697.5 -5762.5 702.5 -5757.5 {name=g dir=in}
B 5 497.5 -5732.5 502.5 -5727.5 {name=p dir=inout}
B 5 497.5 -5672.5 502.5 -5667.5 {name=m dir=inout}
B 5 578.75 -5761.25 581.25 -5758.75 {name=p dir=out}
B 5 607.5 -5652.5 612.5 -5647.5 {name=p dir=inout goto=0}
B 5 607.5 -5912.5 612.5 -5907.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1687.5 -5732.5 1692.5 -5727.5 {name=p dir=inout}
B 5 1687.5 -5672.5 1692.5 -5667.5 {name=m dir=inout}
B 5 1768.75 -5761.25 1771.25 -5758.75 {name=p dir=out}
B 5 1797.5 -5652.5 1802.5 -5647.5 {name=p dir=inout goto=0}
B 5 1797.5 -5912.5 1802.5 -5907.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1037.5 -5732.5 1042.5 -5727.5 {name=p dir=inout}
B 5 1037.5 -5672.5 1042.5 -5667.5 {name=m dir=inout}
B 5 1118.75 -5761.25 1121.25 -5758.75 {name=p dir=out}
B 5 1147.5 -5652.5 1152.5 -5647.5 {name=p dir=inout goto=0}
B 5 1147.5 -5912.5 1152.5 -5907.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1027.5 -7962.5 1032.5 -7957.5 {name=p dir=inout}
B 5 1027.5 -7902.5 1032.5 -7897.5 {name=m dir=inout}
B 5 1108.75 -7991.25 1111.25 -7988.75 {name=p dir=out}
B 5 1137.5 -7882.5 1142.5 -7877.5 {name=p dir=inout goto=0}
B 5 1137.5 -8142.5 1142.5 -8137.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -8021.25 1411.25 -8018.75 {name=p dir=in}
B 5 697.5 -7992.5 702.5 -7987.5 {name=g dir=in}
B 5 497.5 -7962.5 502.5 -7957.5 {name=p dir=inout}
B 5 497.5 -7902.5 502.5 -7897.5 {name=m dir=inout}
B 5 578.75 -7991.25 581.25 -7988.75 {name=p dir=out}
B 5 607.5 -7882.5 612.5 -7877.5 {name=p dir=inout goto=0}
B 5 607.5 -8142.5 612.5 -8137.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -8021.25 881.25 -8018.75 {name=p dir=in}
B 5 1767.5 -8022.5 1772.5 -8017.5 {name=d dir=inout}
B 5 1727.5 -7992.5 1732.5 -7987.5 {name=g dir=in}
B 5 1767.5 -7962.5 1772.5 -7957.5 {name=s dir=inout}
B 5 1767.5 -7992.5 1772.5 -7987.5 {name=b dir=in}
B 5 1767.5 -8112.5 1772.5 -8107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1767.5 -8052.5 1772.5 -8047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1857.5 -8022.5 1862.5 -8017.5 {name=p dir=inout pinnumber=1}
B 5 1857.5 -7962.5 1862.5 -7957.5 {name=m dir=inout pinnumber=2}
B 5 1527.5 -7962.5 1532.5 -7957.5 {name=p dir=inout}
B 5 1527.5 -7902.5 1532.5 -7897.5 {name=m dir=inout}
B 5 1608.75 -7991.25 1611.25 -7988.75 {name=p dir=out}
B 5 1637.5 -7882.5 1642.5 -7877.5 {name=p dir=inout goto=0}
B 5 1637.5 -8142.5 1642.5 -8137.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1908.75 -8021.25 1911.25 -8018.75 {name=p dir=in}
B 5 1648.75 -9291.25 1651.25 -9288.75 {name=p dir=out}
B 5 1677.5 -9182.5 1682.5 -9177.5 {name=p dir=inout goto=0}
B 5 1677.5 -9442.5 1682.5 -9437.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1948.75 -9321.25 1951.25 -9318.75 {name=p dir=in}
B 5 697.5 -9292.5 702.5 -9287.5 {name=g dir=in}
B 5 497.5 -9262.5 502.5 -9257.5 {name=p dir=inout}
B 5 497.5 -9202.5 502.5 -9197.5 {name=m dir=inout}
B 5 578.75 -9291.25 581.25 -9288.75 {name=p dir=out}
B 5 607.5 -9182.5 612.5 -9177.5 {name=p dir=inout goto=0}
B 5 607.5 -9442.5 612.5 -9437.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -9321.25 881.25 -9318.75 {name=p dir=in}
B 5 2108.75 -9291.25 2111.25 -9288.75 {name=p dir=out}
B 5 2137.5 -9182.5 2142.5 -9177.5 {name=p dir=inout goto=0}
B 5 2137.5 -9442.5 2142.5 -9437.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2408.75 -9321.25 2411.25 -9318.75 {name=p dir=in}
B 5 2357.5 -9322.5 2362.5 -9317.5 {name=p dir=inout pinnumber=1}
B 5 2357.5 -9262.5 2362.5 -9257.5 {name=m dir=inout pinnumber=2}
B 5 757.5 -5352.5 762.5 -5347.5 {name=d dir=inout}
B 5 717.5 -5322.5 722.5 -5317.5 {name=g dir=in}
B 5 757.5 -5292.5 762.5 -5287.5 {name=s dir=inout}
B 5 757.5 -5322.5 762.5 -5317.5 {name=b dir=in}
B 5 757.5 -5442.5 762.5 -5437.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -5382.5 762.5 -5377.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 847.5 -5352.5 852.5 -5347.5 {name=p dir=inout pinnumber=1}
B 5 847.5 -5292.5 852.5 -5287.5 {name=m dir=inout pinnumber=2}
B 5 517.5 -5292.5 522.5 -5287.5 {name=p dir=inout}
B 5 517.5 -5232.5 522.5 -5227.5 {name=m dir=inout}
B 5 598.75 -5321.25 601.25 -5318.75 {name=p dir=out}
B 5 627.5 -5212.5 632.5 -5207.5 {name=p dir=inout goto=0}
B 5 627.5 -5472.5 632.5 -5467.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 898.75 -5351.25 901.25 -5348.75 {name=p dir=in}
B 5 1297.5 -5352.5 1302.5 -5347.5 {name=d dir=inout}
B 5 1257.5 -5322.5 1262.5 -5317.5 {name=g dir=in}
B 5 1297.5 -5292.5 1302.5 -5287.5 {name=s dir=inout}
B 5 1297.5 -5322.5 1302.5 -5317.5 {name=b dir=in}
B 5 1297.5 -5442.5 1302.5 -5437.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1297.5 -5382.5 1302.5 -5377.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1387.5 -5352.5 1392.5 -5347.5 {name=p dir=inout pinnumber=1}
B 5 1387.5 -5292.5 1392.5 -5287.5 {name=m dir=inout pinnumber=2}
B 5 1057.5 -5292.5 1062.5 -5287.5 {name=p dir=inout}
B 5 1057.5 -5232.5 1062.5 -5227.5 {name=m dir=inout}
B 5 1138.75 -5321.25 1141.25 -5318.75 {name=p dir=out}
B 5 1167.5 -5212.5 1172.5 -5207.5 {name=p dir=inout goto=0}
B 5 1167.5 -5472.5 1172.5 -5467.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1438.75 -5351.25 1441.25 -5348.75 {name=p dir=in}
B 5 1857.5 -5352.5 1862.5 -5347.5 {name=d dir=inout}
B 5 1817.5 -5322.5 1822.5 -5317.5 {name=g dir=in}
B 5 1857.5 -5292.5 1862.5 -5287.5 {name=s dir=inout}
B 5 1857.5 -5322.5 1862.5 -5317.5 {name=b dir=in}
B 5 1857.5 -5442.5 1862.5 -5437.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1857.5 -5382.5 1862.5 -5377.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1947.5 -5352.5 1952.5 -5347.5 {name=p dir=inout pinnumber=1}
B 5 1947.5 -5292.5 1952.5 -5287.5 {name=m dir=inout pinnumber=2}
B 5 1617.5 -5292.5 1622.5 -5287.5 {name=p dir=inout}
B 5 1617.5 -5232.5 1622.5 -5227.5 {name=m dir=inout}
B 5 1698.75 -5321.25 1701.25 -5318.75 {name=p dir=out}
B 5 1727.5 -5212.5 1732.5 -5207.5 {name=p dir=inout goto=0}
B 5 1727.5 -5472.5 1732.5 -5467.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1998.75 -5351.25 2001.25 -5348.75 {name=p dir=in}
B 5 2427.5 -5352.5 2432.5 -5347.5 {name=d dir=inout}
B 5 2387.5 -5322.5 2392.5 -5317.5 {name=g dir=in}
B 5 2427.5 -5292.5 2432.5 -5287.5 {name=s dir=inout}
B 5 2427.5 -5322.5 2432.5 -5317.5 {name=b dir=in}
B 5 2427.5 -5442.5 2432.5 -5437.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -5382.5 2432.5 -5377.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2517.5 -5352.5 2522.5 -5347.5 {name=p dir=inout pinnumber=1}
B 5 2517.5 -5292.5 2522.5 -5287.5 {name=m dir=inout pinnumber=2}
B 5 2187.5 -5292.5 2192.5 -5287.5 {name=p dir=inout}
B 5 2187.5 -5232.5 2192.5 -5227.5 {name=m dir=inout}
B 5 2268.75 -5321.25 2271.25 -5318.75 {name=p dir=out}
B 5 2297.5 -5212.5 2302.5 -5207.5 {name=p dir=inout goto=0}
B 5 2297.5 -5472.5 2302.5 -5467.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2568.75 -5351.25 2571.25 -5348.75 {name=p dir=in}
B 5 757.5 -7182.5 762.5 -7177.5 {name=d dir=inout}
B 5 717.5 -7152.5 722.5 -7147.5 {name=g dir=in}
B 5 757.5 -7122.5 762.5 -7117.5 {name=s dir=inout}
B 5 757.5 -7152.5 762.5 -7147.5 {name=b dir=in}
B 5 757.5 -7272.5 762.5 -7267.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -7212.5 762.5 -7207.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 847.5 -7182.5 852.5 -7177.5 {name=p dir=inout pinnumber=1}
B 5 847.5 -7122.5 852.5 -7117.5 {name=m dir=inout pinnumber=2}
B 5 517.5 -7122.5 522.5 -7117.5 {name=p dir=inout}
B 5 517.5 -7062.5 522.5 -7057.5 {name=m dir=inout}
B 5 598.75 -7151.25 601.25 -7148.75 {name=p dir=out}
B 5 627.5 -7042.5 632.5 -7037.5 {name=p dir=inout goto=0}
B 5 627.5 -7302.5 632.5 -7297.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 898.75 -7181.25 901.25 -7178.75 {name=p dir=in}
B 5 1297.5 -7182.5 1302.5 -7177.5 {name=d dir=inout}
B 5 1257.5 -7152.5 1262.5 -7147.5 {name=g dir=in}
B 5 1297.5 -7122.5 1302.5 -7117.5 {name=s dir=inout}
B 5 1297.5 -7152.5 1302.5 -7147.5 {name=b dir=in}
B 5 1297.5 -7272.5 1302.5 -7267.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1297.5 -7212.5 1302.5 -7207.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1387.5 -7182.5 1392.5 -7177.5 {name=p dir=inout pinnumber=1}
B 5 1387.5 -7122.5 1392.5 -7117.5 {name=m dir=inout pinnumber=2}
B 5 1057.5 -7122.5 1062.5 -7117.5 {name=p dir=inout}
B 5 1057.5 -7062.5 1062.5 -7057.5 {name=m dir=inout}
B 5 1138.75 -7151.25 1141.25 -7148.75 {name=p dir=out}
B 5 1167.5 -7042.5 1172.5 -7037.5 {name=p dir=inout goto=0}
B 5 1167.5 -7302.5 1172.5 -7297.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1438.75 -7181.25 1441.25 -7178.75 {name=p dir=in}
B 5 2427.5 -7182.5 2432.5 -7177.5 {name=d dir=inout}
B 5 2387.5 -7152.5 2392.5 -7147.5 {name=g dir=in}
B 5 2427.5 -7122.5 2432.5 -7117.5 {name=s dir=inout}
B 5 2427.5 -7152.5 2432.5 -7147.5 {name=b dir=in}
B 5 2427.5 -7272.5 2432.5 -7267.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -7212.5 2432.5 -7207.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2517.5 -7182.5 2522.5 -7177.5 {name=p dir=inout pinnumber=1}
B 5 2517.5 -7122.5 2522.5 -7117.5 {name=m dir=inout pinnumber=2}
B 5 2187.5 -7122.5 2192.5 -7117.5 {name=p dir=inout}
B 5 2187.5 -7062.5 2192.5 -7057.5 {name=m dir=inout}
B 5 2268.75 -7151.25 2271.25 -7148.75 {name=p dir=out}
B 5 2297.5 -7042.5 2302.5 -7037.5 {name=p dir=inout goto=0}
B 5 2297.5 -7302.5 2302.5 -7297.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2568.75 -7181.25 2571.25 -7178.75 {name=p dir=in}
B 5 757.5 -4972.5 762.5 -4967.5 {name=d dir=inout}
B 5 717.5 -4942.5 722.5 -4937.5 {name=g dir=in}
B 5 757.5 -4912.5 762.5 -4907.5 {name=s dir=inout}
B 5 757.5 -4942.5 762.5 -4937.5 {name=b dir=in}
B 5 757.5 -5062.5 762.5 -5057.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -5002.5 762.5 -4997.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 847.5 -4972.5 852.5 -4967.5 {name=p dir=inout pinnumber=1}
B 5 847.5 -4912.5 852.5 -4907.5 {name=m dir=inout pinnumber=2}
B 5 517.5 -4912.5 522.5 -4907.5 {name=p dir=inout}
B 5 517.5 -4852.5 522.5 -4847.5 {name=m dir=inout}
B 5 598.75 -4941.25 601.25 -4938.75 {name=p dir=out}
B 5 627.5 -4832.5 632.5 -4827.5 {name=p dir=inout goto=0}
B 5 627.5 -5092.5 632.5 -5087.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 898.75 -4971.25 901.25 -4968.75 {name=p dir=in}
B 5 1297.5 -4592.5 1302.5 -4587.5 {name=d dir=inout}
B 5 1257.5 -4562.5 1262.5 -4557.5 {name=g dir=in}
B 5 1297.5 -4532.5 1302.5 -4527.5 {name=s dir=inout}
B 5 1297.5 -4562.5 1302.5 -4557.5 {name=b dir=in}
B 5 1387.5 -4592.5 1392.5 -4587.5 {name=p dir=inout pinnumber=1}
B 5 1387.5 -4532.5 1392.5 -4527.5 {name=m dir=inout pinnumber=2}
B 5 1057.5 -4532.5 1062.5 -4527.5 {name=p dir=inout}
B 5 1057.5 -4472.5 1062.5 -4467.5 {name=m dir=inout}
B 5 1138.75 -4561.25 1141.25 -4558.75 {name=p dir=out}
B 5 1167.5 -4452.5 1172.5 -4447.5 {name=p dir=inout goto=0}
B 5 1438.75 -4591.25 1441.25 -4588.75 {name=p dir=in}
B 5 2397.5 -4592.5 2402.5 -4587.5 {name=d dir=inout}
B 5 2357.5 -4562.5 2362.5 -4557.5 {name=g dir=in}
B 5 2397.5 -4532.5 2402.5 -4527.5 {name=s dir=inout}
B 5 2397.5 -4562.5 2402.5 -4557.5 {name=b dir=in}
B 5 2487.5 -4592.5 2492.5 -4587.5 {name=p dir=inout pinnumber=1}
B 5 2487.5 -4532.5 2492.5 -4527.5 {name=m dir=inout pinnumber=2}
B 5 2157.5 -4532.5 2162.5 -4527.5 {name=p dir=inout}
B 5 2157.5 -4472.5 2162.5 -4467.5 {name=m dir=inout}
B 5 2238.75 -4561.25 2241.25 -4558.75 {name=p dir=out}
B 5 2267.5 -4452.5 2272.5 -4447.5 {name=p dir=inout goto=0}
B 5 2538.75 -4591.25 2541.25 -4588.75 {name=p dir=in}
B 5 1837.5 -4592.5 1842.5 -4587.5 {name=d dir=inout}
B 5 1797.5 -4562.5 1802.5 -4557.5 {name=g dir=in}
B 5 1837.5 -4532.5 1842.5 -4527.5 {name=s dir=inout}
B 5 1837.5 -4562.5 1842.5 -4557.5 {name=b dir=in}
B 5 1927.5 -4592.5 1932.5 -4587.5 {name=p dir=inout pinnumber=1}
B 5 1927.5 -4532.5 1932.5 -4527.5 {name=m dir=inout pinnumber=2}
B 5 1597.5 -4532.5 1602.5 -4527.5 {name=p dir=inout}
B 5 1597.5 -4472.5 1602.5 -4467.5 {name=m dir=inout}
B 5 1678.75 -4561.25 1681.25 -4558.75 {name=p dir=out}
B 5 1707.5 -4452.5 1712.5 -4447.5 {name=p dir=inout goto=0}
B 5 1978.75 -4591.25 1981.25 -4588.75 {name=p dir=in}
B 5 817.5 -3822.5 822.5 -3817.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -3762.5 822.5 -3757.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -3762.5 822.5 -3757.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -3702.5 822.5 -3697.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -3702.5 1362.5 -3697.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -3862.5 1902.5 -3857.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -3802.5 1902.5 -3797.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -3762.5 1902.5 -3757.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -3702.5 1902.5 -3697.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -4142.5 822.5 -4137.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -4082.5 822.5 -4077.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -4202.5 822.5 -4197.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -4142.5 822.5 -4137.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -4262.5 822.5 -4257.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -4202.5 822.5 -4197.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -4082.5 1362.5 -4077.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -4262.5 1362.5 -4257.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -4082.5 1902.5 -4077.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -4142.5 1902.5 -4137.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -4262.5 1902.5 -4257.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -4202.5 1902.5 -4197.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -2992.5 712.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -2932.5 712.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -2992.5 822.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -2932.5 822.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -2992.5 932.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -2932.5 932.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -2992.5 1252.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -2932.5 1252.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -2992.5 1362.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -2932.5 1362.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -2992.5 1472.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -2932.5 1472.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -2992.5 1792.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -2932.5 1792.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -2992.5 1902.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -2932.5 1902.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -2992.5 2012.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -2932.5 2012.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2317.5 -2992.5 2322.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2317.5 -2932.5 2322.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2427.5 -2992.5 2432.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -2932.5 2432.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2537.5 -2992.5 2542.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2537.5 -2932.5 2542.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2497.5 -4082.5 2502.5 -4077.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2497.5 -4142.5 2502.5 -4137.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2497.5 -4262.5 2502.5 -4257.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2497.5 -4202.5 2502.5 -4197.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -1062.5 712.5 -1057.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -1002.5 712.5 -997.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -1062.5 822.5 -1057.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -1002.5 822.5 -997.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -1062.5 932.5 -1057.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -1002.5 932.5 -997.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -972.5 712.5 -967.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -912.5 712.5 -907.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -972.5 822.5 -967.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -912.5 822.5 -907.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -972.5 932.5 -967.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -912.5 932.5 -907.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -972.5 1252.5 -967.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -912.5 1252.5 -907.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -972.5 1362.5 -967.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -912.5 1362.5 -907.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -972.5 1472.5 -967.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -912.5 1472.5 -907.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -972.5 1792.5 -967.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -912.5 1792.5 -907.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -972.5 1902.5 -967.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -912.5 1902.5 -907.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -972.5 2012.5 -967.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -912.5 2012.5 -907.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1877.5 -2732.5 1882.5 -2727.5 {name=d dir=inout}
B 5 1837.5 -2702.5 1842.5 -2697.5 {name=g dir=in}
B 5 1877.5 -2672.5 1882.5 -2667.5 {name=s dir=inout}
B 5 1877.5 -2702.5 1882.5 -2697.5 {name=b dir=in}
B 5 1108.75 -9291.25 1111.25 -9288.75 {name=p dir=out}
B 5 1137.5 -9182.5 1142.5 -9177.5 {name=p dir=inout goto=0}
B 5 1137.5 -9442.5 1142.5 -9437.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -9321.25 1411.25 -9318.75 {name=p dir=in}
B 5 1027.5 -9262.5 1032.5 -9257.5 {name=p dir=inout}
B 5 1027.5 -9202.5 1032.5 -9197.5 {name=m dir=inout}
B 5 707.5 -682.5 712.5 -677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -622.5 712.5 -617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -682.5 822.5 -677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -622.5 822.5 -617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -682.5 932.5 -677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -622.5 932.5 -617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -622.5 712.5 -617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -562.5 712.5 -557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -622.5 822.5 -617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -562.5 822.5 -557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -622.5 932.5 -617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -562.5 932.5 -557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -622.5 1252.5 -617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -562.5 1252.5 -557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -622.5 1362.5 -617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -562.5 1362.5 -557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -622.5 1472.5 -617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -562.5 1472.5 -557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -592.5 1792.5 -587.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -532.5 1792.5 -527.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -592.5 1902.5 -587.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -532.5 1902.5 -527.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -592.5 2012.5 -587.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -532.5 2012.5 -527.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1757.5 -1372.5 1762.5 -1367.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1757.5 -1312.5 1762.5 -1307.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1877.5 -1372.5 1882.5 -1367.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1877.5 -1312.5 1882.5 -1307.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 797.5 -1442.5 802.5 -1437.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -222.5 822.5 -217.5 {name=d dir=inout}
B 5 777.5 -192.5 782.5 -187.5 {name=g dir=in}
B 5 817.5 -162.5 822.5 -157.5 {name=s dir=inout}
B 5 817.5 -192.5 822.5 -187.5 {name=b dir=in}
B 5 817.5 -312.5 822.5 -307.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -252.5 822.5 -247.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 907.5 -222.5 912.5 -217.5 {name=p dir=inout pinnumber=1}
B 5 907.5 -162.5 912.5 -157.5 {name=m dir=inout pinnumber=2}
B 5 577.5 -162.5 582.5 -157.5 {name=p dir=inout}
B 5 577.5 -102.5 582.5 -97.5 {name=m dir=inout}
B 5 658.75 -191.25 661.25 -188.75 {name=p dir=out}
B 5 687.5 -82.5 692.5 -77.5 {name=p dir=inout goto=0}
B 5 687.5 -342.5 692.5 -337.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 958.75 -221.25 961.25 -218.75 {name=p dir=in}
B 5 1467.5 -222.5 1472.5 -217.5 {name=d dir=inout}
B 5 1427.5 -192.5 1432.5 -187.5 {name=g dir=in}
B 5 1467.5 -162.5 1472.5 -157.5 {name=s dir=inout}
B 5 1467.5 -192.5 1472.5 -187.5 {name=b dir=in}
B 5 1467.5 -312.5 1472.5 -307.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -252.5 1472.5 -247.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1227.5 -162.5 1232.5 -157.5 {name=p dir=inout}
B 5 1227.5 -102.5 1232.5 -97.5 {name=m dir=inout}
B 5 1308.75 -191.25 1311.25 -188.75 {name=p dir=out}
B 5 1337.5 -82.5 1342.5 -77.5 {name=p dir=inout goto=0}
B 5 1337.5 -342.5 1342.5 -337.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1608.75 -221.25 1611.25 -218.75 {name=p dir=in}
B 5 1297.5 -4972.5 1302.5 -4967.5 {name=d dir=inout}
B 5 1257.5 -4942.5 1262.5 -4937.5 {name=g dir=in}
B 5 1297.5 -4912.5 1302.5 -4907.5 {name=s dir=inout}
B 5 1297.5 -4942.5 1302.5 -4937.5 {name=b dir=in}
B 5 1297.5 -5062.5 1302.5 -5057.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1297.5 -5002.5 1302.5 -4997.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1387.5 -4972.5 1392.5 -4967.5 {name=p dir=inout pinnumber=1}
B 5 1387.5 -4912.5 1392.5 -4907.5 {name=m dir=inout pinnumber=2}
B 5 1057.5 -4912.5 1062.5 -4907.5 {name=p dir=inout}
B 5 1057.5 -4852.5 1062.5 -4847.5 {name=m dir=inout}
B 5 1138.75 -4941.25 1141.25 -4938.75 {name=p dir=out}
B 5 1167.5 -4832.5 1172.5 -4827.5 {name=p dir=inout goto=0}
B 5 1167.5 -5092.5 1172.5 -5087.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1438.75 -4971.25 1441.25 -4968.75 {name=p dir=in}
B 5 1857.5 -4972.5 1862.5 -4967.5 {name=d dir=inout}
B 5 1817.5 -4942.5 1822.5 -4937.5 {name=g dir=in}
B 5 1857.5 -4912.5 1862.5 -4907.5 {name=s dir=inout}
B 5 1857.5 -4942.5 1862.5 -4937.5 {name=b dir=in}
B 5 1857.5 -5062.5 1862.5 -5057.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1857.5 -5002.5 1862.5 -4997.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1947.5 -4972.5 1952.5 -4967.5 {name=p dir=inout pinnumber=1}
B 5 1947.5 -4912.5 1952.5 -4907.5 {name=m dir=inout pinnumber=2}
B 5 1617.5 -4912.5 1622.5 -4907.5 {name=p dir=inout}
B 5 1617.5 -4852.5 1622.5 -4847.5 {name=m dir=inout}
B 5 1698.75 -4941.25 1701.25 -4938.75 {name=p dir=out}
B 5 1727.5 -4832.5 1732.5 -4827.5 {name=p dir=inout goto=0}
B 5 1727.5 -5092.5 1732.5 -5087.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1998.75 -4971.25 2001.25 -4968.75 {name=p dir=in}
B 5 2427.5 -4972.5 2432.5 -4967.5 {name=d dir=inout}
B 5 2387.5 -4942.5 2392.5 -4937.5 {name=g dir=in}
B 5 2427.5 -4912.5 2432.5 -4907.5 {name=s dir=inout}
B 5 2427.5 -4942.5 2432.5 -4937.5 {name=b dir=in}
B 5 2427.5 -5062.5 2432.5 -5057.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -5002.5 2432.5 -4997.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2517.5 -4972.5 2522.5 -4967.5 {name=p dir=inout pinnumber=1}
B 5 2517.5 -4912.5 2522.5 -4907.5 {name=m dir=inout pinnumber=2}
B 5 2187.5 -4912.5 2192.5 -4907.5 {name=p dir=inout}
B 5 2187.5 -4852.5 2192.5 -4847.5 {name=m dir=inout}
B 5 2268.75 -4941.25 2271.25 -4938.75 {name=p dir=out}
B 5 2297.5 -4832.5 2302.5 -4827.5 {name=p dir=inout goto=0}
B 5 2297.5 -5092.5 2302.5 -5087.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2568.75 -4971.25 2571.25 -4968.75 {name=p dir=in}
B 5 2027.5 -222.5 2032.5 -217.5 {name=d dir=inout}
B 5 1987.5 -192.5 1992.5 -187.5 {name=g dir=in}
B 5 2027.5 -162.5 2032.5 -157.5 {name=s dir=inout}
B 5 2027.5 -192.5 2032.5 -187.5 {name=b dir=in}
B 5 2027.5 -312.5 2032.5 -307.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2027.5 -252.5 2032.5 -247.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -162.5 1792.5 -157.5 {name=p dir=inout}
B 5 1787.5 -102.5 1792.5 -97.5 {name=m dir=inout}
B 5 1868.75 -191.25 1871.25 -188.75 {name=p dir=out}
B 5 1897.5 -82.5 1902.5 -77.5 {name=p dir=inout goto=0}
B 5 1897.5 -342.5 1902.5 -337.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2168.75 -221.25 2171.25 -218.75 {name=p dir=in}
B 5 757.5 -4592.5 762.5 -4587.5 {name=d dir=inout}
B 5 717.5 -4562.5 722.5 -4557.5 {name=g dir=in}
B 5 757.5 -4532.5 762.5 -4527.5 {name=s dir=inout}
B 5 757.5 -4562.5 762.5 -4557.5 {name=b dir=in}
B 5 847.5 -4592.5 852.5 -4587.5 {name=p dir=inout pinnumber=1}
B 5 847.5 -4532.5 852.5 -4527.5 {name=m dir=inout pinnumber=2}
B 5 517.5 -4532.5 522.5 -4527.5 {name=p dir=inout}
B 5 517.5 -4472.5 522.5 -4467.5 {name=m dir=inout}
B 5 598.75 -4561.25 601.25 -4558.75 {name=p dir=out}
B 5 627.5 -4452.5 632.5 -4447.5 {name=p dir=inout goto=0}
B 5 898.75 -4591.25 901.25 -4588.75 {name=p dir=in}
B 5 417.5 -7592.5 422.5 -7587.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 607.5 -7592.5 612.5 -7587.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 797.5 -7592.5 802.5 -7587.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1047.5 -7592.5 1052.5 -7587.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1237.5 -7592.5 1242.5 -7587.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 417.5 -7532.5 422.5 -7527.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 607.5 -7532.5 612.5 -7527.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 797.5 -7532.5 802.5 -7527.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1047.5 -7532.5 1052.5 -7527.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1237.5 -7532.5 1242.5 -7527.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1527.5 -7592.5 1532.5 -7587.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1527.5 -7532.5 1532.5 -7527.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1657.5 -7592.5 1662.5 -7587.5 {name=p dir=inout pinnumber=1}
B 5 1657.5 -7532.5 1662.5 -7527.5 {name=m dir=inout pinnumber=2}
B 5 1857.5 -7592.5 1862.5 -7587.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1857.5 -7532.5 1862.5 -7527.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1987.5 -7592.5 1992.5 -7587.5 {name=p dir=inout pinnumber=1}
B 5 1987.5 -7532.5 1992.5 -7527.5 {name=m dir=inout pinnumber=2}
B 5 2397.5 -7592.5 2402.5 -7587.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2397.5 -7532.5 2402.5 -7527.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2527.5 -7592.5 2532.5 -7587.5 {name=p dir=inout pinnumber=1}
B 5 2527.5 -7532.5 2532.5 -7527.5 {name=m dir=inout pinnumber=2}
B 5 2107.5 -7592.5 2112.5 -7587.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2107.5 -7532.5 2112.5 -7527.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2237.5 -7592.5 2242.5 -7587.5 {name=p dir=inout pinnumber=1}
B 5 2237.5 -7532.5 2242.5 -7527.5 {name=m dir=inout pinnumber=2}
B 5 2377.5 -4202.5 2382.5 -4197.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2377.5 -4142.5 2382.5 -4137.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
A 1 1220 -2360 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1340 -2360 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1850 -2360 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1970 -2360 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1280 -2080 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1910 -2080 5.590169943749475 333.434948822922 360 {fill=1}
A 1 740 -1680 5.590169943749475 333.434948822922 360 {fill=1}
A 2 1570 -9230 15 270 360 {}
A 2 2030 -9230 15 270 360 {}
A 4 1030 -8760 15 270 360 {}
A 4 1570 -8760 15 270 360 {}
A 4 500 -8760 15 270 360 {}
A 4 500 -8300 15 270 360 {}
A 4 1040 -8300 15 270 360 {}
A 4 500 -6680 15 270 360 {}
A 4 1040 -6680 15 270 360 {}
A 4 500 -6190 15 270 360 {}
A 4 1040 -6190 15 270 360 {}
A 4 500 -5700 15 270 360 {}
A 4 1690 -5700 15 270 360 {}
A 4 1040 -5700 15 270 360 {}
A 4 1030 -7930 15 270 360 {}
A 4 500 -7930 15 270 360 {}
A 4 1530 -7930 15 270 360 {}
A 4 500 -9230 15 270 360 {}
A 4 520 -5260 15 270 360 {}
A 4 1060 -5260 15 270 360 {}
A 4 1620 -5260 15 270 360 {}
A 4 2190 -5260 15 270 360 {}
A 4 520 -7090 15 270 360 {}
A 4 1060 -7090 15 270 360 {}
A 4 2190 -7090 15 270 360 {}
A 4 520 -4880 15 270 360 {}
A 4 1060 -4500 15 270 360 {}
A 4 2160 -4500 15 270 360 {}
A 4 1600 -4500 15 270 360 {}
A 4 1030 -9230 15 270 360 {}
A 4 580 -130 15 270 360 {}
A 4 1230 -130 15 270 360 {}
A 4 1060 -4880 15 270 360 {}
A 4 1620 -4880 15 270 360 {}
A 4 2190 -4880 15 270 360 {}
A 4 1790 -130 15 270 360 {}
A 4 520 -4500 15 270 360 {}
A 5 1360 -3440 5.590169943749475 333.434948822922 360 {fill=1}
P 1 14 920 -8680 942.5 -8680 947.5 -8680 947.5 -8675 947.5 -8632.5 940 -8607.5 935 -8607.5 905 -8607.5 900 -8607.5 892.5 -8632.5 892.5 -8675 892.5 -8680 897.5 -8680 920 -8680 {bezier=1}
P 1 14 935 -8677.5 940 -8677.5 945 -8677.5 945 -8672.5 945 -8652.5 945 -8647.5 940 -8647.5 930 -8647.5 925 -8647.5 925 -8652.5 925 -8672.5 925 -8677.5 930 -8677.5 935 -8677.5 {bezier=1}
P 1 5 917.5 -8675 922.5 -8675 922.5 -8650 917.5 -8650 917.5 -8675 {}
P 1 14 1350 -8680 1372.5 -8680 1377.5 -8680 1377.5 -8675 1377.5 -8632.5 1370 -8607.5 1365 -8607.5 1335 -8607.5 1330 -8607.5 1322.5 -8632.5 1322.5 -8675 1322.5 -8680 1327.5 -8680 1350 -8680 {bezier=1}
P 1 14 1365 -8677.5 1370 -8677.5 1375 -8677.5 1375 -8672.5 1375 -8652.5 1375 -8647.5 1370 -8647.5 1360 -8647.5 1355 -8647.5 1355 -8652.5 1355 -8672.5 1355 -8677.5 1360 -8677.5 1365 -8677.5 {bezier=1}
P 1 5 1347.5 -8675 1352.5 -8675 1352.5 -8650 1347.5 -8650 1347.5 -8675 {}
P 1 14 2120 -8680 2142.5 -8680 2147.5 -8680 2147.5 -8675 2147.5 -8632.5 2140 -8607.5 2135 -8607.5 2105 -8607.5 2100 -8607.5 2092.5 -8632.5 2092.5 -8675 2092.5 -8680 2097.5 -8680 2120 -8680 {bezier=1}
P 1 14 2135 -8677.5 2140 -8677.5 2145 -8677.5 2145 -8672.5 2145 -8652.5 2145 -8647.5 2140 -8647.5 2130 -8647.5 2125 -8647.5 2125 -8652.5 2125 -8672.5 2125 -8677.5 2130 -8677.5 2135 -8677.5 {bezier=1}
P 1 5 2117.5 -8675 2122.5 -8675 2122.5 -8650 2117.5 -8650 2117.5 -8675 {}
P 1 14 1420 -8490 1442.5 -8490 1447.5 -8490 1447.5 -8485 1447.5 -8442.5 1440 -8417.5 1435 -8417.5 1405 -8417.5 1400 -8417.5 1392.5 -8442.5 1392.5 -8485 1392.5 -8490 1397.5 -8490 1420 -8490 {bezier=1}
P 1 14 1435 -8487.5 1440 -8487.5 1445 -8487.5 1445 -8482.5 1445 -8462.5 1445 -8457.5 1440 -8457.5 1430 -8457.5 1425 -8457.5 1425 -8462.5 1425 -8482.5 1425 -8487.5 1430 -8487.5 1435 -8487.5 {bezier=1}
P 1 5 1417.5 -8485 1422.5 -8485 1422.5 -8460 1417.5 -8460 1417.5 -8485 {}
P 1 14 1440 -6880 1462.5 -6880 1467.5 -6880 1467.5 -6875 1467.5 -6832.5 1460 -6807.5 1455 -6807.5 1425 -6807.5 1420 -6807.5 1412.5 -6832.5 1412.5 -6875 1412.5 -6880 1417.5 -6880 1440 -6880 {bezier=1}
P 1 14 1455 -6877.5 1460 -6877.5 1465 -6877.5 1465 -6872.5 1465 -6852.5 1465 -6847.5 1460 -6847.5 1450 -6847.5 1445 -6847.5 1445 -6852.5 1445 -6872.5 1445 -6877.5 1450 -6877.5 1455 -6877.5 {bezier=1}
P 1 5 1437.5 -6875 1442.5 -6875 1442.5 -6850 1437.5 -6850 1437.5 -6875 {}
P 1 10 1530 -6865 1555 -6865 1565 -6855 1565 -6825 1555 -6815 1505 -6815 1495 -6825 1495 -6855 1505 -6865 1530 -6865 {bezier=1}
P 1 10 1530 -6870 1560 -6870 1570 -6860 1570 -6820 1560 -6810 1500 -6810 1490 -6820 1490 -6860 1500 -6870 1530 -6870 {bezier=1}
P 1 14 1440 -6390 1462.5 -6390 1467.5 -6390 1467.5 -6385 1467.5 -6342.5 1460 -6317.5 1455 -6317.5 1425 -6317.5 1420 -6317.5 1412.5 -6342.5 1412.5 -6385 1412.5 -6390 1417.5 -6390 1440 -6390 {bezier=1}
P 1 14 1455 -6387.5 1460 -6387.5 1465 -6387.5 1465 -6382.5 1465 -6362.5 1465 -6357.5 1460 -6357.5 1450 -6357.5 1445 -6357.5 1445 -6362.5 1445 -6382.5 1445 -6387.5 1450 -6387.5 1455 -6387.5 {bezier=1}
P 1 5 1437.5 -6385 1442.5 -6385 1442.5 -6360 1437.5 -6360 1437.5 -6385 {}
P 1 10 1530 -6375 1555 -6375 1565 -6365 1565 -6335 1555 -6325 1505 -6325 1495 -6335 1495 -6365 1505 -6375 1530 -6375 {bezier=1}
P 1 10 1530 -6380 1560 -6380 1570 -6370 1570 -6330 1560 -6320 1500 -6320 1490 -6330 1490 -6370 1500 -6380 1530 -6380 {bezier=1}
P 1 14 950 -5660 972.5 -5660 977.5 -5660 977.5 -5655 977.5 -5612.5 970 -5587.5 965 -5587.5 935 -5587.5 930 -5587.5 922.5 -5612.5 922.5 -5655 922.5 -5660 927.5 -5660 950 -5660 {bezier=1}
P 1 14 965 -5657.5 970 -5657.5 975 -5657.5 975 -5652.5 975 -5632.5 975 -5627.5 970 -5627.5 960 -5627.5 955 -5627.5 955 -5632.5 955 -5652.5 955 -5657.5 960 -5657.5 965 -5657.5 {bezier=1}
P 1 5 947.5 -5655 952.5 -5655 952.5 -5630 947.5 -5630 947.5 -5655 {}
P 1 14 1430 -5670 1452.5 -5670 1457.5 -5670 1457.5 -5665 1457.5 -5622.5 1450 -5597.5 1445 -5597.5 1415 -5597.5 1410 -5597.5 1402.5 -5622.5 1402.5 -5665 1402.5 -5670 1407.5 -5670 1430 -5670 {bezier=1}
P 1 14 1445 -5667.5 1450 -5667.5 1455 -5667.5 1455 -5662.5 1455 -5642.5 1455 -5637.5 1450 -5637.5 1440 -5637.5 1435 -5637.5 1435 -5642.5 1435 -5662.5 1435 -5667.5 1440 -5667.5 1445 -5667.5 {bezier=1}
P 1 5 1427.5 -5665 1432.5 -5665 1432.5 -5640 1427.5 -5640 1427.5 -5665 {}
P 1 10 1520 -5655 1545 -5655 1555 -5645 1555 -5615 1545 -5605 1495 -5605 1485 -5615 1485 -5645 1495 -5655 1520 -5655 {bezier=1}
P 1 10 1520 -5660 1550 -5660 1560 -5650 1560 -5610 1550 -5600 1490 -5600 1480 -5610 1480 -5650 1490 -5660 1520 -5660 {bezier=1}
P 1 14 920 -7850 942.5 -7850 947.5 -7850 947.5 -7845 947.5 -7802.5 940 -7777.5 935 -7777.5 905 -7777.5 900 -7777.5 892.5 -7802.5 892.5 -7845 892.5 -7850 897.5 -7850 920 -7850 {bezier=1}
P 1 14 935 -7847.5 940 -7847.5 945 -7847.5 945 -7842.5 945 -7822.5 945 -7817.5 940 -7817.5 930 -7817.5 925 -7817.5 925 -7822.5 925 -7842.5 925 -7847.5 930 -7847.5 935 -7847.5 {bezier=1}
P 1 5 917.5 -7845 922.5 -7845 922.5 -7820 917.5 -7820 917.5 -7845 {}
P 1 14 1350 -7850 1372.5 -7850 1377.5 -7850 1377.5 -7845 1377.5 -7802.5 1370 -7777.5 1365 -7777.5 1335 -7777.5 1330 -7777.5 1322.5 -7802.5 1322.5 -7845 1322.5 -7850 1327.5 -7850 1350 -7850 {bezier=1}
P 1 14 1365 -7847.5 1370 -7847.5 1375 -7847.5 1375 -7842.5 1375 -7822.5 1375 -7817.5 1370 -7817.5 1360 -7817.5 1355 -7817.5 1355 -7822.5 1355 -7842.5 1355 -7847.5 1360 -7847.5 1365 -7847.5 {bezier=1}
P 1 5 1347.5 -7845 1352.5 -7845 1352.5 -7820 1347.5 -7820 1347.5 -7845 {}
P 1 14 2120 -7850 2142.5 -7850 2147.5 -7850 2147.5 -7845 2147.5 -7802.5 2140 -7777.5 2135 -7777.5 2105 -7777.5 2100 -7777.5 2092.5 -7802.5 2092.5 -7845 2092.5 -7850 2097.5 -7850 2120 -7850 {bezier=1}
P 1 14 2135 -7847.5 2140 -7847.5 2145 -7847.5 2145 -7842.5 2145 -7822.5 2145 -7817.5 2140 -7817.5 2130 -7817.5 2125 -7817.5 2125 -7822.5 2125 -7842.5 2125 -7847.5 2130 -7847.5 2135 -7847.5 {bezier=1}
P 1 5 2117.5 -7845 2122.5 -7845 2122.5 -7820 2117.5 -7820 2117.5 -7845 {}
P 1 10 1270 -7845 1295 -7845 1305 -7835 1305 -7805 1295 -7795 1245 -7795 1235 -7805 1235 -7835 1245 -7845 1270 -7845 {bezier=1}
P 1 10 1270 -7850 1300 -7850 1310 -7840 1310 -7800 1300 -7790 1240 -7790 1230 -7800 1230 -7840 1240 -7850 1270 -7850 {bezier=1}
P 1 14 920 -9150 942.5 -9150 947.5 -9150 947.5 -9145 947.5 -9102.5 940 -9077.5 935 -9077.5 905 -9077.5 900 -9077.5 892.5 -9102.5 892.5 -9145 892.5 -9150 897.5 -9150 920 -9150 {bezier=1}
P 1 14 935 -9147.5 940 -9147.5 945 -9147.5 945 -9142.5 945 -9122.5 945 -9117.5 940 -9117.5 930 -9117.5 925 -9117.5 925 -9122.5 925 -9142.5 925 -9147.5 930 -9147.5 935 -9147.5 {bezier=1}
P 1 5 917.5 -9145 922.5 -9145 922.5 -9120 917.5 -9120 917.5 -9145 {}
P 1 14 1630 -9140 1652.5 -9140 1657.5 -9140 1657.5 -9135 1657.5 -9092.5 1650 -9067.5 1645 -9067.5 1615 -9067.5 1610 -9067.5 1602.5 -9092.5 1602.5 -9135 1602.5 -9140 1607.5 -9140 1630 -9140 {bezier=1}
P 1 14 1645 -9137.5 1650 -9137.5 1655 -9137.5 1655 -9132.5 1655 -9112.5 1655 -9107.5 1650 -9107.5 1640 -9107.5 1635 -9107.5 1635 -9112.5 1635 -9132.5 1635 -9137.5 1640 -9137.5 1645 -9137.5 {bezier=1}
P 1 5 1627.5 -9135 1632.5 -9135 1632.5 -9110 1627.5 -9110 1627.5 -9135 {}
P 1 10 1710 -9125 1735 -9125 1745 -9115 1745 -9085 1735 -9075 1685 -9075 1675 -9085 1675 -9115 1685 -9125 1710 -9125 {bezier=1}
P 1 10 1710 -9130 1740 -9130 1750 -9120 1750 -9080 1740 -9070 1680 -9070 1670 -9080 1670 -9120 1680 -9130 1710 -9130 {bezier=1}
P 1 14 2410 -9130 2432.5 -9130 2437.5 -9130 2437.5 -9125 2437.5 -9082.5 2430 -9057.5 2425 -9057.5 2395 -9057.5 2390 -9057.5 2382.5 -9082.5 2382.5 -9125 2382.5 -9130 2387.5 -9130 2410 -9130 {bezier=1}
P 1 14 2425 -9127.5 2430 -9127.5 2435 -9127.5 2435 -9122.5 2435 -9102.5 2435 -9097.5 2430 -9097.5 2420 -9097.5 2415 -9097.5 2415 -9102.5 2415 -9122.5 2415 -9127.5 2420 -9127.5 2425 -9127.5 {bezier=1}
P 1 5 2407.5 -9125 2412.5 -9125 2412.5 -9100 2407.5 -9100 2407.5 -9125 {}
P 1 10 2490 -9115 2515 -9115 2525 -9105 2525 -9075 2515 -9065 2465 -9065 2455 -9075 2455 -9105 2465 -9115 2490 -9115 {bezier=1}
P 1 10 2490 -9120 2520 -9120 2530 -9110 2530 -9070 2520 -9060 2460 -9060 2450 -9070 2450 -9110 2460 -9120 2490 -9120 {bezier=1}
P 1 14 1490 -5470 1512.5 -5470 1517.5 -5470 1517.5 -5465 1517.5 -5422.5 1510 -5397.5 1505 -5397.5 1475 -5397.5 1470 -5397.5 1462.5 -5422.5 1462.5 -5465 1462.5 -5470 1467.5 -5470 1490 -5470 {bezier=1}
P 1 14 1505 -5467.5 1510 -5467.5 1515 -5467.5 1515 -5462.5 1515 -5442.5 1515 -5437.5 1510 -5437.5 1500 -5437.5 1495 -5437.5 1495 -5442.5 1495 -5462.5 1495 -5467.5 1500 -5467.5 1505 -5467.5 {bezier=1}
P 1 5 1487.5 -5465 1492.5 -5465 1492.5 -5440 1487.5 -5440 1487.5 -5465 {}
P 1 14 1940 -5540 1962.5 -5540 1967.5 -5540 1967.5 -5535 1967.5 -5492.5 1960 -5467.5 1955 -5467.5 1925 -5467.5 1920 -5467.5 1912.5 -5492.5 1912.5 -5535 1912.5 -5540 1917.5 -5540 1940 -5540 {bezier=1}
P 1 14 1955 -5537.5 1960 -5537.5 1965 -5537.5 1965 -5532.5 1965 -5512.5 1965 -5507.5 1960 -5507.5 1950 -5507.5 1945 -5507.5 1945 -5512.5 1945 -5532.5 1945 -5537.5 1950 -5537.5 1955 -5537.5 {bezier=1}
P 1 5 1937.5 -5535 1942.5 -5535 1942.5 -5510 1937.5 -5510 1937.5 -5535 {}
P 1 14 2560 -5450 2582.5 -5450 2587.5 -5450 2587.5 -5445 2587.5 -5402.5 2580 -5377.5 2575 -5377.5 2545 -5377.5 2540 -5377.5 2532.5 -5402.5 2532.5 -5445 2532.5 -5450 2537.5 -5450 2560 -5450 {bezier=1}
P 1 14 2575 -5447.5 2580 -5447.5 2585 -5447.5 2585 -5442.5 2585 -5422.5 2585 -5417.5 2580 -5417.5 2570 -5417.5 2565 -5417.5 2565 -5422.5 2565 -5442.5 2565 -5447.5 2570 -5447.5 2575 -5447.5 {bezier=1}
P 1 5 2557.5 -5445 2562.5 -5445 2562.5 -5420 2557.5 -5420 2557.5 -5445 {}
P 1 14 690 -7270 712.5 -7270 717.5 -7270 717.5 -7265 717.5 -7222.5 710 -7197.5 705 -7197.5 675 -7197.5 670 -7197.5 662.5 -7222.5 662.5 -7265 662.5 -7270 667.5 -7270 690 -7270 {bezier=1}
P 1 14 705 -7267.5 710 -7267.5 715 -7267.5 715 -7262.5 715 -7242.5 715 -7237.5 710 -7237.5 700 -7237.5 695 -7237.5 695 -7242.5 695 -7262.5 695 -7267.5 700 -7267.5 705 -7267.5 {bezier=1}
P 1 5 687.5 -7265 692.5 -7265 692.5 -7240 687.5 -7240 687.5 -7265 {}
P 1 14 1350 -7290 1372.5 -7290 1377.5 -7290 1377.5 -7285 1377.5 -7242.5 1370 -7217.5 1365 -7217.5 1335 -7217.5 1330 -7217.5 1322.5 -7242.5 1322.5 -7285 1322.5 -7290 1327.5 -7290 1350 -7290 {bezier=1}
P 1 14 1365 -7287.5 1370 -7287.5 1375 -7287.5 1375 -7282.5 1375 -7262.5 1375 -7257.5 1370 -7257.5 1360 -7257.5 1355 -7257.5 1355 -7262.5 1355 -7282.5 1355 -7287.5 1360 -7287.5 1365 -7287.5 {bezier=1}
P 1 5 1347.5 -7285 1352.5 -7285 1352.5 -7260 1347.5 -7260 1347.5 -7285 {}
P 1 14 2540 -7340 2562.5 -7340 2567.5 -7340 2567.5 -7335 2567.5 -7292.5 2560 -7267.5 2555 -7267.5 2525 -7267.5 2520 -7267.5 2512.5 -7292.5 2512.5 -7335 2512.5 -7340 2517.5 -7340 2540 -7340 {bezier=1}
P 1 14 2555 -7337.5 2560 -7337.5 2565 -7337.5 2565 -7332.5 2565 -7312.5 2565 -7307.5 2560 -7307.5 2550 -7307.5 2545 -7307.5 2545 -7312.5 2545 -7332.5 2545 -7337.5 2550 -7337.5 2555 -7337.5 {bezier=1}
P 1 5 2537.5 -7335 2542.5 -7335 2542.5 -7310 2537.5 -7310 2537.5 -7335 {}
P 1 14 1390 -4730 1412.5 -4730 1417.5 -4730 1417.5 -4725 1417.5 -4682.5 1410 -4657.5 1405 -4657.5 1375 -4657.5 1370 -4657.5 1362.5 -4682.5 1362.5 -4725 1362.5 -4730 1367.5 -4730 1390 -4730 {bezier=1}
P 1 14 1405 -4727.5 1410 -4727.5 1415 -4727.5 1415 -4722.5 1415 -4702.5 1415 -4697.5 1410 -4697.5 1400 -4697.5 1395 -4697.5 1395 -4702.5 1395 -4722.5 1395 -4727.5 1400 -4727.5 1405 -4727.5 {bezier=1}
P 1 5 1387.5 -4725 1392.5 -4725 1392.5 -4700 1387.5 -4700 1387.5 -4725 {}
P 1 14 1790 -4680 1812.5 -4680 1817.5 -4680 1817.5 -4675 1817.5 -4632.5 1810 -4607.5 1805 -4607.5 1775 -4607.5 1770 -4607.5 1762.5 -4632.5 1762.5 -4675 1762.5 -4680 1767.5 -4680 1790 -4680 {bezier=1}
P 1 14 1805 -4677.5 1810 -4677.5 1815 -4677.5 1815 -4672.5 1815 -4652.5 1815 -4647.5 1810 -4647.5 1800 -4647.5 1795 -4647.5 1795 -4652.5 1795 -4672.5 1795 -4677.5 1800 -4677.5 1805 -4677.5 {bezier=1}
P 1 5 1787.5 -4675 1792.5 -4675 1792.5 -4650 1787.5 -4650 1787.5 -4675 {}
P 1 10 1710 -4665 1735 -4665 1745 -4655 1745 -4625 1735 -4615 1685 -4615 1675 -4625 1675 -4655 1685 -4665 1710 -4665 {bezier=1}
P 1 10 1710 -4670 1740 -4670 1750 -4660 1750 -4620 1740 -4610 1680 -4610 1670 -4620 1670 -4660 1680 -4670 1710 -4670 {bezier=1}
P 1 14 2350 -4710 2372.5 -4710 2377.5 -4710 2377.5 -4705 2377.5 -4662.5 2370 -4637.5 2365 -4637.5 2335 -4637.5 2330 -4637.5 2322.5 -4662.5 2322.5 -4705 2322.5 -4710 2327.5 -4710 2350 -4710 {bezier=1}
P 1 14 2365 -4707.5 2370 -4707.5 2375 -4707.5 2375 -4702.5 2375 -4682.5 2375 -4677.5 2370 -4677.5 2360 -4677.5 2355 -4677.5 2355 -4682.5 2355 -4702.5 2355 -4707.5 2360 -4707.5 2365 -4707.5 {bezier=1}
P 1 5 2347.5 -4705 2352.5 -4705 2352.5 -4680 2347.5 -4680 2347.5 -4705 {}
P 1 14 1430 -4160 1452.5 -4160 1457.5 -4160 1457.5 -4155 1457.5 -4112.5 1450 -4087.5 1445 -4087.5 1415 -4087.5 1410 -4087.5 1402.5 -4112.5 1402.5 -4155 1402.5 -4160 1407.5 -4160 1430 -4160 {bezier=1}
P 1 14 1445 -4157.5 1450 -4157.5 1455 -4157.5 1455 -4152.5 1455 -4132.5 1455 -4127.5 1450 -4127.5 1440 -4127.5 1435 -4127.5 1435 -4132.5 1435 -4152.5 1435 -4157.5 1440 -4157.5 1445 -4157.5 {bezier=1}
P 1 5 1427.5 -4155 1432.5 -4155 1432.5 -4130 1427.5 -4130 1427.5 -4155 {}
P 1 10 1430 -4315 1455 -4315 1465 -4305 1465 -4275 1455 -4265 1405 -4265 1395 -4275 1395 -4305 1405 -4315 1430 -4315 {bezier=1}
P 1 10 1430 -4320 1460 -4320 1470 -4310 1470 -4270 1460 -4260 1400 -4260 1390 -4270 1390 -4310 1400 -4320 1430 -4320 {bezier=1}
P 1 10 1430 -4235 1455 -4235 1465 -4225 1465 -4195 1455 -4185 1405 -4185 1395 -4195 1395 -4225 1405 -4235 1430 -4235 {bezier=1}
P 1 10 1430 -4240 1460 -4240 1470 -4230 1470 -4190 1460 -4180 1400 -4180 1390 -4190 1390 -4230 1400 -4240 1430 -4240 {bezier=1}
P 1 14 1700 -4160 1722.5 -4160 1727.5 -4160 1727.5 -4155 1727.5 -4112.5 1720 -4087.5 1715 -4087.5 1685 -4087.5 1680 -4087.5 1672.5 -4112.5 1672.5 -4155 1672.5 -4160 1677.5 -4160 1700 -4160 {bezier=1}
P 1 14 1715 -4157.5 1720 -4157.5 1725 -4157.5 1725 -4152.5 1725 -4132.5 1725 -4127.5 1720 -4127.5 1710 -4127.5 1705 -4127.5 1705 -4132.5 1705 -4152.5 1705 -4157.5 1710 -4157.5 1715 -4157.5 {bezier=1}
P 1 5 1697.5 -4155 1702.5 -4155 1702.5 -4130 1697.5 -4130 1697.5 -4155 {}
P 1 10 1700 -4315 1725 -4315 1735 -4305 1735 -4275 1725 -4265 1675 -4265 1665 -4275 1665 -4305 1675 -4315 1700 -4315 {bezier=1}
P 1 10 1700 -4320 1730 -4320 1740 -4310 1740 -4270 1730 -4260 1670 -4260 1660 -4270 1660 -4310 1670 -4320 1700 -4320 {bezier=1}
P 1 10 1700 -4235 1725 -4235 1735 -4225 1735 -4195 1725 -4185 1675 -4185 1665 -4195 1665 -4225 1675 -4235 1700 -4235 {bezier=1}
P 1 10 1700 -4240 1730 -4240 1740 -4230 1740 -4190 1730 -4180 1670 -4180 1660 -4190 1660 -4230 1670 -4240 1700 -4240 {bezier=1}
P 1 14 2300 -4160 2322.5 -4160 2327.5 -4160 2327.5 -4155 2327.5 -4112.5 2320 -4087.5 2315 -4087.5 2285 -4087.5 2280 -4087.5 2272.5 -4112.5 2272.5 -4155 2272.5 -4160 2277.5 -4160 2300 -4160 {bezier=1}
P 1 14 2315 -4157.5 2320 -4157.5 2325 -4157.5 2325 -4152.5 2325 -4132.5 2325 -4127.5 2320 -4127.5 2310 -4127.5 2305 -4127.5 2305 -4132.5 2305 -4152.5 2305 -4157.5 2310 -4157.5 2315 -4157.5 {bezier=1}
P 1 5 2297.5 -4155 2302.5 -4155 2302.5 -4130 2297.5 -4130 2297.5 -4155 {}
P 1 14 1430 -3780 1452.5 -3780 1457.5 -3780 1457.5 -3775 1457.5 -3732.5 1450 -3707.5 1445 -3707.5 1415 -3707.5 1410 -3707.5 1402.5 -3732.5 1402.5 -3775 1402.5 -3780 1407.5 -3780 1430 -3780 {bezier=1}
P 1 14 1445 -3777.5 1450 -3777.5 1455 -3777.5 1455 -3772.5 1455 -3752.5 1455 -3747.5 1450 -3747.5 1440 -3747.5 1435 -3747.5 1435 -3752.5 1435 -3772.5 1435 -3777.5 1440 -3777.5 1445 -3777.5 {bezier=1}
P 1 5 1427.5 -3775 1432.5 -3775 1432.5 -3750 1427.5 -3750 1427.5 -3775 {}
P 1 10 1430 -3935 1455 -3935 1465 -3925 1465 -3895 1455 -3885 1405 -3885 1395 -3895 1395 -3925 1405 -3935 1430 -3935 {bezier=1}
P 1 10 1430 -3940 1460 -3940 1470 -3930 1470 -3890 1460 -3880 1400 -3880 1390 -3890 1390 -3930 1400 -3940 1430 -3940 {bezier=1}
P 1 10 1430 -3855 1455 -3855 1465 -3845 1465 -3815 1455 -3805 1405 -3805 1395 -3815 1395 -3845 1405 -3855 1430 -3855 {bezier=1}
P 1 10 1430 -3860 1460 -3860 1470 -3850 1470 -3810 1460 -3800 1400 -3800 1390 -3810 1390 -3850 1400 -3860 1430 -3860 {bezier=1}
P 1 14 2080 -1050 2102.5 -1050 2107.5 -1050 2107.5 -1045 2107.5 -1002.5 2100 -977.5 2095 -977.5 2065 -977.5 2060 -977.5 2052.5 -1002.5 2052.5 -1045 2052.5 -1050 2057.5 -1050 2080 -1050 {bezier=1}
P 1 14 2095 -1047.5 2100 -1047.5 2105 -1047.5 2105 -1042.5 2105 -1022.5 2105 -1017.5 2100 -1017.5 2090 -1017.5 2085 -1017.5 2085 -1022.5 2085 -1042.5 2085 -1047.5 2090 -1047.5 2095 -1047.5 {bezier=1}
P 1 5 2077.5 -1045 2082.5 -1045 2082.5 -1020 2077.5 -1020 2077.5 -1045 {}
P 1 10 2080 -1115 2105 -1115 2115 -1105 2115 -1075 2105 -1065 2055 -1065 2045 -1075 2045 -1105 2055 -1115 2080 -1115 {bezier=1}
P 1 10 2080 -1120 2110 -1120 2120 -1110 2120 -1070 2110 -1060 2050 -1060 2040 -1070 2040 -1110 2050 -1120 2080 -1120 {bezier=1}
P 1 14 1570 -1020 1592.5 -1020 1597.5 -1020 1597.5 -1015 1597.5 -972.5 1590 -947.5 1585 -947.5 1555 -947.5 1550 -947.5 1542.5 -972.5 1542.5 -1015 1542.5 -1020 1547.5 -1020 1570 -1020 {bezier=1}
P 1 14 1585 -1017.5 1590 -1017.5 1595 -1017.5 1595 -1012.5 1595 -992.5 1595 -987.5 1590 -987.5 1580 -987.5 1575 -987.5 1575 -992.5 1575 -1012.5 1575 -1017.5 1580 -1017.5 1585 -1017.5 {bezier=1}
P 1 5 1567.5 -1015 1572.5 -1015 1572.5 -990 1567.5 -990 1567.5 -1015 {}
P 1 14 1430 -3420 1452.5 -3420 1457.5 -3420 1457.5 -3415 1457.5 -3372.5 1450 -3347.5 1445 -3347.5 1415 -3347.5 1410 -3347.5 1402.5 -3372.5 1402.5 -3415 1402.5 -3420 1407.5 -3420 1430 -3420 {bezier=1}
P 1 14 1415 -3417.5 1410 -3417.5 1405 -3417.5 1405 -3412.5 1405 -3392.5 1405 -3387.5 1410 -3387.5 1420 -3387.5 1425 -3387.5 1425 -3392.5 1425 -3412.5 1425 -3417.5 1420 -3417.5 1415 -3417.5 {bezier=1}
P 1 5 1427.5 -3415 1432.5 -3415 1432.5 -3390 1427.5 -3390 1427.5 -3415 {}
P 1 10 1430 -3485 1455 -3485 1465 -3475 1465 -3445 1455 -3435 1405 -3435 1395 -3445 1395 -3475 1405 -3485 1430 -3485 {bezier=1}
P 1 10 1430 -3490 1460 -3490 1470 -3480 1470 -3440 1460 -3430 1400 -3430 1390 -3440 1390 -3480 1400 -3490 1430 -3490 {bezier=1}
P 1 14 1960 -3530 1982.5 -3530 1987.5 -3530 1987.5 -3525 1987.5 -3482.5 1980 -3457.5 1975 -3457.5 1945 -3457.5 1940 -3457.5 1932.5 -3482.5 1932.5 -3525 1932.5 -3530 1937.5 -3530 1960 -3530 {bezier=1}
P 1 14 1975 -3527.5 1980 -3527.5 1985 -3527.5 1985 -3522.5 1985 -3502.5 1985 -3497.5 1980 -3497.5 1970 -3497.5 1965 -3497.5 1965 -3502.5 1965 -3522.5 1965 -3527.5 1970 -3527.5 1975 -3527.5 {bezier=1}
P 1 5 1957.5 -3525 1962.5 -3525 1962.5 -3500 1957.5 -3500 1957.5 -3525 {}
P 1 14 1580 -3010 1602.5 -3010 1607.5 -3010 1607.5 -3005 1607.5 -2962.5 1600 -2937.5 1595 -2937.5 1565 -2937.5 1560 -2937.5 1552.5 -2962.5 1552.5 -3005 1552.5 -3010 1557.5 -3010 1580 -3010 {bezier=1}
P 1 14 1595 -3007.5 1600 -3007.5 1605 -3007.5 1605 -3002.5 1605 -2982.5 1605 -2977.5 1600 -2977.5 1590 -2977.5 1585 -2977.5 1585 -2982.5 1585 -3002.5 1585 -3007.5 1590 -3007.5 1595 -3007.5 {bezier=1}
P 1 5 1577.5 -3005 1582.5 -3005 1582.5 -2980 1577.5 -2980 1577.5 -3005 {}
P 1 10 1580 -3075 1605 -3075 1615 -3065 1615 -3035 1605 -3025 1555 -3025 1545 -3035 1545 -3065 1555 -3075 1580 -3075 {bezier=1}
P 1 10 1580 -3080 1610 -3080 1620 -3070 1620 -3030 1610 -3020 1550 -3020 1540 -3030 1540 -3070 1550 -3080 1580 -3080 {bezier=1}
P 1 14 2070 -3070 2092.5 -3070 2097.5 -3070 2097.5 -3065 2097.5 -3022.5 2090 -2997.5 2085 -2997.5 2055 -2997.5 2050 -2997.5 2042.5 -3022.5 2042.5 -3065 2042.5 -3070 2047.5 -3070 2070 -3070 {bezier=1}
P 1 14 2085 -3067.5 2090 -3067.5 2095 -3067.5 2095 -3062.5 2095 -3042.5 2095 -3037.5 2090 -3037.5 2080 -3037.5 2075 -3037.5 2075 -3042.5 2075 -3062.5 2075 -3067.5 2080 -3067.5 2085 -3067.5 {bezier=1}
P 1 5 2067.5 -3065 2072.5 -3065 2072.5 -3040 2067.5 -3040 2067.5 -3065 {}
P 1 14 2600 -3200 2622.5 -3200 2627.5 -3200 2627.5 -3195 2627.5 -3152.5 2620 -3127.5 2615 -3127.5 2585 -3127.5 2580 -3127.5 2572.5 -3152.5 2572.5 -3195 2572.5 -3200 2577.5 -3200 2600 -3200 {bezier=1}
P 1 14 2615 -3197.5 2620 -3197.5 2625 -3197.5 2625 -3192.5 2625 -3172.5 2625 -3167.5 2620 -3167.5 2610 -3167.5 2605 -3167.5 2605 -3172.5 2605 -3192.5 2605 -3197.5 2610 -3197.5 2615 -3197.5 {bezier=1}
P 1 5 2597.5 -3195 2602.5 -3195 2602.5 -3170 2597.5 -3170 2597.5 -3195 {}
P 1 10 1960 -2775 1985 -2775 1995 -2765 1995 -2735 1985 -2725 1935 -2725 1925 -2735 1925 -2765 1935 -2775 1960 -2775 {bezier=1}
P 1 10 1960 -2780 1990 -2780 2000 -2770 2000 -2730 1990 -2720 1930 -2720 1920 -2730 1920 -2770 1930 -2780 1960 -2780 {bezier=1}
P 1 10 1960 -2695 1985 -2695 1995 -2685 1995 -2655 1985 -2645 1935 -2645 1925 -2655 1925 -2685 1935 -2695 1960 -2695 {bezier=1}
P 1 10 1960 -2700 1990 -2700 2000 -2690 2000 -2650 1990 -2640 1930 -2640 1920 -2650 1920 -2690 1930 -2700 1960 -2700 {bezier=1}
P 1 14 990 -9420 1012.5 -9420 1017.5 -9420 1017.5 -9415 1017.5 -9372.5 1010 -9347.5 1005 -9347.5 975 -9347.5 970 -9347.5 962.5 -9372.5 962.5 -9415 962.5 -9420 967.5 -9420 990 -9420 {bezier=1}
P 1 14 1005 -9417.5 1010 -9417.5 1015 -9417.5 1015 -9412.5 1015 -9392.5 1015 -9387.5 1010 -9387.5 1000 -9387.5 995 -9387.5 995 -9392.5 995 -9412.5 995 -9417.5 1000 -9417.5 1005 -9417.5 {bezier=1}
P 1 5 987.5 -9415 992.5 -9415 992.5 -9390 987.5 -9390 987.5 -9415 {}
P 1 10 1080 -9405 1105 -9405 1115 -9395 1115 -9365 1105 -9355 1055 -9355 1045 -9365 1045 -9395 1055 -9405 1080 -9405 {bezier=1}
P 1 10 1080 -9410 1110 -9410 1120 -9400 1120 -9360 1110 -9350 1050 -9350 1040 -9360 1040 -9400 1050 -9410 1080 -9410 {bezier=1}
P 1 14 1570 -640 1592.5 -640 1597.5 -640 1597.5 -635 1597.5 -592.5 1590 -567.5 1585 -567.5 1555 -567.5 1550 -567.5 1542.5 -592.5 1542.5 -635 1542.5 -640 1547.5 -640 1570 -640 {bezier=1}
P 1 14 1585 -637.5 1590 -637.5 1595 -637.5 1595 -632.5 1595 -612.5 1595 -607.5 1590 -607.5 1580 -607.5 1575 -607.5 1575 -612.5 1575 -632.5 1575 -637.5 1580 -637.5 1585 -637.5 {bezier=1}
P 1 5 1567.5 -635 1572.5 -635 1572.5 -610 1567.5 -610 1567.5 -635 {}
P 1 14 2080 -590 2102.5 -590 2107.5 -590 2107.5 -585 2107.5 -542.5 2100 -517.5 2095 -517.5 2065 -517.5 2060 -517.5 2052.5 -542.5 2052.5 -585 2052.5 -590 2057.5 -590 2080 -590 {bezier=1}
P 1 14 2095 -587.5 2100 -587.5 2105 -587.5 2105 -582.5 2105 -562.5 2105 -557.5 2100 -557.5 2090 -557.5 2085 -557.5 2085 -562.5 2085 -582.5 2085 -587.5 2090 -587.5 2095 -587.5 {bezier=1}
P 1 5 2077.5 -585 2082.5 -585 2082.5 -560 2077.5 -560 2077.5 -585 {}
P 1 10 2080 -735 2105 -735 2115 -725 2115 -695 2105 -685 2055 -685 2045 -695 2045 -725 2055 -735 2080 -735 {bezier=1}
P 1 10 2080 -740 2110 -740 2120 -730 2120 -690 2110 -680 2050 -680 2040 -690 2040 -730 2050 -740 2080 -740 {bezier=1}
P 1 10 2080 -665 2105 -665 2115 -655 2115 -625 2105 -615 2055 -615 2045 -625 2045 -655 2055 -665 2080 -665 {bezier=1}
P 1 10 2080 -670 2110 -670 2120 -660 2120 -620 2110 -610 2050 -610 2040 -620 2040 -660 2050 -670 2080 -670 {bezier=1}
P 1 10 1920 -2475 1945 -2475 1955 -2465 1955 -2435 1945 -2425 1895 -2425 1885 -2435 1885 -2465 1895 -2475 1920 -2475 {bezier=1}
P 1 10 1920 -2480 1950 -2480 1960 -2470 1960 -2430 1950 -2420 1890 -2420 1880 -2430 1880 -2470 1890 -2480 1920 -2480 {bezier=1}
P 1 10 1830 -2045 1855 -2045 1865 -2035 1865 -2005 1855 -1995 1805 -1995 1795 -2005 1795 -2035 1805 -2045 1830 -2045 {bezier=1}
P 1 10 1830 -2050 1860 -2050 1870 -2040 1870 -2000 1860 -1990 1800 -1990 1790 -2000 1790 -2040 1800 -2050 1830 -2050 {bezier=1}
P 1 14 2500 -3450 2522.5 -3450 2527.5 -3450 2527.5 -3445 2527.5 -3402.5 2520 -3377.5 2515 -3377.5 2485 -3377.5 2480 -3377.5 2472.5 -3402.5 2472.5 -3445 2472.5 -3450 2477.5 -3450 2500 -3450 {bezier=1}
P 1 14 2515 -3447.5 2520 -3447.5 2525 -3447.5 2525 -3442.5 2525 -3422.5 2525 -3417.5 2520 -3417.5 2510 -3417.5 2505 -3417.5 2505 -3422.5 2505 -3442.5 2505 -3447.5 2510 -3447.5 2515 -3447.5 {bezier=1}
P 1 5 2497.5 -3445 2502.5 -3445 2502.5 -3420 2497.5 -3420 2497.5 -3445 {}
P 1 10 1290 -1395 1315 -1395 1325 -1385 1325 -1355 1315 -1345 1265 -1345 1255 -1355 1255 -1385 1265 -1395 1290 -1395 {bezier=1}
P 1 10 1290 -1400 1320 -1400 1330 -1390 1330 -1350 1320 -1340 1260 -1340 1250 -1350 1250 -1390 1260 -1400 1290 -1400 {bezier=1}
P 1 14 1820 -1490 1842.5 -1490 1847.5 -1490 1847.5 -1485 1847.5 -1442.5 1840 -1417.5 1835 -1417.5 1805 -1417.5 1800 -1417.5 1792.5 -1442.5 1792.5 -1485 1792.5 -1490 1797.5 -1490 1820 -1490 {bezier=1}
P 1 14 1835 -1487.5 1840 -1487.5 1845 -1487.5 1845 -1482.5 1845 -1462.5 1845 -1457.5 1840 -1457.5 1830 -1457.5 1825 -1457.5 1825 -1462.5 1825 -1482.5 1825 -1487.5 1830 -1487.5 1835 -1487.5 {bezier=1}
P 1 5 1817.5 -1485 1822.5 -1485 1822.5 -1460 1817.5 -1460 1817.5 -1485 {}
P 1 14 670 -1420 692.5 -1420 697.5 -1420 697.5 -1415 697.5 -1372.5 690 -1347.5 685 -1347.5 655 -1347.5 650 -1347.5 642.5 -1372.5 642.5 -1415 642.5 -1420 647.5 -1420 670 -1420 {bezier=1}
P 1 14 685 -1417.5 690 -1417.5 695 -1417.5 695 -1412.5 695 -1392.5 695 -1387.5 690 -1387.5 680 -1387.5 675 -1387.5 675 -1392.5 675 -1412.5 675 -1417.5 680 -1417.5 685 -1417.5 {bezier=1}
P 1 5 667.5 -1415 672.5 -1415 672.5 -1390 667.5 -1390 667.5 -1415 {}
P 1 14 790 -1420 812.5 -1420 817.5 -1420 817.5 -1415 817.5 -1372.5 810 -1347.5 805 -1347.5 775 -1347.5 770 -1347.5 762.5 -1372.5 762.5 -1415 762.5 -1420 767.5 -1420 790 -1420 {bezier=1}
P 1 14 805 -1417.5 810 -1417.5 815 -1417.5 815 -1412.5 815 -1392.5 815 -1387.5 810 -1387.5 800 -1387.5 795 -1387.5 795 -1392.5 795 -1412.5 795 -1417.5 800 -1417.5 805 -1417.5 {bezier=1}
P 1 5 787.5 -1415 792.5 -1415 792.5 -1390 787.5 -1390 787.5 -1415 {}
P 1 10 790 -1325 815 -1325 825 -1315 825 -1285 815 -1275 765 -1275 755 -1285 755 -1315 765 -1325 790 -1325 {bezier=1}
P 1 10 790 -1330 820 -1330 830 -1320 830 -1280 820 -1270 760 -1270 750 -1280 750 -1320 760 -1330 790 -1330 {bezier=1}
P 1 14 1650 -90 1672.5 -90 1677.5 -90 1677.5 -85 1677.5 -42.5 1670 -17.5 1665 -17.5 1635 -17.5 1630 -17.5 1622.5 -42.5 1622.5 -85 1622.5 -90 1627.5 -90 1650 -90 {bezier=1}
P 1 14 1635 -87.5 1630 -87.5 1625 -87.5 1625 -82.5 1625 -62.5 1625 -57.5 1630 -57.5 1640 -57.5 1645 -57.5 1645 -62.5 1645 -82.5 1645 -87.5 1640 -87.5 1635 -87.5 {bezier=1}
P 1 5 1647.5 -85 1652.5 -85 1652.5 -60 1647.5 -60 1647.5 -85 {}
P 1 10 1650 -165 1675 -165 1685 -155 1685 -125 1675 -115 1625 -115 1615 -125 1615 -155 1625 -165 1650 -165 {bezier=1}
P 1 10 1650 -170 1680 -170 1690 -160 1690 -120 1680 -110 1620 -110 1610 -120 1610 -160 1620 -170 1650 -170 {bezier=1}
P 1 10 1920 -1905 1945 -1905 1955 -1895 1955 -1865 1945 -1855 1895 -1855 1885 -1865 1885 -1895 1895 -1905 1920 -1905 {bezier=1}
P 1 10 1920 -1910 1950 -1910 1960 -1900 1960 -1860 1950 -1850 1890 -1850 1880 -1860 1880 -1900 1890 -1910 1920 -1910 {bezier=1}
P 1 14 460 -4910 482.5 -4910 487.5 -4910 487.5 -4905 487.5 -4862.5 480 -4837.5 475 -4837.5 445 -4837.5 440 -4837.5 432.5 -4862.5 432.5 -4905 432.5 -4910 437.5 -4910 460 -4910 {bezier=1}
P 1 14 475 -4907.5 480 -4907.5 485 -4907.5 485 -4902.5 485 -4882.5 485 -4877.5 480 -4877.5 470 -4877.5 465 -4877.5 465 -4882.5 465 -4902.5 465 -4907.5 470 -4907.5 475 -4907.5 {bezier=1}
P 1 5 457.5 -4905 462.5 -4905 462.5 -4880 457.5 -4880 457.5 -4905 {}
P 1 14 1000 -5090 1022.5 -5090 1027.5 -5090 1027.5 -5085 1027.5 -5042.5 1020 -5017.5 1015 -5017.5 985 -5017.5 980 -5017.5 972.5 -5042.5 972.5 -5085 972.5 -5090 977.5 -5090 1000 -5090 {bezier=1}
P 1 14 1015 -5087.5 1020 -5087.5 1025 -5087.5 1025 -5082.5 1025 -5062.5 1025 -5057.5 1020 -5057.5 1010 -5057.5 1005 -5057.5 1005 -5062.5 1005 -5082.5 1005 -5087.5 1010 -5087.5 1015 -5087.5 {bezier=1}
P 1 5 997.5 -5085 1002.5 -5085 1002.5 -5060 997.5 -5060 997.5 -5085 {}
P 1 14 2010 -4880 2032.5 -4880 2037.5 -4880 2037.5 -4875 2037.5 -4832.5 2030 -4807.5 2025 -4807.5 1995 -4807.5 1990 -4807.5 1982.5 -4832.5 1982.5 -4875 1982.5 -4880 1987.5 -4880 2010 -4880 {bezier=1}
P 1 14 2025 -4877.5 2030 -4877.5 2035 -4877.5 2035 -4872.5 2035 -4852.5 2035 -4847.5 2030 -4847.5 2020 -4847.5 2015 -4847.5 2015 -4852.5 2015 -4872.5 2015 -4877.5 2020 -4877.5 2025 -4877.5 {bezier=1}
P 1 5 2007.5 -4875 2012.5 -4875 2012.5 -4850 2007.5 -4850 2007.5 -4875 {}
P 1 14 2580 -4880 2602.5 -4880 2607.5 -4880 2607.5 -4875 2607.5 -4832.5 2600 -4807.5 2595 -4807.5 2565 -4807.5 2560 -4807.5 2552.5 -4832.5 2552.5 -4875 2552.5 -4880 2557.5 -4880 2580 -4880 {bezier=1}
P 1 14 2595 -4877.5 2600 -4877.5 2605 -4877.5 2605 -4872.5 2605 -4852.5 2605 -4847.5 2600 -4847.5 2590 -4847.5 2585 -4847.5 2585 -4852.5 2585 -4872.5 2585 -4877.5 2590 -4877.5 2595 -4877.5 {bezier=1}
P 1 5 2577.5 -4875 2582.5 -4875 2582.5 -4850 2577.5 -4850 2577.5 -4875 {}
P 1 14 2280 -5670 2302.5 -5670 2307.5 -5670 2307.5 -5665 2307.5 -5622.5 2300 -5597.5 2295 -5597.5 2265 -5597.5 2260 -5597.5 2252.5 -5622.5 2252.5 -5665 2252.5 -5670 2257.5 -5670 2280 -5670 {bezier=1}
P 1 14 2295 -5667.5 2300 -5667.5 2305 -5667.5 2305 -5662.5 2305 -5642.5 2305 -5637.5 2300 -5637.5 2290 -5637.5 2285 -5637.5 2285 -5642.5 2285 -5662.5 2285 -5667.5 2290 -5667.5 2295 -5667.5 {bezier=1}
P 1 5 2277.5 -5665 2282.5 -5665 2282.5 -5640 2277.5 -5640 2277.5 -5665 {}
P 1 10 2370 -5655 2395 -5655 2405 -5645 2405 -5615 2395 -5605 2345 -5605 2335 -5615 2335 -5645 2345 -5655 2370 -5655 {bezier=1}
P 1 10 2370 -5660 2400 -5660 2410 -5650 2410 -5610 2400 -5600 2340 -5600 2330 -5610 2330 -5650 2340 -5660 2370 -5660 {bezier=1}
P 1 14 1980 -3780 2002.5 -3780 2007.5 -3780 2007.5 -3775 2007.5 -3732.5 2000 -3707.5 1995 -3707.5 1965 -3707.5 1960 -3707.5 1952.5 -3732.5 1952.5 -3775 1952.5 -3780 1957.5 -3780 1980 -3780 {bezier=1}
P 1 14 1995 -3777.5 2000 -3777.5 2005 -3777.5 2005 -3772.5 2005 -3752.5 2005 -3747.5 2000 -3747.5 1990 -3747.5 1985 -3747.5 1985 -3752.5 1985 -3772.5 1985 -3777.5 1990 -3777.5 1995 -3777.5 {bezier=1}
P 1 5 1977.5 -3775 1982.5 -3775 1982.5 -3750 1977.5 -3750 1977.5 -3775 {}
P 1 10 1980 -3935 2005 -3935 2015 -3925 2015 -3895 2005 -3885 1955 -3885 1945 -3895 1945 -3925 1955 -3935 1980 -3935 {bezier=1}
P 1 10 1980 -3940 2010 -3940 2020 -3930 2020 -3890 2010 -3880 1950 -3880 1940 -3890 1940 -3930 1950 -3940 1980 -3940 {bezier=1}
P 1 10 1980 -3855 2005 -3855 2015 -3845 2015 -3815 2005 -3805 1955 -3805 1945 -3815 1945 -3845 1955 -3855 1980 -3855 {bezier=1}
P 1 10 1980 -3860 2010 -3860 2020 -3850 2020 -3810 2010 -3800 1950 -3800 1940 -3810 1940 -3850 1950 -3860 1980 -3860 {bezier=1}
P 1 14 2340 -2080 2362.5 -2080 2367.5 -2080 2367.5 -2075 2367.5 -2032.5 2360 -2007.5 2355 -2007.5 2325 -2007.5 2320 -2007.5 2312.5 -2032.5 2312.5 -2075 2312.5 -2080 2317.5 -2080 2340 -2080 {bezier=1}
P 1 14 2355 -2077.5 2360 -2077.5 2365 -2077.5 2365 -2072.5 2365 -2052.5 2365 -2047.5 2360 -2047.5 2350 -2047.5 2345 -2047.5 2345 -2052.5 2345 -2072.5 2345 -2077.5 2350 -2077.5 2355 -2077.5 {bezier=1}
P 1 5 2337.5 -2075 2342.5 -2075 2342.5 -2050 2337.5 -2050 2337.5 -2075 {}
P 1 14 810 -2200 832.5 -2200 837.5 -2200 837.5 -2195 837.5 -2152.5 830 -2127.5 825 -2127.5 795 -2127.5 790 -2127.5 782.5 -2152.5 782.5 -2195 782.5 -2200 787.5 -2200 810 -2200 {bezier=1}
P 1 14 825 -2197.5 830 -2197.5 835 -2197.5 835 -2192.5 835 -2172.5 835 -2167.5 830 -2167.5 820 -2167.5 815 -2167.5 815 -2172.5 815 -2192.5 815 -2197.5 820 -2197.5 825 -2197.5 {bezier=1}
P 1 5 807.5 -2195 812.5 -2195 812.5 -2170 807.5 -2170 807.5 -2195 {}
P 1 14 1350 -2180 1372.5 -2180 1377.5 -2180 1377.5 -2175 1377.5 -2132.5 1370 -2107.5 1365 -2107.5 1335 -2107.5 1330 -2107.5 1322.5 -2132.5 1322.5 -2175 1322.5 -2180 1327.5 -2180 1350 -2180 {bezier=1}
P 1 14 1365 -2177.5 1370 -2177.5 1375 -2177.5 1375 -2172.5 1375 -2152.5 1375 -2147.5 1370 -2147.5 1360 -2147.5 1355 -2147.5 1355 -2152.5 1355 -2172.5 1355 -2177.5 1360 -2177.5 1365 -2177.5 {bezier=1}
P 1 5 1347.5 -2175 1352.5 -2175 1352.5 -2150 1347.5 -2150 1347.5 -2175 {}
P 1 14 1260 -1800 1282.5 -1800 1287.5 -1800 1287.5 -1795 1287.5 -1752.5 1280 -1727.5 1275 -1727.5 1245 -1727.5 1240 -1727.5 1232.5 -1752.5 1232.5 -1795 1232.5 -1800 1237.5 -1800 1260 -1800 {bezier=1}
P 1 14 1275 -1797.5 1280 -1797.5 1285 -1797.5 1285 -1792.5 1285 -1772.5 1285 -1767.5 1280 -1767.5 1270 -1767.5 1265 -1767.5 1265 -1772.5 1265 -1792.5 1265 -1797.5 1270 -1797.5 1275 -1797.5 {bezier=1}
P 1 5 1257.5 -1795 1262.5 -1795 1262.5 -1770 1257.5 -1770 1257.5 -1795 {}
P 1 14 2520 -1750 2542.5 -1750 2547.5 -1750 2547.5 -1745 2547.5 -1702.5 2540 -1677.5 2535 -1677.5 2505 -1677.5 2500 -1677.5 2492.5 -1702.5 2492.5 -1745 2492.5 -1750 2497.5 -1750 2520 -1750 {bezier=1}
P 1 14 2535 -1747.5 2540 -1747.5 2545 -1747.5 2545 -1742.5 2545 -1722.5 2545 -1717.5 2540 -1717.5 2530 -1717.5 2525 -1717.5 2525 -1722.5 2525 -1742.5 2525 -1747.5 2530 -1747.5 2535 -1747.5 {bezier=1}
P 1 5 2517.5 -1745 2522.5 -1745 2522.5 -1720 2517.5 -1720 2517.5 -1745 {}
P 1 14 2480 -340 2502.5 -340 2507.5 -340 2507.5 -335 2507.5 -292.5 2500 -267.5 2495 -267.5 2465 -267.5 2460 -267.5 2452.5 -292.5 2452.5 -335 2452.5 -340 2457.5 -340 2480 -340 {bezier=1}
P 1 14 2495 -337.5 2490 -337.5 2485 -337.5 2485 -332.5 2485 -312.5 2485 -307.5 2490 -307.5 2500 -307.5 2505 -307.5 2505 -312.5 2505 -332.5 2505 -337.5 2500 -337.5 2495 -337.5 {bezier=1}
P 1 5 2477.5 -335 2482.5 -335 2482.5 -310 2477.5 -310 2477.5 -335 {}
P 1 14 460 -4570 482.5 -4570 487.5 -4570 487.5 -4565 487.5 -4522.5 480 -4497.5 475 -4497.5 445 -4497.5 440 -4497.5 432.5 -4522.5 432.5 -4565 432.5 -4570 437.5 -4570 460 -4570 {bezier=1}
P 1 14 475 -4567.5 480 -4567.5 485 -4567.5 485 -4562.5 485 -4542.5 485 -4537.5 480 -4537.5 470 -4537.5 465 -4537.5 465 -4542.5 465 -4562.5 465 -4567.5 470 -4567.5 475 -4567.5 {bezier=1}
P 1 5 457.5 -4565 462.5 -4565 462.5 -4540 457.5 -4540 457.5 -4565 {}
P 1 10 2270 -4695 2295 -4695 2305 -4685 2305 -4655 2295 -4645 2245 -4645 2235 -4655 2235 -4685 2245 -4695 2270 -4695 {bezier=1}
P 1 10 2270 -4700 2300 -4700 2310 -4690 2310 -4650 2300 -4640 2240 -4640 2230 -4650 2230 -4690 2240 -4700 2270 -4700 {bezier=1}
P 1 14 820 -5440 842.5 -5440 847.5 -5440 847.5 -5435 847.5 -5392.5 840 -5367.5 835 -5367.5 805 -5367.5 800 -5367.5 792.5 -5392.5 792.5 -5435 792.5 -5440 797.5 -5440 820 -5440 {bezier=1}
P 1 14 835 -5437.5 840 -5437.5 845 -5437.5 845 -5432.5 845 -5412.5 845 -5407.5 840 -5407.5 830 -5407.5 825 -5407.5 825 -5412.5 825 -5432.5 825 -5437.5 830 -5437.5 835 -5437.5 {bezier=1}
P 1 5 817.5 -5435 822.5 -5435 822.5 -5410 817.5 -5410 817.5 -5435 {}
P 1 14 480 -7600 502.5 -7600 507.5 -7600 507.5 -7595 507.5 -7552.5 500 -7527.5 495 -7527.5 465 -7527.5 460 -7527.5 452.5 -7552.5 452.5 -7595 452.5 -7600 457.5 -7600 480 -7600 {bezier=1}
P 1 14 495 -7597.5 500 -7597.5 505 -7597.5 505 -7592.5 505 -7572.5 505 -7567.5 500 -7567.5 490 -7567.5 485 -7567.5 485 -7572.5 485 -7592.5 485 -7597.5 490 -7597.5 495 -7597.5 {bezier=1}
P 1 5 477.5 -7595 482.5 -7595 482.5 -7570 477.5 -7570 477.5 -7595 {}
P 1 14 670 -7710 692.5 -7710 697.5 -7710 697.5 -7705 697.5 -7662.5 690 -7637.5 685 -7637.5 655 -7637.5 650 -7637.5 642.5 -7662.5 642.5 -7705 642.5 -7710 647.5 -7710 670 -7710 {bezier=1}
P 1 14 685 -7707.5 690 -7707.5 695 -7707.5 695 -7702.5 695 -7682.5 695 -7677.5 690 -7677.5 680 -7677.5 675 -7677.5 675 -7682.5 675 -7702.5 675 -7707.5 680 -7707.5 685 -7707.5 {bezier=1}
P 1 5 667.5 -7705 672.5 -7705 672.5 -7680 667.5 -7680 667.5 -7705 {}
P 1 14 900 -7670 922.5 -7670 927.5 -7670 927.5 -7665 927.5 -7622.5 920 -7597.5 915 -7597.5 885 -7597.5 880 -7597.5 872.5 -7622.5 872.5 -7665 872.5 -7670 877.5 -7670 900 -7670 {bezier=1}
P 1 14 915 -7667.5 920 -7667.5 925 -7667.5 925 -7662.5 925 -7642.5 925 -7637.5 920 -7637.5 910 -7637.5 905 -7637.5 905 -7642.5 905 -7662.5 905 -7667.5 910 -7667.5 915 -7667.5 {bezier=1}
P 1 5 897.5 -7665 902.5 -7665 902.5 -7640 897.5 -7640 897.5 -7665 {}
P 1 14 1110 -7710 1132.5 -7710 1137.5 -7710 1137.5 -7705 1137.5 -7662.5 1130 -7637.5 1125 -7637.5 1095 -7637.5 1090 -7637.5 1082.5 -7662.5 1082.5 -7705 1082.5 -7710 1087.5 -7710 1110 -7710 {bezier=1}
P 1 14 1125 -7707.5 1130 -7707.5 1135 -7707.5 1135 -7702.5 1135 -7682.5 1135 -7677.5 1130 -7677.5 1120 -7677.5 1115 -7677.5 1115 -7682.5 1115 -7702.5 1115 -7707.5 1120 -7707.5 1125 -7707.5 {bezier=1}
P 1 5 1107.5 -7705 1112.5 -7705 1112.5 -7680 1107.5 -7680 1107.5 -7705 {}
P 1 14 1380 -7710 1402.5 -7710 1407.5 -7710 1407.5 -7705 1407.5 -7662.5 1400 -7637.5 1395 -7637.5 1365 -7637.5 1360 -7637.5 1352.5 -7662.5 1352.5 -7705 1352.5 -7710 1357.5 -7710 1380 -7710 {bezier=1}
P 1 14 1395 -7707.5 1400 -7707.5 1405 -7707.5 1405 -7702.5 1405 -7682.5 1405 -7677.5 1400 -7677.5 1390 -7677.5 1385 -7677.5 1385 -7682.5 1385 -7702.5 1385 -7707.5 1390 -7707.5 1395 -7707.5 {bezier=1}
P 1 5 1377.5 -7705 1382.5 -7705 1382.5 -7680 1377.5 -7680 1377.5 -7705 {}
P 1 14 1720 -7570 1742.5 -7570 1747.5 -7570 1747.5 -7565 1747.5 -7522.5 1740 -7497.5 1735 -7497.5 1705 -7497.5 1700 -7497.5 1692.5 -7522.5 1692.5 -7565 1692.5 -7570 1697.5 -7570 1720 -7570 {bezier=1}
P 1 14 1735 -7567.5 1740 -7567.5 1745 -7567.5 1745 -7562.5 1745 -7542.5 1745 -7537.5 1740 -7537.5 1730 -7537.5 1725 -7537.5 1725 -7542.5 1725 -7562.5 1725 -7567.5 1730 -7567.5 1735 -7567.5 {bezier=1}
P 1 5 1717.5 -7565 1722.5 -7565 1722.5 -7540 1717.5 -7540 1717.5 -7565 {}
P 1 14 1970 -7680 1992.5 -7680 1997.5 -7680 1997.5 -7675 1997.5 -7632.5 1990 -7607.5 1985 -7607.5 1955 -7607.5 1950 -7607.5 1942.5 -7632.5 1942.5 -7675 1942.5 -7680 1947.5 -7680 1970 -7680 {bezier=1}
P 1 14 1985 -7677.5 1990 -7677.5 1995 -7677.5 1995 -7672.5 1995 -7652.5 1995 -7647.5 1990 -7647.5 1980 -7647.5 1975 -7647.5 1975 -7652.5 1975 -7672.5 1975 -7677.5 1980 -7677.5 1985 -7677.5 {bezier=1}
P 1 5 1967.5 -7675 1972.5 -7675 1972.5 -7650 1967.5 -7650 1967.5 -7675 {}
P 1 14 2590 -7680 2612.5 -7680 2617.5 -7680 2617.5 -7675 2617.5 -7632.5 2610 -7607.5 2605 -7607.5 2575 -7607.5 2570 -7607.5 2562.5 -7632.5 2562.5 -7675 2562.5 -7680 2567.5 -7680 2590 -7680 {bezier=1}
P 1 14 2605 -7677.5 2610 -7677.5 2615 -7677.5 2615 -7672.5 2615 -7652.5 2615 -7647.5 2610 -7647.5 2600 -7647.5 2595 -7647.5 2595 -7652.5 2595 -7672.5 2595 -7677.5 2600 -7677.5 2605 -7677.5 {bezier=1}
P 1 5 2587.5 -7675 2592.5 -7675 2592.5 -7650 2587.5 -7650 2587.5 -7675 {}
P 1 14 2250 -7680 2272.5 -7680 2277.5 -7680 2277.5 -7675 2277.5 -7632.5 2270 -7607.5 2265 -7607.5 2235 -7607.5 2230 -7607.5 2222.5 -7632.5 2222.5 -7675 2222.5 -7680 2227.5 -7680 2250 -7680 {bezier=1}
P 1 14 2265 -7677.5 2270 -7677.5 2275 -7677.5 2275 -7672.5 2275 -7652.5 2275 -7647.5 2270 -7647.5 2260 -7647.5 2255 -7647.5 2255 -7652.5 2255 -7672.5 2255 -7677.5 2260 -7677.5 2265 -7677.5 {bezier=1}
P 1 5 2247.5 -7675 2252.5 -7675 2252.5 -7650 2247.5 -7650 2247.5 -7675 {}
P 2 7 897.5 -5790 893.75 -5795 885 -5795 888.75 -5790 885 -5785 893.75 -5785 897.5 -5790 {fill=true}
P 2 7 1437.5 -5790 1433.75 -5795 1425 -5795 1428.75 -5790 1425 -5785 1433.75 -5785 1437.5 -5790 {fill=true}
P 2 7 2277.5 -5790 2273.75 -5795 2265 -5795 2268.75 -5790 2265 -5785 2273.75 -5785 2277.5 -5790 {fill=true}
P 2 7 2030 -1070 2020 -1080 2030 -1080 2030 -1080 2010 -1090 2020 -1070 2020 -1080 {}
P 2 7 1520 -970 1510 -980 1520 -980 1520 -980 1500 -990 1510 -970 1510 -980 {}
P 2 7 2030 -690 2020 -700 2030 -700 2030 -700 2010 -710 2020 -690 2020 -700 {}
P 2 7 1520 -590 1510 -600 1520 -600 1520 -600 1500 -610 1510 -590 1510 -600 {}
P 3 6 1280 -1650 1280 -1660 1270 -1660 1280 -1680 1290 -1660 1280 -1660 {}
P 3 6 740 -1650 740 -1660 730 -1660 740 -1680 750 -1660 740 -1660 {}
P 5 7 1105 -8820 1101.25 -8825 1092.5 -8825 1096.25 -8820 1092.5 -8815 1101.25 -8815 1105 -8820 {fill=true}
P 5 7 1427.5 -8850 1423.75 -8855 1415 -8855 1418.75 -8850 1415 -8845 1423.75 -8845 1427.5 -8850 {fill=true}
P 5 7 1645 -8820 1641.25 -8825 1632.5 -8825 1636.25 -8820 1632.5 -8815 1641.25 -8815 1645 -8820 {fill=true}
P 5 7 1967.5 -8850 1963.75 -8855 1955 -8855 1958.75 -8850 1955 -8845 1963.75 -8845 1967.5 -8850 {fill=true}
P 5 7 575 -8820 571.25 -8825 562.5 -8825 566.25 -8820 562.5 -8815 571.25 -8815 575 -8820 {fill=true}
P 5 7 897.5 -8850 893.75 -8855 885 -8855 888.75 -8850 885 -8845 893.75 -8845 897.5 -8850 {fill=true}
P 5 7 575 -8360 571.25 -8365 562.5 -8365 566.25 -8360 562.5 -8355 571.25 -8355 575 -8360 {fill=true}
P 5 7 897.5 -8390 893.75 -8395 885 -8395 888.75 -8390 885 -8385 893.75 -8385 897.5 -8390 {fill=true}
P 5 7 1115 -8360 1111.25 -8365 1102.5 -8365 1106.25 -8360 1102.5 -8355 1111.25 -8355 1115 -8360 {fill=true}
P 5 7 1437.5 -8390 1433.75 -8395 1425 -8395 1428.75 -8390 1425 -8385 1433.75 -8385 1437.5 -8390 {fill=true}
P 5 7 575 -6740 571.25 -6745 562.5 -6745 566.25 -6740 562.5 -6735 571.25 -6735 575 -6740 {fill=true}
P 5 7 897.5 -6770 893.75 -6775 885 -6775 888.75 -6770 885 -6765 893.75 -6765 897.5 -6770 {fill=true}
P 5 7 1115 -6740 1111.25 -6745 1102.5 -6745 1106.25 -6740 1102.5 -6735 1111.25 -6735 1115 -6740 {fill=true}
P 5 7 1437.5 -6770 1433.75 -6775 1425 -6775 1428.75 -6770 1425 -6765 1433.75 -6765 1437.5 -6770 {fill=true}
P 5 7 575 -6250 571.25 -6255 562.5 -6255 566.25 -6250 562.5 -6245 571.25 -6245 575 -6250 {fill=true}
P 5 7 897.5 -6280 893.75 -6285 885 -6285 888.75 -6280 885 -6275 893.75 -6275 897.5 -6280 {fill=true}
P 5 7 1115 -6250 1111.25 -6255 1102.5 -6255 1106.25 -6250 1102.5 -6245 1111.25 -6245 1115 -6250 {fill=true}
P 5 7 1437.5 -6280 1433.75 -6285 1425 -6285 1428.75 -6280 1425 -6275 1433.75 -6275 1437.5 -6280 {fill=true}
P 5 7 575 -5760 571.25 -5765 562.5 -5765 566.25 -5760 562.5 -5755 571.25 -5755 575 -5760 {fill=true}
P 5 7 1765 -5760 1761.25 -5765 1752.5 -5765 1756.25 -5760 1752.5 -5755 1761.25 -5755 1765 -5760 {fill=true}
P 5 7 1115 -5760 1111.25 -5765 1102.5 -5765 1106.25 -5760 1102.5 -5755 1111.25 -5755 1115 -5760 {fill=true}
P 5 7 1105 -7990 1101.25 -7995 1092.5 -7995 1096.25 -7990 1092.5 -7985 1101.25 -7985 1105 -7990 {fill=true}
P 5 7 1427.5 -8020 1423.75 -8025 1415 -8025 1418.75 -8020 1415 -8015 1423.75 -8015 1427.5 -8020 {fill=true}
P 5 7 575 -7990 571.25 -7995 562.5 -7995 566.25 -7990 562.5 -7985 571.25 -7985 575 -7990 {fill=true}
P 5 7 897.5 -8020 893.75 -8025 885 -8025 888.75 -8020 885 -8015 893.75 -8015 897.5 -8020 {fill=true}
P 5 7 1605 -7990 1601.25 -7995 1592.5 -7995 1596.25 -7990 1592.5 -7985 1601.25 -7985 1605 -7990 {fill=true}
P 5 7 1927.5 -8020 1923.75 -8025 1915 -8025 1918.75 -8020 1915 -8015 1923.75 -8015 1927.5 -8020 {fill=true}
P 5 7 1645 -9290 1641.25 -9295 1632.5 -9295 1636.25 -9290 1632.5 -9285 1641.25 -9285 1645 -9290 {fill=true}
P 5 7 1967.5 -9320 1963.75 -9325 1955 -9325 1958.75 -9320 1955 -9315 1963.75 -9315 1967.5 -9320 {fill=true}
P 5 7 575 -9290 571.25 -9295 562.5 -9295 566.25 -9290 562.5 -9285 571.25 -9285 575 -9290 {fill=true}
P 5 7 897.5 -9320 893.75 -9325 885 -9325 888.75 -9320 885 -9315 893.75 -9315 897.5 -9320 {fill=true}
P 5 7 2105 -9290 2101.25 -9295 2092.5 -9295 2096.25 -9290 2092.5 -9285 2101.25 -9285 2105 -9290 {fill=true}
P 5 7 2427.5 -9320 2423.75 -9325 2415 -9325 2418.75 -9320 2415 -9315 2423.75 -9315 2427.5 -9320 {fill=true}
P 5 7 595 -5320 591.25 -5325 582.5 -5325 586.25 -5320 582.5 -5315 591.25 -5315 595 -5320 {fill=true}
P 5 7 917.5 -5350 913.75 -5355 905 -5355 908.75 -5350 905 -5345 913.75 -5345 917.5 -5350 {fill=true}
P 5 7 1135 -5320 1131.25 -5325 1122.5 -5325 1126.25 -5320 1122.5 -5315 1131.25 -5315 1135 -5320 {fill=true}
P 5 7 1457.5 -5350 1453.75 -5355 1445 -5355 1448.75 -5350 1445 -5345 1453.75 -5345 1457.5 -5350 {fill=true}
P 5 7 1695 -5320 1691.25 -5325 1682.5 -5325 1686.25 -5320 1682.5 -5315 1691.25 -5315 1695 -5320 {fill=true}
P 5 7 2017.5 -5350 2013.75 -5355 2005 -5355 2008.75 -5350 2005 -5345 2013.75 -5345 2017.5 -5350 {fill=true}
P 5 7 2265 -5320 2261.25 -5325 2252.5 -5325 2256.25 -5320 2252.5 -5315 2261.25 -5315 2265 -5320 {fill=true}
P 5 7 2587.5 -5350 2583.75 -5355 2575 -5355 2578.75 -5350 2575 -5345 2583.75 -5345 2587.5 -5350 {fill=true}
P 5 7 595 -7150 591.25 -7155 582.5 -7155 586.25 -7150 582.5 -7145 591.25 -7145 595 -7150 {fill=true}
P 5 7 917.5 -7180 913.75 -7185 905 -7185 908.75 -7180 905 -7175 913.75 -7175 917.5 -7180 {fill=true}
P 5 7 1135 -7150 1131.25 -7155 1122.5 -7155 1126.25 -7150 1122.5 -7145 1131.25 -7145 1135 -7150 {fill=true}
P 5 7 1457.5 -7180 1453.75 -7185 1445 -7185 1448.75 -7180 1445 -7175 1453.75 -7175 1457.5 -7180 {fill=true}
P 5 7 2265 -7150 2261.25 -7155 2252.5 -7155 2256.25 -7150 2252.5 -7145 2261.25 -7145 2265 -7150 {fill=true}
P 5 7 2587.5 -7180 2583.75 -7185 2575 -7185 2578.75 -7180 2575 -7175 2583.75 -7175 2587.5 -7180 {fill=true}
P 5 7 595 -4940 591.25 -4945 582.5 -4945 586.25 -4940 582.5 -4935 591.25 -4935 595 -4940 {fill=true}
P 5 7 917.5 -4970 913.75 -4975 905 -4975 908.75 -4970 905 -4965 913.75 -4965 917.5 -4970 {fill=true}
P 5 7 1135 -4560 1131.25 -4565 1122.5 -4565 1126.25 -4560 1122.5 -4555 1131.25 -4555 1135 -4560 {fill=true}
P 5 7 1457.5 -4590 1453.75 -4595 1445 -4595 1448.75 -4590 1445 -4585 1453.75 -4585 1457.5 -4590 {fill=true}
P 5 7 2235 -4560 2231.25 -4565 2222.5 -4565 2226.25 -4560 2222.5 -4555 2231.25 -4555 2235 -4560 {fill=true}
P 5 7 2557.5 -4590 2553.75 -4595 2545 -4595 2548.75 -4590 2545 -4585 2553.75 -4585 2557.5 -4590 {fill=true}
P 5 7 1675 -4560 1671.25 -4565 1662.5 -4565 1666.25 -4560 1662.5 -4555 1671.25 -4555 1675 -4560 {fill=true}
P 5 7 1997.5 -4590 1993.75 -4595 1985 -4595 1988.75 -4590 1985 -4585 1993.75 -4585 1997.5 -4590 {fill=true}
P 5 7 1105 -9290 1101.25 -9295 1092.5 -9295 1096.25 -9290 1092.5 -9285 1101.25 -9285 1105 -9290 {fill=true}
P 5 7 1427.5 -9320 1423.75 -9325 1415 -9325 1418.75 -9320 1415 -9315 1423.75 -9315 1427.5 -9320 {fill=true}
P 5 7 655 -190 651.25 -195 642.5 -195 646.25 -190 642.5 -185 651.25 -185 655 -190 {fill=true}
P 5 7 977.5 -220 973.75 -225 965 -225 968.75 -220 965 -215 973.75 -215 977.5 -220 {fill=true}
P 5 7 1305 -190 1301.25 -195 1292.5 -195 1296.25 -190 1292.5 -185 1301.25 -185 1305 -190 {fill=true}
P 5 7 1627.5 -220 1623.75 -225 1615 -225 1618.75 -220 1615 -215 1623.75 -215 1627.5 -220 {fill=true}
P 5 7 1135 -4940 1131.25 -4945 1122.5 -4945 1126.25 -4940 1122.5 -4935 1131.25 -4935 1135 -4940 {fill=true}
P 5 7 1457.5 -4970 1453.75 -4975 1445 -4975 1448.75 -4970 1445 -4965 1453.75 -4965 1457.5 -4970 {fill=true}
P 5 7 1695 -4940 1691.25 -4945 1682.5 -4945 1686.25 -4940 1682.5 -4935 1691.25 -4935 1695 -4940 {fill=true}
P 5 7 2017.5 -4970 2013.75 -4975 2005 -4975 2008.75 -4970 2005 -4965 2013.75 -4965 2017.5 -4970 {fill=true}
P 5 7 2265 -4940 2261.25 -4945 2252.5 -4945 2256.25 -4940 2252.5 -4935 2261.25 -4935 2265 -4940 {fill=true}
P 5 7 2587.5 -4970 2583.75 -4975 2575 -4975 2578.75 -4970 2575 -4965 2583.75 -4965 2587.5 -4970 {fill=true}
P 5 7 1865 -190 1861.25 -195 1852.5 -195 1856.25 -190 1852.5 -185 1861.25 -185 1865 -190 {fill=true}
P 5 7 2187.5 -220 2183.75 -225 2175 -225 2178.75 -220 2175 -215 2183.75 -215 2187.5 -220 {fill=true}
P 5 7 595 -4560 591.25 -4565 582.5 -4565 586.25 -4560 582.5 -4555 591.25 -4555 595 -4560 {fill=true}
P 5 7 917.5 -4590 913.75 -4595 905 -4595 908.75 -4590 905 -4585 913.75 -4585 917.5 -4590 {fill=true}
P 7 14 905 -8677.5 910 -8677.5 915 -8677.5 915 -8672.5 915 -8652.5 915 -8647.5 910 -8647.5 900 -8647.5 895 -8647.5 895 -8652.5 895 -8672.5 895 -8677.5 900 -8677.5 905 -8677.5 {fill=1
bezier=1}
P 7 14 1335 -8677.5 1340 -8677.5 1345 -8677.5 1345 -8672.5 1345 -8652.5 1345 -8647.5 1340 -8647.5 1330 -8647.5 1325 -8647.5 1325 -8652.5 1325 -8672.5 1325 -8677.5 1330 -8677.5 1335 -8677.5 {fill=1
bezier=1}
P 7 14 1405 -8487.5 1410 -8487.5 1415 -8487.5 1415 -8482.5 1415 -8462.5 1415 -8457.5 1410 -8457.5 1400 -8457.5 1395 -8457.5 1395 -8462.5 1395 -8482.5 1395 -8487.5 1400 -8487.5 1405 -8487.5 {fill=1
bezier=1}
P 7 14 1425 -6877.5 1430 -6877.5 1435 -6877.5 1435 -6872.5 1435 -6852.5 1435 -6847.5 1430 -6847.5 1420 -6847.5 1415 -6847.5 1415 -6852.5 1415 -6872.5 1415 -6877.5 1420 -6877.5 1425 -6877.5 {fill=1
bezier=1}
P 7 14 1425 -6387.5 1430 -6387.5 1435 -6387.5 1435 -6382.5 1435 -6362.5 1435 -6357.5 1430 -6357.5 1420 -6357.5 1415 -6357.5 1415 -6362.5 1415 -6382.5 1415 -6387.5 1420 -6387.5 1425 -6387.5 {fill=1
bezier=1}
P 7 14 935 -5657.5 940 -5657.5 945 -5657.5 945 -5652.5 945 -5632.5 945 -5627.5 940 -5627.5 930 -5627.5 925 -5627.5 925 -5632.5 925 -5652.5 925 -5657.5 930 -5657.5 935 -5657.5 {fill=1
bezier=1}
P 7 14 1415 -5667.5 1420 -5667.5 1425 -5667.5 1425 -5662.5 1425 -5642.5 1425 -5637.5 1420 -5637.5 1410 -5637.5 1405 -5637.5 1405 -5642.5 1405 -5662.5 1405 -5667.5 1410 -5667.5 1415 -5667.5 {fill=1
bezier=1}
P 7 14 905 -7847.5 910 -7847.5 915 -7847.5 915 -7842.5 915 -7822.5 915 -7817.5 910 -7817.5 900 -7817.5 895 -7817.5 895 -7822.5 895 -7842.5 895 -7847.5 900 -7847.5 905 -7847.5 {fill=1
bezier=1}
P 7 14 905 -9147.5 910 -9147.5 915 -9147.5 915 -9142.5 915 -9122.5 915 -9117.5 910 -9117.5 900 -9117.5 895 -9117.5 895 -9122.5 895 -9142.5 895 -9147.5 900 -9147.5 905 -9147.5 {fill=1
bezier=1}
P 7 14 1615 -9137.5 1620 -9137.5 1625 -9137.5 1625 -9132.5 1625 -9112.5 1625 -9107.5 1620 -9107.5 1610 -9107.5 1605 -9107.5 1605 -9112.5 1605 -9132.5 1605 -9137.5 1610 -9137.5 1615 -9137.5 {fill=1
bezier=1}
P 7 14 2395 -9127.5 2400 -9127.5 2405 -9127.5 2405 -9122.5 2405 -9102.5 2405 -9097.5 2400 -9097.5 2390 -9097.5 2385 -9097.5 2385 -9102.5 2385 -9122.5 2385 -9127.5 2390 -9127.5 2395 -9127.5 {fill=1
bezier=1}
P 7 14 1475 -5467.5 1480 -5467.5 1485 -5467.5 1485 -5462.5 1485 -5442.5 1485 -5437.5 1480 -5437.5 1470 -5437.5 1465 -5437.5 1465 -5442.5 1465 -5462.5 1465 -5467.5 1470 -5467.5 1475 -5467.5 {fill=1
bezier=1}
P 7 14 1925 -5537.5 1930 -5537.5 1935 -5537.5 1935 -5532.5 1935 -5512.5 1935 -5507.5 1930 -5507.5 1920 -5507.5 1915 -5507.5 1915 -5512.5 1915 -5532.5 1915 -5537.5 1920 -5537.5 1925 -5537.5 {fill=1
bezier=1}
P 7 14 675 -7267.5 680 -7267.5 685 -7267.5 685 -7262.5 685 -7242.5 685 -7237.5 680 -7237.5 670 -7237.5 665 -7237.5 665 -7242.5 665 -7262.5 665 -7267.5 670 -7267.5 675 -7267.5 {fill=1
bezier=1}
P 7 14 1335 -7287.5 1340 -7287.5 1345 -7287.5 1345 -7282.5 1345 -7262.5 1345 -7257.5 1340 -7257.5 1330 -7257.5 1325 -7257.5 1325 -7262.5 1325 -7282.5 1325 -7287.5 1330 -7287.5 1335 -7287.5 {fill=1
bezier=1}
P 7 14 1375 -4727.5 1380 -4727.5 1385 -4727.5 1385 -4722.5 1385 -4702.5 1385 -4697.5 1380 -4697.5 1370 -4697.5 1365 -4697.5 1365 -4702.5 1365 -4722.5 1365 -4727.5 1370 -4727.5 1375 -4727.5 {fill=1}
P 7 14 1775 -4677.5 1780 -4677.5 1785 -4677.5 1785 -4672.5 1785 -4652.5 1785 -4647.5 1780 -4647.5 1770 -4647.5 1765 -4647.5 1765 -4652.5 1765 -4672.5 1765 -4677.5 1770 -4677.5 1775 -4677.5 {fill=1
bezier=1}
P 7 14 1415 -4157.5 1420 -4157.5 1425 -4157.5 1425 -4152.5 1425 -4132.5 1425 -4127.5 1420 -4127.5 1410 -4127.5 1405 -4127.5 1405 -4132.5 1405 -4152.5 1405 -4157.5 1410 -4157.5 1415 -4157.5 {fill=1
bezier=1}
P 7 14 1685 -4157.5 1690 -4157.5 1695 -4157.5 1695 -4152.5 1695 -4132.5 1695 -4127.5 1690 -4127.5 1680 -4127.5 1675 -4127.5 1675 -4132.5 1675 -4152.5 1675 -4157.5 1680 -4157.5 1685 -4157.5 {fill=1
bezier=1}
P 7 14 1415 -3777.5 1420 -3777.5 1425 -3777.5 1425 -3772.5 1425 -3752.5 1425 -3747.5 1420 -3747.5 1410 -3747.5 1405 -3747.5 1405 -3752.5 1405 -3772.5 1405 -3777.5 1410 -3777.5 1415 -3777.5 {fill=1
bezier=1}
P 7 14 2065 -1047.5 2070 -1047.5 2075 -1047.5 2075 -1042.5 2075 -1022.5 2075 -1017.5 2070 -1017.5 2060 -1017.5 2055 -1017.5 2055 -1022.5 2055 -1042.5 2055 -1047.5 2060 -1047.5 2065 -1047.5 {fill=1
bezier=1}
P 7 14 1555 -1017.5 1560 -1017.5 1565 -1017.5 1565 -1012.5 1565 -992.5 1565 -987.5 1560 -987.5 1550 -987.5 1545 -987.5 1545 -992.5 1545 -1012.5 1545 -1017.5 1550 -1017.5 1555 -1017.5 {fill=1
bezier=1}
P 7 14 1445 -3417.5 1440 -3417.5 1435 -3417.5 1435 -3412.5 1435 -3392.5 1435 -3387.5 1440 -3387.5 1450 -3387.5 1455 -3387.5 1455 -3392.5 1455 -3412.5 1455 -3417.5 1450 -3417.5 1445 -3417.5 {fill=1
bezier=1}
P 7 14 1945 -3527.5 1950 -3527.5 1955 -3527.5 1955 -3522.5 1955 -3502.5 1955 -3497.5 1950 -3497.5 1940 -3497.5 1935 -3497.5 1935 -3502.5 1935 -3522.5 1935 -3527.5 1940 -3527.5 1945 -3527.5 {fill=1
bezier=1}
P 7 14 1565 -3007.5 1570 -3007.5 1575 -3007.5 1575 -3002.5 1575 -2982.5 1575 -2977.5 1570 -2977.5 1560 -2977.5 1555 -2977.5 1555 -2982.5 1555 -3002.5 1555 -3007.5 1560 -3007.5 1565 -3007.5 {fill=1
bezier=1}
P 7 14 2055 -3067.5 2060 -3067.5 2065 -3067.5 2065 -3062.5 2065 -3042.5 2065 -3037.5 2060 -3037.5 2050 -3037.5 2045 -3037.5 2045 -3042.5 2045 -3062.5 2045 -3067.5 2050 -3067.5 2055 -3067.5 {fill=1
bezier=1}
P 7 14 975 -9417.5 980 -9417.5 985 -9417.5 985 -9412.5 985 -9392.5 985 -9387.5 980 -9387.5 970 -9387.5 965 -9387.5 965 -9392.5 965 -9412.5 965 -9417.5 970 -9417.5 975 -9417.5 {fill=1
bezier=1}
P 7 14 1555 -637.5 1560 -637.5 1565 -637.5 1565 -632.5 1565 -612.5 1565 -607.5 1560 -607.5 1550 -607.5 1545 -607.5 1545 -612.5 1545 -632.5 1545 -637.5 1550 -637.5 1555 -637.5 {fill=1
bezier=1}
P 7 14 2065 -587.5 2070 -587.5 2075 -587.5 2075 -582.5 2075 -562.5 2075 -557.5 2070 -557.5 2060 -557.5 2055 -557.5 2055 -562.5 2055 -582.5 2055 -587.5 2060 -587.5 2065 -587.5 {fill=1
bezier=1}
P 7 14 2485 -3447.5 2490 -3447.5 2495 -3447.5 2495 -3442.5 2495 -3422.5 2495 -3417.5 2490 -3417.5 2480 -3417.5 2475 -3417.5 2475 -3422.5 2475 -3442.5 2475 -3447.5 2480 -3447.5 2485 -3447.5 {fill=1
bezier=1}
P 7 14 1805 -1487.5 1810 -1487.5 1815 -1487.5 1815 -1482.5 1815 -1462.5 1815 -1457.5 1810 -1457.5 1800 -1457.5 1795 -1457.5 1795 -1462.5 1795 -1482.5 1795 -1487.5 1800 -1487.5 1805 -1487.5 {fill=1
bezier=1}
P 7 14 655 -1417.5 660 -1417.5 665 -1417.5 665 -1412.5 665 -1392.5 665 -1387.5 660 -1387.5 650 -1387.5 645 -1387.5 645 -1392.5 645 -1412.5 645 -1417.5 650 -1417.5 655 -1417.5 {fill=1
bezier=1}
P 7 14 775 -1417.5 780 -1417.5 785 -1417.5 785 -1412.5 785 -1392.5 785 -1387.5 780 -1387.5 770 -1387.5 765 -1387.5 765 -1392.5 765 -1412.5 765 -1417.5 770 -1417.5 775 -1417.5 {fill=1
bezier=1}
P 7 14 1665 -87.5 1660 -87.5 1655 -87.5 1655 -82.5 1655 -62.5 1655 -57.5 1660 -57.5 1670 -57.5 1675 -57.5 1675 -62.5 1675 -82.5 1675 -87.5 1670 -87.5 1665 -87.5 {fill=1
bezier=1}
P 7 14 445 -4907.5 450 -4907.5 455 -4907.5 455 -4902.5 455 -4882.5 455 -4877.5 450 -4877.5 440 -4877.5 435 -4877.5 435 -4882.5 435 -4902.5 435 -4907.5 440 -4907.5 445 -4907.5 {fill=1
bezier=1}
P 7 14 985 -5087.5 990 -5087.5 995 -5087.5 995 -5082.5 995 -5062.5 995 -5057.5 990 -5057.5 980 -5057.5 975 -5057.5 975 -5062.5 975 -5082.5 975 -5087.5 980 -5087.5 985 -5087.5 {fill=1
bezier=1}
P 7 14 1995 -4877.5 2000 -4877.5 2005 -4877.5 2005 -4872.5 2005 -4852.5 2005 -4847.5 2000 -4847.5 1990 -4847.5 1985 -4847.5 1985 -4852.5 1985 -4872.5 1985 -4877.5 1990 -4877.5 1995 -4877.5 {fill=1
bezier=1}
P 7 14 2565 -4877.5 2570 -4877.5 2575 -4877.5 2575 -4872.5 2575 -4852.5 2575 -4847.5 2570 -4847.5 2560 -4847.5 2555 -4847.5 2555 -4852.5 2555 -4872.5 2555 -4877.5 2560 -4877.5 2565 -4877.5 {fill=1
bezier=1}
P 7 14 2265 -5667.5 2270 -5667.5 2275 -5667.5 2275 -5662.5 2275 -5642.5 2275 -5637.5 2270 -5637.5 2260 -5637.5 2255 -5637.5 2255 -5642.5 2255 -5662.5 2255 -5667.5 2260 -5667.5 2265 -5667.5 {fill=1
bezier=1}
P 7 14 1965 -3777.5 1970 -3777.5 1975 -3777.5 1975 -3772.5 1975 -3752.5 1975 -3747.5 1970 -3747.5 1960 -3747.5 1955 -3747.5 1955 -3752.5 1955 -3772.5 1955 -3777.5 1960 -3777.5 1965 -3777.5 {fill=1
bezier=1}
P 7 14 2325 -2077.5 2330 -2077.5 2335 -2077.5 2335 -2072.5 2335 -2052.5 2335 -2047.5 2330 -2047.5 2320 -2047.5 2315 -2047.5 2315 -2052.5 2315 -2072.5 2315 -2077.5 2320 -2077.5 2325 -2077.5 {fill=1
bezier=1}
P 7 14 795 -2197.5 800 -2197.5 805 -2197.5 805 -2192.5 805 -2172.5 805 -2167.5 800 -2167.5 790 -2167.5 785 -2167.5 785 -2172.5 785 -2192.5 785 -2197.5 790 -2197.5 795 -2197.5 {fill=1
bezier=1}
P 7 14 1335 -2177.5 1340 -2177.5 1345 -2177.5 1345 -2172.5 1345 -2152.5 1345 -2147.5 1340 -2147.5 1330 -2147.5 1325 -2147.5 1325 -2152.5 1325 -2172.5 1325 -2177.5 1330 -2177.5 1335 -2177.5 {fill=1
bezier=1}
P 7 14 1245 -1797.5 1250 -1797.5 1255 -1797.5 1255 -1792.5 1255 -1772.5 1255 -1767.5 1250 -1767.5 1240 -1767.5 1235 -1767.5 1235 -1772.5 1235 -1792.5 1235 -1797.5 1240 -1797.5 1245 -1797.5 {fill=1
bezier=1}
P 7 14 2505 -1747.5 2510 -1747.5 2515 -1747.5 2515 -1742.5 2515 -1722.5 2515 -1717.5 2510 -1717.5 2500 -1717.5 2495 -1717.5 2495 -1722.5 2495 -1742.5 2495 -1747.5 2500 -1747.5 2505 -1747.5 {fill=1
bezier=1}
P 7 14 2465 -337.5 2460 -337.5 2455 -337.5 2455 -332.5 2455 -312.5 2455 -307.5 2460 -307.5 2470 -307.5 2475 -307.5 2475 -312.5 2475 -332.5 2475 -337.5 2470 -337.5 2465 -337.5 {fill=1
bezier=1}
P 7 14 445 -4567.5 450 -4567.5 455 -4567.5 455 -4562.5 455 -4542.5 455 -4537.5 450 -4537.5 440 -4537.5 435 -4537.5 435 -4542.5 435 -4562.5 435 -4567.5 440 -4567.5 445 -4567.5 {fill=1}
P 7 14 2525 -7337.5 2530 -7337.5 2535 -7337.5 2535 -7332.5 2535 -7312.5 2535 -7307.5 2530 -7307.5 2520 -7307.5 2515 -7307.5 2515 -7312.5 2515 -7332.5 2515 -7337.5 2520 -7337.5 2525 -7337.5 {fill=1
bezier=1}
P 7 14 805 -5437.5 810 -5437.5 815 -5437.5 815 -5432.5 815 -5412.5 815 -5407.5 810 -5407.5 800 -5407.5 795 -5407.5 795 -5412.5 795 -5432.5 795 -5437.5 800 -5437.5 805 -5437.5 {fill=1
bezier=1}
P 7 14 2545 -5447.5 2550 -5447.5 2555 -5447.5 2555 -5442.5 2555 -5422.5 2555 -5417.5 2550 -5417.5 2540 -5417.5 2535 -5417.5 2535 -5422.5 2535 -5442.5 2535 -5447.5 2540 -5447.5 2545 -5447.5 {fill=1
bezier=1}
P 7 14 1335 -7847.5 1340 -7847.5 1345 -7847.5 1345 -7842.5 1345 -7822.5 1345 -7817.5 1340 -7817.5 1330 -7817.5 1325 -7817.5 1325 -7822.5 1325 -7842.5 1325 -7847.5 1330 -7847.5 1335 -7847.5 {fill=1
bezier=1}
P 7 14 2105 -7847.5 2110 -7847.5 2115 -7847.5 2115 -7842.5 2115 -7822.5 2115 -7817.5 2110 -7817.5 2100 -7817.5 2095 -7817.5 2095 -7822.5 2095 -7842.5 2095 -7847.5 2100 -7847.5 2105 -7847.5 {fill=1
bezier=1}
P 7 14 465 -7597.5 470 -7597.5 475 -7597.5 475 -7592.5 475 -7572.5 475 -7567.5 470 -7567.5 460 -7567.5 455 -7567.5 455 -7572.5 455 -7592.5 455 -7597.5 460 -7597.5 465 -7597.5 {fill=1
bezier=1}
P 7 14 655 -7707.5 660 -7707.5 665 -7707.5 665 -7702.5 665 -7682.5 665 -7677.5 660 -7677.5 650 -7677.5 645 -7677.5 645 -7682.5 645 -7702.5 645 -7707.5 650 -7707.5 655 -7707.5 {fill=1
bezier=1}
P 7 14 885 -7667.5 890 -7667.5 895 -7667.5 895 -7662.5 895 -7642.5 895 -7637.5 890 -7637.5 880 -7637.5 875 -7637.5 875 -7642.5 875 -7662.5 875 -7667.5 880 -7667.5 885 -7667.5 {fill=1
bezier=1}
P 7 14 1095 -7707.5 1100 -7707.5 1105 -7707.5 1105 -7702.5 1105 -7682.5 1105 -7677.5 1100 -7677.5 1090 -7677.5 1085 -7677.5 1085 -7682.5 1085 -7702.5 1085 -7707.5 1090 -7707.5 1095 -7707.5 {fill=1
bezier=1}
P 7 14 1365 -7707.5 1370 -7707.5 1375 -7707.5 1375 -7702.5 1375 -7682.5 1375 -7677.5 1370 -7677.5 1360 -7677.5 1355 -7677.5 1355 -7682.5 1355 -7702.5 1355 -7707.5 1360 -7707.5 1365 -7707.5 {fill=1
bezier=1}
P 7 14 1705 -7567.5 1710 -7567.5 1715 -7567.5 1715 -7562.5 1715 -7542.5 1715 -7537.5 1710 -7537.5 1700 -7537.5 1695 -7537.5 1695 -7542.5 1695 -7562.5 1695 -7567.5 1700 -7567.5 1705 -7567.5 {fill=1
bezier=1}
P 7 14 1955 -7677.5 1960 -7677.5 1965 -7677.5 1965 -7672.5 1965 -7652.5 1965 -7647.5 1960 -7647.5 1950 -7647.5 1945 -7647.5 1945 -7652.5 1945 -7672.5 1945 -7677.5 1950 -7677.5 1955 -7677.5 {fill=1
bezier=1}
P 7 14 2575 -7677.5 2580 -7677.5 2585 -7677.5 2585 -7672.5 2585 -7652.5 2585 -7647.5 2580 -7647.5 2570 -7647.5 2565 -7647.5 2565 -7652.5 2565 -7672.5 2565 -7677.5 2570 -7677.5 2575 -7677.5 {fill=1
bezier=1}
P 7 14 2235 -7677.5 2240 -7677.5 2245 -7677.5 2245 -7672.5 2245 -7652.5 2245 -7647.5 2240 -7647.5 2230 -7647.5 2225 -7647.5 2225 -7652.5 2225 -7672.5 2225 -7677.5 2230 -7677.5 2235 -7677.5 {fill=1
bezier=1}
P 7 14 2285 -4157.5 2290 -4157.5 2295 -4157.5 2295 -4152.5 2295 -4132.5 2295 -4127.5 2290 -4127.5 2280 -4127.5 2275 -4127.5 2275 -4132.5 2275 -4152.5 2275 -4157.5 2280 -4157.5 2285 -4157.5 {fill=1
bezier=1}
P 7 14 2335 -4707.5 2340 -4707.5 2345 -4707.5 2345 -4702.5 2345 -4682.5 2345 -4677.5 2340 -4677.5 2330 -4677.5 2325 -4677.5 2325 -4682.5 2325 -4702.5 2325 -4707.5 2330 -4707.5 2335 -4707.5 {fill=1
bezier=1}
P 7 14 2105 -8677.5 2110 -8677.5 2115 -8677.5 2115 -8672.5 2115 -8652.5 2115 -8647.5 2110 -8647.5 2100 -8647.5 2095 -8647.5 2095 -8652.5 2095 -8672.5 2095 -8677.5 2100 -8677.5 2105 -8677.5 {fill=1
bezier=1}
P 7 14 2585 -3197.5 2590 -3197.5 2595 -3197.5 2595 -3192.5 2595 -3172.5 2595 -3167.5 2590 -3167.5 2580 -3167.5 2575 -3167.5 2575 -3172.5 2575 -3192.5 2575 -3197.5 2580 -3197.5 2585 -3197.5 {fill=1
bezier=1}
P 9 8 1770 -7230 1912.5 -7202.5 1890 -7170 1980 -7110 1960 -7080 1870 -7140 1845 -7105 1770 -7230 {fill=0}
P 10 7 880 -8650 872.5 -8657.5 877.5 -8662.5 862.5 -8667.5 867.5 -8652.5 872.5 -8657.5 880 -8650 {fill=1}
P 10 7 2110 -8700 2102.5 -8707.5 2107.5 -8712.5 2092.5 -8717.5 2097.5 -8702.5 2102.5 -8707.5 2110 -8700 {fill=1}
P 10 7 1330 -8690 1322.5 -8697.5 1327.5 -8702.5 1312.5 -8707.5 1317.5 -8692.5 1322.5 -8697.5 1330 -8690 {fill=1}
P 10 7 760 -8430 752.5 -8437.5 757.5 -8442.5 742.5 -8447.5 747.5 -8432.5 752.5 -8437.5 760 -8430 {fill=1}
P 10 7 1380 -8430 1372.5 -8437.5 1377.5 -8442.5 1362.5 -8447.5 1367.5 -8432.5 1372.5 -8437.5 1380 -8430 {fill=1}
P 10 7 760 -6810 752.5 -6817.5 757.5 -6822.5 742.5 -6827.5 747.5 -6812.5 752.5 -6817.5 760 -6810 {fill=1}
P 10 7 1380 -6810 1372.5 -6817.5 1377.5 -6822.5 1362.5 -6827.5 1367.5 -6812.5 1372.5 -6817.5 1380 -6810 {fill=1}
P 10 7 760 -6320 752.5 -6327.5 757.5 -6332.5 742.5 -6337.5 747.5 -6322.5 752.5 -6327.5 760 -6320 {fill=1}
P 10 7 1380 -6320 1372.5 -6327.5 1377.5 -6332.5 1362.5 -6337.5 1367.5 -6322.5 1372.5 -6327.5 1380 -6320 {fill=1}
P 10 7 920 -5600 912.5 -5607.5 917.5 -5612.5 902.5 -5617.5 907.5 -5602.5 912.5 -5607.5 920 -5600 {fill=1}
P 10 7 1390 -5660 1382.5 -5667.5 1387.5 -5672.5 1372.5 -5677.5 1377.5 -5662.5 1382.5 -5667.5 1390 -5660 {fill=1}
P 10 7 2240 -5660 2232.5 -5667.5 2237.5 -5672.5 2222.5 -5677.5 2227.5 -5662.5 2232.5 -5667.5 2240 -5660 {fill=1}
P 10 7 880 -7820 872.5 -7827.5 877.5 -7832.5 862.5 -7837.5 867.5 -7822.5 872.5 -7827.5 880 -7820 {fill=1}
P 10 7 2110 -7870 2102.5 -7877.5 2107.5 -7882.5 2092.5 -7887.5 2097.5 -7872.5 2102.5 -7877.5 2110 -7870 {fill=1}
P 10 7 1330 -7860 1322.5 -7867.5 1327.5 -7872.5 1312.5 -7877.5 1317.5 -7862.5 1322.5 -7867.5 1330 -7860 {fill=1}
P 10 7 880 -9120 872.5 -9127.5 877.5 -9132.5 862.5 -9137.5 867.5 -9122.5 872.5 -9127.5 880 -9120 {fill=1}
P 10 7 1630 -9150 1622.5 -9157.5 1627.5 -9162.5 1612.5 -9167.5 1617.5 -9152.5 1622.5 -9157.5 1630 -9150 {fill=1}
P 10 7 2410 -9140 2402.5 -9147.5 2407.5 -9152.5 2392.5 -9157.5 2397.5 -9142.5 2402.5 -9147.5 2410 -9140 {fill=1}
P 10 7 780 -5420 772.5 -5427.5 777.5 -5432.5 762.5 -5437.5 767.5 -5422.5 772.5 -5427.5 780 -5420 {fill=1}
P 10 7 1450 -5420 1442.5 -5427.5 1447.5 -5432.5 1432.5 -5437.5 1437.5 -5422.5 1442.5 -5427.5 1450 -5420 {fill=1}
P 10 7 1950 -5420 1942.5 -5427.5 1947.5 -5432.5 1932.5 -5437.5 1937.5 -5422.5 1942.5 -5427.5 1950 -5420 {fill=1}
P 10 7 2520 -5450 2512.5 -5457.5 2517.5 -5462.5 2502.5 -5467.5 2507.5 -5452.5 2512.5 -5457.5 2520 -5450 {fill=1}
P 10 7 730 -7280 722.5 -7287.5 727.5 -7292.5 712.5 -7297.5 717.5 -7282.5 722.5 -7287.5 730 -7280 {fill=1}
P 10 7 1310 -7280 1302.5 -7287.5 1307.5 -7292.5 1292.5 -7297.5 1297.5 -7282.5 1302.5 -7287.5 1310 -7280 {fill=1}
P 10 7 2520 -7350 2512.5 -7357.5 2517.5 -7362.5 2502.5 -7367.5 2507.5 -7352.5 2512.5 -7357.5 2520 -7350 {fill=1}
P 10 7 1360 -4730 1352.5 -4737.5 1357.5 -4742.5 1342.5 -4747.5 1347.5 -4732.5 1352.5 -4737.5 1360 -4730 {fill=1}
P 10 7 2360 -4720 2352.5 -4727.5 2357.5 -4732.5 2342.5 -4737.5 2347.5 -4722.5 2352.5 -4727.5 2360 -4720 {fill=1}
P 10 7 1800 -4690 1792.5 -4697.5 1797.5 -4702.5 1782.5 -4707.5 1787.5 -4692.5 1792.5 -4697.5 1800 -4690 {fill=1}
P 10 7 1380 -3770 1372.5 -3777.5 1377.5 -3782.5 1362.5 -3787.5 1367.5 -3772.5 1372.5 -3777.5 1380 -3770 {fill=1}
P 10 7 1920 -3810 1912.5 -3817.5 1917.5 -3822.5 1902.5 -3827.5 1907.5 -3812.5 1912.5 -3817.5 1920 -3810 {fill=1}
P 10 7 1380 -4150 1372.5 -4157.5 1377.5 -4162.5 1362.5 -4167.5 1367.5 -4152.5 1372.5 -4157.5 1380 -4150 {fill=1}
P 10 7 1800 -4150 1792.5 -4157.5 1797.5 -4162.5 1782.5 -4167.5 1787.5 -4152.5 1792.5 -4157.5 1800 -4150 {fill=1}
P 10 7 2280 -4170 2272.5 -4177.5 2277.5 -4182.5 2262.5 -4187.5 2267.5 -4172.5 2272.5 -4177.5 2280 -4170 {fill=1}
P 10 7 660 -2670 652.5 -2677.5 657.5 -2682.5 642.5 -2687.5 647.5 -2672.5 652.5 -2677.5 660 -2670 {fill=1}
P 10 7 1240 -2670 1232.5 -2677.5 1237.5 -2682.5 1222.5 -2687.5 1227.5 -2672.5 1232.5 -2677.5 1240 -2670 {fill=1}
P 10 7 1010 -9430 1002.5 -9437.5 1007.5 -9442.5 992.5 -9447.5 997.5 -9432.5 1002.5 -9437.5 1010 -9430 {fill=1}
P 10 7 680 -2430 672.5 -2437.5 677.5 -2442.5 662.5 -2447.5 667.5 -2432.5 672.5 -2437.5 680 -2430 {fill=1}
P 10 7 1300 -2340 1292.5 -2347.5 1297.5 -2352.5 1282.5 -2357.5 1287.5 -2342.5 1292.5 -2347.5 1300 -2340 {fill=1}
P 10 7 760 -2160 752.5 -2167.5 757.5 -2172.5 742.5 -2177.5 747.5 -2162.5 752.5 -2167.5 760 -2160 {fill=1}
P 10 7 1300 -2130 1292.5 -2137.5 1297.5 -2142.5 1282.5 -2147.5 1287.5 -2132.5 1292.5 -2137.5 1300 -2130 {fill=1}
P 10 7 2350 -2100 2342.5 -2107.5 2347.5 -2112.5 2332.5 -2117.5 2337.5 -2102.5 2342.5 -2107.5 2350 -2100 {fill=1}
P 10 7 1830 -1380 1822.5 -1387.5 1827.5 -1392.5 1812.5 -1397.5 1817.5 -1382.5 1822.5 -1387.5 1830 -1380 {fill=1}
P 10 7 700 -1450 692.5 -1457.5 697.5 -1462.5 682.5 -1467.5 687.5 -1452.5 692.5 -1457.5 700 -1450 {fill=1}
P 10 7 820 -1450 812.5 -1457.5 817.5 -1462.5 802.5 -1467.5 807.5 -1452.5 812.5 -1457.5 820 -1450 {fill=1}
P 10 7 930 -170 922.5 -177.5 927.5 -182.5 912.5 -187.5 917.5 -172.5 922.5 -177.5 930 -170 {fill=1}
P 10 7 1580 -170 1572.5 -177.5 1577.5 -182.5 1562.5 -187.5 1567.5 -172.5 1572.5 -177.5 1580 -170 {fill=1}
P 10 7 760 -1730 752.5 -1737.5 757.5 -1742.5 742.5 -1747.5 747.5 -1732.5 752.5 -1737.5 760 -1730 {fill=1}
P 10 7 1220 -1780 1212.5 -1787.5 1217.5 -1792.5 1202.5 -1797.5 1207.5 -1782.5 1212.5 -1787.5 1220 -1780 {fill=1}
P 10 7 540 -4890 532.5 -4897.5 537.5 -4902.5 522.5 -4907.5 527.5 -4892.5 532.5 -4897.5 540 -4890 {fill=1}
P 10 7 1080 -5070 1072.5 -5077.5 1077.5 -5082.5 1062.5 -5087.5 1067.5 -5072.5 1072.5 -5077.5 1080 -5070 {fill=1}
P 10 7 1970 -4810 1962.5 -4817.5 1967.5 -4822.5 1952.5 -4827.5 1957.5 -4812.5 1962.5 -4817.5 1970 -4810 {fill=1}
P 10 7 2540 -4860 2532.5 -4867.5 2537.5 -4872.5 2522.5 -4877.5 2527.5 -4862.5 2532.5 -4867.5 2540 -4860 {fill=1}
P 10 7 840 -3420 832.5 -3427.5 837.5 -3432.5 822.5 -3437.5 827.5 -3422.5 832.5 -3427.5 840 -3420 {fill=1}
P 10 7 1380 -3420 1372.5 -3427.5 1377.5 -3432.5 1362.5 -3437.5 1367.5 -3422.5 1372.5 -3427.5 1380 -3420 {fill=1}
P 10 7 1920 -3500 1912.5 -3507.5 1917.5 -3512.5 1902.5 -3517.5 1907.5 -3502.5 1912.5 -3507.5 1920 -3500 {fill=1}
P 10 7 2460 -3420 2452.5 -3427.5 2457.5 -3432.5 2442.5 -3437.5 2447.5 -3422.5 2452.5 -3427.5 2460 -3420 {fill=1}
P 10 7 2560 -3170 2552.5 -3177.5 2557.5 -3182.5 2542.5 -3187.5 2547.5 -3172.5 2552.5 -3177.5 2560 -3170 {fill=1}
P 10 7 2030 -3070 2022.5 -3077.5 2027.5 -3082.5 2012.5 -3087.5 2017.5 -3072.5 2022.5 -3077.5 2030 -3070 {fill=1}
P 10 7 1520 -3060 1512.5 -3067.5 1517.5 -3072.5 1502.5 -3077.5 1507.5 -3062.5 1512.5 -3067.5 1520 -3060 {fill=1}
P 10 8 1770 -7230 1912.5 -7202.5 1890 -7170 1980 -7110 1960 -7080 1870 -7140 1845 -7105 1770 -7230 {fill=1}
P 10 7 2470 -1740 2462.5 -1747.5 2467.5 -1752.5 2452.5 -1757.5 2457.5 -1742.5 2462.5 -1747.5 2470 -1740 {fill=1}
P 10 7 2450 -350 2442.5 -357.5 2447.5 -362.5 2432.5 -367.5 2437.5 -352.5 2442.5 -357.5 2450 -350 {fill=1}
P 10 7 480 -4580 472.5 -4587.5 477.5 -4592.5 462.5 -4597.5 467.5 -4582.5 472.5 -4587.5 480 -4580 {fill=1}
P 10 7 440 -7570 432.5 -7577.5 437.5 -7582.5 422.5 -7587.5 427.5 -7572.5 432.5 -7577.5 440 -7570 {fill=1}
P 10 7 630 -7680 622.5 -7687.5 627.5 -7692.5 612.5 -7697.5 617.5 -7682.5 622.5 -7687.5 630 -7680 {fill=1}
P 10 7 860 -7640 852.5 -7647.5 857.5 -7652.5 842.5 -7657.5 847.5 -7642.5 852.5 -7647.5 860 -7640 {fill=1}
P 10 7 1070 -7680 1062.5 -7687.5 1067.5 -7692.5 1052.5 -7697.5 1057.5 -7682.5 1062.5 -7687.5 1070 -7680 {fill=1}
P 10 7 1340 -7680 1332.5 -7687.5 1337.5 -7692.5 1322.5 -7697.5 1327.5 -7682.5 1332.5 -7687.5 1340 -7680 {fill=1}
P 10 7 1680 -7540 1672.5 -7547.5 1677.5 -7552.5 1662.5 -7557.5 1667.5 -7542.5 1672.5 -7547.5 1680 -7540 {fill=1}
P 10 7 1930 -7680 1922.5 -7687.5 1927.5 -7692.5 1912.5 -7697.5 1917.5 -7682.5 1922.5 -7687.5 1930 -7680 {fill=1}
P 10 7 2550 -7680 2542.5 -7687.5 2547.5 -7692.5 2532.5 -7697.5 2537.5 -7682.5 2542.5 -7687.5 2550 -7680 {fill=1}
P 10 7 2210 -7680 2202.5 -7687.5 2207.5 -7692.5 2192.5 -7697.5 2197.5 -7682.5 2202.5 -7687.5 2210 -7680 {fill=1}
T {INTUITIVE_INTERFACE CHEAT SHEET} 1110 -9870 0 0 2 2 {hcenter=1}
T {D} 1275 -8847.5 0 0 0.15 0.15 { layer=2}
T {D} 2055 -8857.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -8847.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -8387.5 0 0 0.15 0.15 {}
T {D} 1285 -8387.5 0 0 0.15 0.15 {}
T {D} 745 -6767.5 0 0 0.15 0.15 {}
T {D} 1285 -6767.5 0 0 0.15 0.15 {}
T {D} 745 -6277.5 0 0 0.15 0.15 {}
T {D} 1285 -6277.5 0 0 0.15 0.15 {}
T {D} 745 -5787.5 0 0 0.15 0.15 { layer=2}
T {D} 2125 -5787.5 0 0 0.15 0.15 { layer=2}
T {D} 1285 -5787.5 0 0 0.15 0.15 { layer=2}
T {(Enable Options-> Intuitive Click & Drag interface
or add: `set intuitive_interface 1` in xschemrc file).} 1090 -9730 0 0 1 1 {hcenter=1 layer=1}
T {Move objects} 0 -8920 0 0 1 1 {}
T {Move objects} 0 -8510 0 0 1 1 {}
T {Move objects,
create wires} 0 -6890 0 0 1 1 {}
T {Move objects,
keep attached
wires
} 0 -6400 0 0 1 1 {}
T {Move objects,
keep attached
wires
} 0 -5910 0 0 1 1 {}
T {Shift} 1530 -6855 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1530 -6365 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1520 -5645 0 0 0.5 0.5 {hcenter=1}
T {Duplicate objects} 0 -8070 0 0 1 1 {}
T {D} 1275 -8017.5 0 0 0.15 0.15 { layer=2}
T {D} 2055 -8027.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -8017.5 0 0 0.15 0.15 { layer=2}
T {D} 1775 -8017.5 0 0 0.15 0.15 {}
T {Shift} 1270 -7835 0 0 0.5 0.5 {hcenter=1}
T {D} 1815 -9317.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -9317.5 0 0 0.15 0.15 { layer=2}
T {Select
and unselect
objects} 0 -9370 0 0 1 1 {}
T {Shift} 1710 -9115 0 0 0.5 0.5 {hcenter=1}
T {D} 2275 -9317.5 0 0 0.15 0.15 { layer=2}
T {Alt} 2490 -9105 0 0 0.5 0.5 {hcenter=1}
T {Select} 750 -9120 0 0 0.5 0.5 {}
T {Add
Selection} 1770 -9130 0 0 0.5 0.5 {}
T {Remove
Selection} 2220 -9130 0 0 0.5 0.5 {}
T {D} 765 -5347.5 0 0 0.15 0.15 {}
T {D} 1305 -5347.5 0 0 0.15 0.15 {}
T {D} 1865 -5347.5 0 0 0.15 0.15 {}
T {D} 2435 -5347.5 0 0 0.15 0.15 {}
T {D} 765 -7177.5 0 0 0.15 0.15 {}
T {D} 1305 -7177.5 0 0 0.15 0.15 {}
T {D} 2435 -7177.5 0 0 0.15 0.15 {}
T {D} 765 -4967.5 0 0 0.15 0.15 {}
T {D} 1305 -4587.5 0 0 0.15 0.15 {}
T {D} 2405 -4587.5 0 0 0.15 0.15 {}
T {D} 1845 -4587.5 0 0 0.15 0.15 {}
T {Create and move
wires} 0 -5470 0 0 1 1 {}
T {Resize wires} 0 -7300 0 0 1 1 {}
T {Create wires} 0 -5090 0 0 1 1 {}
T {Stretch circuit} 0 -4710 0 0 1 1 {}
T {Move components, 
create wires,
resize wires} 0 -3920 0 0 1 1 {}
T {Move components,
create new wires} 0 -4300 0 0 1 1 {}
T {Cut wires} 0 -3570 0 0 1 1 {}
T {Stretch multiple
shapes} 0 -3150 0 0 1 1 {}
T {Ctrl} 1710 -4655 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1430 -4305 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1430 -4225 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1700 -4305 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1700 -4225 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1430 -3925 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1430 -3845 0 0 0.5 0.5 {hcenter=1}
T {Accurately position closer
to the wire end to be moved
so it will not be unselected} 1610 -7410 0 0 0.5 0.5 {}
T {Move multiple
objects keeping
connections} 0 -1130 0 0 1 1 {}
T {Ctrl} 2080 -1105 0 0 0.5 0.5 {hcenter=1}
T {Alt} 1430 -3475 0 0 0.5 0.5 {hcenter=1}
T {Click to select wire, release button
click wire endpoint and drag it away} 660 -7390 0 0 0.5 0.5 {}
T {Ctrl} 1580 -3065 0 0 0.5 0.5 {hcenter=1}
T {D} 655 -2727.5 0 0 0.15 0.15 { layer=2}
T {D} 1235 -2727.5 0 0 0.15 0.15 { layer=2}
T {D} 1885 -2727.5 0 0 0.15 0.15 {}
T {Ctrl} 1960 -2765 0 0 0.5 0.5 {hcenter=1}
T {!} 1960 -2685 0 0 0.5 0.5 {hcenter=1}
T {Break wires
under component
} 0 -2800 0 0 1 1 {}
T {If Shift key is needed for ! 
use also Shift} 2020 -2740 0 0 0.5 0.5 {}
T {D} 1275 -9317.5 0 0 0.15 0.15 { layer=2}
T {Add
Selection} 1090 -9140 0 0 0.5 0.5 {}
T {Shift} 1080 -9395 0 0 0.5 0.5 {hcenter=1}
T {Move multiple
objects keeping
connections,
adding wires} 0 -750 0 0 1 1 {}
T {Ctrl} 2080 -725 0 0 0.5 0.5 {hcenter=1}
T {Shift} 2080 -655 0 0 0.5 0.5 {hcenter=1}
T {Join / Trim wires} 0 -2460 0 0 1 1 {}
T {&} 1920 -2465 0 0 0.5 0.5 {hcenter=1}
T {This wire will not be broken} 1120 -2050 0 0 0.5 0.5 {}
T {&} 1830 -2035 0 0 0.5 0.5 {hcenter=1}
T {This wire is now 
broken} 1890 -2050 0 0 0.5 0.5 {}
T {break wires
at instance
pins} 0 -1530 0 0 1 1 {}
T {!} 1290 -1385 0 0 0.5 0.5 {hcenter=1}
T {Shift} 790 -1315 0 0 0.5 0.5 {hcenter=1}
T {+} 720 -1390 0 0 0.5 0.5 {}
T {The single wire line will be
broken at selected instance pins} 1640 -1560 0 0 0.5 0.5 {}
T {Single wire line} 640 -1550 0 0 0.5 0.5 {}
T {D} 825 -217.5 0 0 0.15 0.15 {}
T {D} 1475 -217.5 0 0 0.15 0.15 {}
T {Shift} 1650 -155 0 0 0.5 0.5 {hcenter=1}
T {Select instance
and all connected
wires} 0 -350 0 0 1 1 {}
T {Join / Trim wires} 0 -2180 0 0 1 1 {}
T {Options->Auto join / trim wires to perform this function automatically} 840 -2280 0 0 0.5 0.5 {}
T {Join / Trim wires} 0 -1790 0 0 1 1 {}
T {This wire is broken} 630 -1650 0 0 0.5 0.5 {}
T {This wire is still broken} 1170 -1650 0 0 0.5 0.5 {}
T {This wire is now joined} 1800 -1650 0 0 0.5 0.5 {}
T {&} 1920 -1895 0 0 0.5 0.5 {hcenter=1}
T {Options->Auto join / trim wires to perform this function automatically} 840 -1910 0 0 0.5 0.5 {}
T {Options->Auto join / trim wires to perform this function automatically} 840 -2520 0 0 0.5 0.5 {}
T {multiple overlayed wires create
unneeded connecting dots} 1110 -2440 0 0 0.5 0.5 {}
T {overlayed wires are removed} 2270 -2420 0 0 0.5 0.5 {}
T {D} 1305 -4967.5 0 0 0.15 0.15 {}
T {D} 1865 -4967.5 0 0 0.15 0.15 {}
T {D} 2435 -4967.5 0 0 0.15 0.15 {}
T {Ctrl} 2370 -5645 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1980 -3925 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1980 -3845 0 0 0.5 0.5 {hcenter=1}
T {you can now 
select one of
the cut segments...} 1930 -3440 0 0 0.4 0.4 {}
T {... and move it.} 2420 -3360 0 0 0.4 0.4 {}
T {D} 2035 -217.5 0 0 0.15 0.15 {}
T {D} 765 -4587.5 0 0 0.15 0.15 {}
T {Ctrl} 2270 -4685 0 0 0.5 0.5 {hcenter=1}
T {Add / resize
wires} 0 -7620 0 0 1 1 {}
T {Click to
unselect} 860 -7580 0 0 0.5 0.5 {}
T {'Insert' key to
add a component} 1590 -7490 0 0 0.5 0.5 {}
T {Click to select} 1820 -7740 0 0 0.5 0.5 {}
T {Extend wire} 2390 -7750 0 0 0.5 0.5 {}
T {Click to
unselect} 2190 -4260 0 0 0.5 0.5 {}
T {Click one of the
selected objects
and drag it away.} 2330 -250 0 0 0.4 0.4 {}
