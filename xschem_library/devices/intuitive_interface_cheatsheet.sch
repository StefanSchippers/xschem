v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 1 917.5 -8072.5 922.5 -8072.5 {}
L 1 917.5 -8070 922.5 -8070 {}
L 1 917.5 -8067.5 922.5 -8067.5 {}
L 1 917.5 -8065 922.5 -8065 {}
L 1 917.5 -8062.5 922.5 -8062.5 {}
L 1 917.5 -8060 922.5 -8060 {}
L 1 917.5 -8057.5 922.5 -8057.5 {}
L 1 917.5 -8055 922.5 -8055 {}
L 1 917.5 -8052.5 922.5 -8052.5 {}
L 1 1347.5 -8072.5 1352.5 -8072.5 {}
L 1 1347.5 -8070 1352.5 -8070 {}
L 1 1347.5 -8067.5 1352.5 -8067.5 {}
L 1 1347.5 -8065 1352.5 -8065 {}
L 1 1347.5 -8062.5 1352.5 -8062.5 {}
L 1 1347.5 -8060 1352.5 -8060 {}
L 1 1347.5 -8057.5 1352.5 -8057.5 {}
L 1 1347.5 -8055 1352.5 -8055 {}
L 1 1347.5 -8052.5 1352.5 -8052.5 {}
L 1 2117.5 -8072.5 2122.5 -8072.5 {}
L 1 2117.5 -8070 2122.5 -8070 {}
L 1 2117.5 -8067.5 2122.5 -8067.5 {}
L 1 2117.5 -8065 2122.5 -8065 {}
L 1 2117.5 -8062.5 2122.5 -8062.5 {}
L 1 2117.5 -8060 2122.5 -8060 {}
L 1 2117.5 -8057.5 2122.5 -8057.5 {}
L 1 2117.5 -8055 2122.5 -8055 {}
L 1 2117.5 -8052.5 2122.5 -8052.5 {}
L 1 1417.5 -7882.5 1422.5 -7882.5 {}
L 1 1417.5 -7880 1422.5 -7880 {}
L 1 1417.5 -7877.5 1422.5 -7877.5 {}
L 1 1417.5 -7875 1422.5 -7875 {}
L 1 1417.5 -7872.5 1422.5 -7872.5 {}
L 1 1417.5 -7870 1422.5 -7870 {}
L 1 1417.5 -7867.5 1422.5 -7867.5 {}
L 1 1417.5 -7865 1422.5 -7865 {}
L 1 1417.5 -7862.5 1422.5 -7862.5 {}
L 1 1437.5 -7062.5 1442.5 -7062.5 {}
L 1 1437.5 -7060 1442.5 -7060 {}
L 1 1437.5 -7057.5 1442.5 -7057.5 {}
L 1 1437.5 -7055 1442.5 -7055 {}
L 1 1437.5 -7052.5 1442.5 -7052.5 {}
L 1 1437.5 -7050 1442.5 -7050 {}
L 1 1437.5 -7047.5 1442.5 -7047.5 {}
L 1 1437.5 -7045 1442.5 -7045 {}
L 1 1437.5 -7042.5 1442.5 -7042.5 {}
L 1 1437.5 -6572.5 1442.5 -6572.5 {}
L 1 1437.5 -6570 1442.5 -6570 {}
L 1 1437.5 -6567.5 1442.5 -6567.5 {}
L 1 1437.5 -6565 1442.5 -6565 {}
L 1 1437.5 -6562.5 1442.5 -6562.5 {}
L 1 1437.5 -6560 1442.5 -6560 {}
L 1 1437.5 -6557.5 1442.5 -6557.5 {}
L 1 1437.5 -6555 1442.5 -6555 {}
L 1 1437.5 -6552.5 1442.5 -6552.5 {}
L 1 947.5 -5842.5 952.5 -5842.5 {}
L 1 947.5 -5840 952.5 -5840 {}
L 1 947.5 -5837.5 952.5 -5837.5 {}
L 1 947.5 -5835 952.5 -5835 {}
L 1 947.5 -5832.5 952.5 -5832.5 {}
L 1 947.5 -5830 952.5 -5830 {}
L 1 947.5 -5827.5 952.5 -5827.5 {}
L 1 947.5 -5825 952.5 -5825 {}
L 1 947.5 -5822.5 952.5 -5822.5 {}
L 1 1040 -6100 1280 -6100 {}
L 1 1040 -5840 1280 -5840 {}
L 1 1427.5 -5852.5 1432.5 -5852.5 {}
L 1 1427.5 -5850 1432.5 -5850 {}
L 1 1427.5 -5847.5 1432.5 -5847.5 {}
L 1 1427.5 -5845 1432.5 -5845 {}
L 1 1427.5 -5842.5 1432.5 -5842.5 {}
L 1 1427.5 -5840 1432.5 -5840 {}
L 1 1427.5 -5837.5 1432.5 -5837.5 {}
L 1 1427.5 -5835 1432.5 -5835 {}
L 1 1427.5 -5832.5 1432.5 -5832.5 {}
L 1 917.5 -7242.5 922.5 -7242.5 {}
L 1 917.5 -7240 922.5 -7240 {}
L 1 917.5 -7237.5 922.5 -7237.5 {}
L 1 917.5 -7235 922.5 -7235 {}
L 1 917.5 -7232.5 922.5 -7232.5 {}
L 1 917.5 -7230 922.5 -7230 {}
L 1 917.5 -7227.5 922.5 -7227.5 {}
L 1 917.5 -7225 922.5 -7225 {}
L 1 917.5 -7222.5 922.5 -7222.5 {}
L 1 1347.5 -7242.5 1352.5 -7242.5 {}
L 1 1347.5 -7240 1352.5 -7240 {}
L 1 1347.5 -7237.5 1352.5 -7237.5 {}
L 1 1347.5 -7235 1352.5 -7235 {}
L 1 1347.5 -7232.5 1352.5 -7232.5 {}
L 1 1347.5 -7230 1352.5 -7230 {}
L 1 1347.5 -7227.5 1352.5 -7227.5 {}
L 1 1347.5 -7225 1352.5 -7225 {}
L 1 1347.5 -7222.5 1352.5 -7222.5 {}
L 1 2117.5 -7242.5 2122.5 -7242.5 {}
L 1 2117.5 -7240 2122.5 -7240 {}
L 1 2117.5 -7237.5 2122.5 -7237.5 {}
L 1 2117.5 -7235 2122.5 -7235 {}
L 1 2117.5 -7232.5 2122.5 -7232.5 {}
L 1 2117.5 -7230 2122.5 -7230 {}
L 1 2117.5 -7227.5 2122.5 -7227.5 {}
L 1 2117.5 -7225 2122.5 -7225 {}
L 1 2117.5 -7222.5 2122.5 -7222.5 {}
L 1 917.5 -8542.5 922.5 -8542.5 {}
L 1 917.5 -8540 922.5 -8540 {}
L 1 917.5 -8537.5 922.5 -8537.5 {}
L 1 917.5 -8535 922.5 -8535 {}
L 1 917.5 -8532.5 922.5 -8532.5 {}
L 1 917.5 -8530 922.5 -8530 {}
L 1 917.5 -8527.5 922.5 -8527.5 {}
L 1 917.5 -8525 922.5 -8525 {}
L 1 917.5 -8522.5 922.5 -8522.5 {}
L 1 1627.5 -8532.5 1632.5 -8532.5 {}
L 1 1627.5 -8530 1632.5 -8530 {}
L 1 1627.5 -8527.5 1632.5 -8527.5 {}
L 1 1627.5 -8525 1632.5 -8525 {}
L 1 1627.5 -8522.5 1632.5 -8522.5 {}
L 1 1627.5 -8520 1632.5 -8520 {}
L 1 1627.5 -8517.5 1632.5 -8517.5 {}
L 1 1627.5 -8515 1632.5 -8515 {}
L 1 1627.5 -8512.5 1632.5 -8512.5 {}
L 1 2407.5 -8522.5 2412.5 -8522.5 {}
L 1 2407.5 -8520 2412.5 -8520 {}
L 1 2407.5 -8517.5 2412.5 -8517.5 {}
L 1 2407.5 -8515 2412.5 -8515 {}
L 1 2407.5 -8512.5 2412.5 -8512.5 {}
L 1 2407.5 -8510 2412.5 -8510 {}
L 1 2407.5 -8507.5 2412.5 -8507.5 {}
L 1 2407.5 -8505 2412.5 -8505 {}
L 1 2407.5 -8502.5 2412.5 -8502.5 {}
L 1 520 -5280 760 -5280 {}
L 1 820 -3350 820 -3020 {}
L 1 1360 -3350 1360 -3020 {}
L 1 1900 -3180 1900 -3020 {}
L 1 820 -2830 820 -2730 {}
L 1 710 -2830 710 -2730 {}
L 1 930 -2830 930 -2730 {}
L 1 820 -3710 820 -3560 {}
L 1 1360 -3710 1360 -3560 {}
L 1 1900 -3710 1900 -3600 {}
L 1 1487.5 -5652.5 1492.5 -5652.5 {}
L 1 1487.5 -5650 1492.5 -5650 {}
L 1 1487.5 -5647.5 1492.5 -5647.5 {}
L 1 1487.5 -5645 1492.5 -5645 {}
L 1 1487.5 -5642.5 1492.5 -5642.5 {}
L 1 1487.5 -5640 1492.5 -5640 {}
L 1 1487.5 -5637.5 1492.5 -5637.5 {}
L 1 1487.5 -5635 1492.5 -5635 {}
L 1 1487.5 -5632.5 1492.5 -5632.5 {}
L 1 1937.5 -5722.5 1942.5 -5722.5 {}
L 1 1937.5 -5720 1942.5 -5720 {}
L 1 1937.5 -5717.5 1942.5 -5717.5 {}
L 1 1937.5 -5715 1942.5 -5715 {}
L 1 1937.5 -5712.5 1942.5 -5712.5 {}
L 1 1937.5 -5710 1942.5 -5710 {}
L 1 1937.5 -5707.5 1942.5 -5707.5 {}
L 1 1937.5 -5705 1942.5 -5705 {}
L 1 1937.5 -5702.5 1942.5 -5702.5 {}
L 1 2557.5 -5632.5 2562.5 -5632.5 {}
L 1 2557.5 -5630 2562.5 -5630 {}
L 1 2557.5 -5627.5 2562.5 -5627.5 {}
L 1 2557.5 -5625 2562.5 -5625 {}
L 1 2557.5 -5622.5 2562.5 -5622.5 {}
L 1 2557.5 -5620 2562.5 -5620 {}
L 1 2557.5 -5617.5 2562.5 -5617.5 {}
L 1 2557.5 -5615 2562.5 -5615 {}
L 1 2557.5 -5612.5 2562.5 -5612.5 {}
L 1 687.5 -4822.5 692.5 -4822.5 {}
L 1 687.5 -4820 692.5 -4820 {}
L 1 687.5 -4817.5 692.5 -4817.5 {}
L 1 687.5 -4815 692.5 -4815 {}
L 1 687.5 -4812.5 692.5 -4812.5 {}
L 1 687.5 -4810 692.5 -4810 {}
L 1 687.5 -4807.5 692.5 -4807.5 {}
L 1 687.5 -4805 692.5 -4805 {}
L 1 687.5 -4802.5 692.5 -4802.5 {}
L 1 1347.5 -4842.5 1352.5 -4842.5 {}
L 1 1347.5 -4840 1352.5 -4840 {}
L 1 1347.5 -4837.5 1352.5 -4837.5 {}
L 1 1347.5 -4835 1352.5 -4835 {}
L 1 1347.5 -4832.5 1352.5 -4832.5 {}
L 1 1347.5 -4830 1352.5 -4830 {}
L 1 1347.5 -4827.5 1352.5 -4827.5 {}
L 1 1347.5 -4825 1352.5 -4825 {}
L 1 1347.5 -4822.5 1352.5 -4822.5 {}
L 1 2537.5 -4892.5 2542.5 -4892.5 {}
L 1 2537.5 -4890 2542.5 -4890 {}
L 1 2537.5 -4887.5 2542.5 -4887.5 {}
L 1 2537.5 -4885 2542.5 -4885 {}
L 1 2537.5 -4882.5 2542.5 -4882.5 {}
L 1 2537.5 -4880 2542.5 -4880 {}
L 1 2537.5 -4877.5 2542.5 -4877.5 {}
L 1 2537.5 -4875 2542.5 -4875 {}
L 1 2537.5 -4872.5 2542.5 -4872.5 {}
L 1 847.5 -4462.5 852.5 -4462.5 {}
L 1 847.5 -4460 852.5 -4460 {}
L 1 847.5 -4457.5 852.5 -4457.5 {}
L 1 847.5 -4455 852.5 -4455 {}
L 1 847.5 -4452.5 852.5 -4452.5 {}
L 1 847.5 -4450 852.5 -4450 {}
L 1 847.5 -4447.5 852.5 -4447.5 {}
L 1 847.5 -4445 852.5 -4445 {}
L 1 847.5 -4442.5 852.5 -4442.5 {}
L 1 1247.5 -4412.5 1252.5 -4412.5 {}
L 1 1247.5 -4410 1252.5 -4410 {}
L 1 1247.5 -4407.5 1252.5 -4407.5 {}
L 1 1247.5 -4405 1252.5 -4405 {}
L 1 1247.5 -4402.5 1252.5 -4402.5 {}
L 1 1247.5 -4400 1252.5 -4400 {}
L 1 1247.5 -4397.5 1252.5 -4397.5 {}
L 1 1247.5 -4395 1252.5 -4395 {}
L 1 1247.5 -4392.5 1252.5 -4392.5 {}
L 1 1807.5 -4442.5 1812.5 -4442.5 {}
L 1 1807.5 -4440 1812.5 -4440 {}
L 1 1807.5 -4437.5 1812.5 -4437.5 {}
L 1 1807.5 -4435 1812.5 -4435 {}
L 1 1807.5 -4432.5 1812.5 -4432.5 {}
L 1 1807.5 -4430 1812.5 -4430 {}
L 1 1807.5 -4427.5 1812.5 -4427.5 {}
L 1 1807.5 -4425 1812.5 -4425 {}
L 1 1807.5 -4422.5 1812.5 -4422.5 {}
L 1 1427.5 -3892.5 1432.5 -3892.5 {}
L 1 1427.5 -3890 1432.5 -3890 {}
L 1 1427.5 -3887.5 1432.5 -3887.5 {}
L 1 1427.5 -3885 1432.5 -3885 {}
L 1 1427.5 -3882.5 1432.5 -3882.5 {}
L 1 1427.5 -3880 1432.5 -3880 {}
L 1 1427.5 -3877.5 1432.5 -3877.5 {}
L 1 1427.5 -3875 1432.5 -3875 {}
L 1 1427.5 -3872.5 1432.5 -3872.5 {}
L 1 1697.5 -3892.5 1702.5 -3892.5 {}
L 1 1697.5 -3890 1702.5 -3890 {}
L 1 1697.5 -3887.5 1702.5 -3887.5 {}
L 1 1697.5 -3885 1702.5 -3885 {}
L 1 1697.5 -3882.5 1702.5 -3882.5 {}
L 1 1697.5 -3880 1702.5 -3880 {}
L 1 1697.5 -3877.5 1702.5 -3877.5 {}
L 1 1697.5 -3875 1702.5 -3875 {}
L 1 1697.5 -3872.5 1702.5 -3872.5 {}
L 1 2297.5 -3892.5 2302.5 -3892.5 {}
L 1 2297.5 -3890 2302.5 -3890 {}
L 1 2297.5 -3887.5 2302.5 -3887.5 {}
L 1 2297.5 -3885 2302.5 -3885 {}
L 1 2297.5 -3882.5 2302.5 -3882.5 {}
L 1 2297.5 -3880 2302.5 -3880 {}
L 1 2297.5 -3877.5 2302.5 -3877.5 {}
L 1 2297.5 -3875 2302.5 -3875 {}
L 1 2297.5 -3872.5 2302.5 -3872.5 {}
L 1 1427.5 -3512.5 1432.5 -3512.5 {}
L 1 1427.5 -3510 1432.5 -3510 {}
L 1 1427.5 -3507.5 1432.5 -3507.5 {}
L 1 1427.5 -3505 1432.5 -3505 {}
L 1 1427.5 -3502.5 1432.5 -3502.5 {}
L 1 1427.5 -3500 1432.5 -3500 {}
L 1 1427.5 -3497.5 1432.5 -3497.5 {}
L 1 1427.5 -3495 1432.5 -3495 {}
L 1 1427.5 -3492.5 1432.5 -3492.5 {}
L 1 820 -900 820 -800 {}
L 1 710 -900 710 -800 {}
L 1 930 -900 930 -800 {}
L 1 820 -740 820 -710 {}
L 1 710 -740 710 -710 {}
L 1 930 -740 930 -710 {}
L 1 2077.5 -782.5 2082.5 -782.5 {}
L 1 2077.5 -780 2082.5 -780 {}
L 1 2077.5 -777.5 2082.5 -777.5 {}
L 1 2077.5 -775 2082.5 -775 {}
L 1 2077.5 -772.5 2082.5 -772.5 {}
L 1 2077.5 -770 2082.5 -770 {}
L 1 2077.5 -767.5 2082.5 -767.5 {}
L 1 2077.5 -765 2082.5 -765 {}
L 1 2077.5 -762.5 2082.5 -762.5 {}
L 1 1567.5 -752.5 1572.5 -752.5 {}
L 1 1567.5 -750 1572.5 -750 {}
L 1 1567.5 -747.5 1572.5 -747.5 {}
L 1 1567.5 -745 1572.5 -745 {}
L 1 1567.5 -742.5 1572.5 -742.5 {}
L 1 1567.5 -740 1572.5 -740 {}
L 1 1567.5 -737.5 1572.5 -737.5 {}
L 1 1567.5 -735 1572.5 -735 {}
L 1 1567.5 -732.5 1572.5 -732.5 {}
L 1 1427.5 -3152.5 1432.5 -3152.5 {}
L 1 1427.5 -3150 1432.5 -3150 {}
L 1 1427.5 -3147.5 1432.5 -3147.5 {}
L 1 1427.5 -3145 1432.5 -3145 {}
L 1 1427.5 -3142.5 1432.5 -3142.5 {}
L 1 1427.5 -3140 1432.5 -3140 {}
L 1 1427.5 -3137.5 1432.5 -3137.5 {}
L 1 1427.5 -3135 1432.5 -3135 {}
L 1 1427.5 -3132.5 1432.5 -3132.5 {}
L 1 1957.5 -3262.5 1962.5 -3262.5 {}
L 1 1957.5 -3260 1962.5 -3260 {}
L 1 1957.5 -3257.5 1962.5 -3257.5 {}
L 1 1957.5 -3255 1962.5 -3255 {}
L 1 1957.5 -3252.5 1962.5 -3252.5 {}
L 1 1957.5 -3250 1962.5 -3250 {}
L 1 1957.5 -3247.5 1962.5 -3247.5 {}
L 1 1957.5 -3245 1962.5 -3245 {}
L 1 1957.5 -3242.5 1962.5 -3242.5 {}
L 1 1577.5 -2742.5 1582.5 -2742.5 {}
L 1 1577.5 -2740 1582.5 -2740 {}
L 1 1577.5 -2737.5 1582.5 -2737.5 {}
L 1 1577.5 -2735 1582.5 -2735 {}
L 1 1577.5 -2732.5 1582.5 -2732.5 {}
L 1 1577.5 -2730 1582.5 -2730 {}
L 1 1577.5 -2727.5 1582.5 -2727.5 {}
L 1 1577.5 -2725 1582.5 -2725 {}
L 1 1577.5 -2722.5 1582.5 -2722.5 {}
L 1 2067.5 -2802.5 2072.5 -2802.5 {}
L 1 2067.5 -2800 2072.5 -2800 {}
L 1 2067.5 -2797.5 2072.5 -2797.5 {}
L 1 2067.5 -2795 2072.5 -2795 {}
L 1 2067.5 -2792.5 2072.5 -2792.5 {}
L 1 2067.5 -2790 2072.5 -2790 {}
L 1 2067.5 -2787.5 2072.5 -2787.5 {}
L 1 2067.5 -2785 2072.5 -2785 {}
L 1 2067.5 -2782.5 2072.5 -2782.5 {}
L 1 2597.5 -2932.5 2602.5 -2932.5 {}
L 1 2597.5 -2930 2602.5 -2930 {}
L 1 2597.5 -2927.5 2602.5 -2927.5 {}
L 1 2597.5 -2925 2602.5 -2925 {}
L 1 2597.5 -2922.5 2602.5 -2922.5 {}
L 1 2597.5 -2920 2602.5 -2920 {}
L 1 2597.5 -2917.5 2602.5 -2917.5 {}
L 1 2597.5 -2915 2602.5 -2915 {}
L 1 2597.5 -2912.5 2602.5 -2912.5 {}
L 1 987.5 -8812.5 992.5 -8812.5 {}
L 1 987.5 -8810 992.5 -8810 {}
L 1 987.5 -8807.5 992.5 -8807.5 {}
L 1 987.5 -8805 992.5 -8805 {}
L 1 987.5 -8802.5 992.5 -8802.5 {}
L 1 987.5 -8800 992.5 -8800 {}
L 1 987.5 -8797.5 992.5 -8797.5 {}
L 1 987.5 -8795 992.5 -8795 {}
L 1 987.5 -8792.5 992.5 -8792.5 {}
L 1 820 -520 820 -420 {}
L 1 710 -520 710 -420 {}
L 1 930 -520 930 -420 {}
L 1 1567.5 -372.5 1572.5 -372.5 {}
L 1 1567.5 -370 1572.5 -370 {}
L 1 1567.5 -367.5 1572.5 -367.5 {}
L 1 1567.5 -365 1572.5 -365 {}
L 1 1567.5 -362.5 1572.5 -362.5 {}
L 1 1567.5 -360 1572.5 -360 {}
L 1 1567.5 -357.5 1572.5 -357.5 {}
L 1 1567.5 -355 1572.5 -355 {}
L 1 1567.5 -352.5 1572.5 -352.5 {}
L 1 2077.5 -322.5 2082.5 -322.5 {}
L 1 2077.5 -320 2082.5 -320 {}
L 1 2077.5 -317.5 2082.5 -317.5 {}
L 1 2077.5 -315 2082.5 -315 {}
L 1 2077.5 -312.5 2082.5 -312.5 {}
L 1 2077.5 -310 2082.5 -310 {}
L 1 2077.5 -307.5 2082.5 -307.5 {}
L 1 2077.5 -305 2082.5 -305 {}
L 1 2077.5 -302.5 2082.5 -302.5 {}
L 1 620 -2100 870 -2100 {}
L 1 1340 -2100 1410 -2100 {}
L 1 1160 -2100 1220 -2100 {}
L 1 1790 -2100 2040 -2100 {}
L 1 2340 -2100 2590 -2100 {}
L 1 620 -1820 870 -1820 {}
L 1 1160 -1820 1410 -1820 {}
L 1 1790 -1820 2040 -1820 {}
L 1 1910 -1940 1910 -1820 {}
L 1 2460 -1820 2590 -1820 {}
L 1 2460 -1940 2460 -1820 {}
L 1 2360 -3180 2360 -3020 {}
L 1 2497.5 -3182.5 2502.5 -3182.5 {}
L 1 2497.5 -3180 2502.5 -3180 {}
L 1 2497.5 -3177.5 2502.5 -3177.5 {}
L 1 2497.5 -3175 2502.5 -3175 {}
L 1 2497.5 -3172.5 2502.5 -3172.5 {}
L 1 2497.5 -3170 2502.5 -3170 {}
L 1 2497.5 -3167.5 2502.5 -3167.5 {}
L 1 2497.5 -3165 2502.5 -3165 {}
L 1 2497.5 -3162.5 2502.5 -3162.5 {}
L 1 1160 -1240 1410 -1240 {}
L 1 1880 -1110 1950 -1110 {}
L 1 1700 -1110 1760 -1110 {}
L 1 1817.5 -1222.5 1822.5 -1222.5 {}
L 1 1817.5 -1220 1822.5 -1220 {}
L 1 1817.5 -1217.5 1822.5 -1217.5 {}
L 1 1817.5 -1215 1822.5 -1215 {}
L 1 1817.5 -1212.5 1822.5 -1212.5 {}
L 1 1817.5 -1210 1822.5 -1210 {}
L 1 1817.5 -1207.5 1822.5 -1207.5 {}
L 1 1817.5 -1205 1822.5 -1205 {}
L 1 1817.5 -1202.5 1822.5 -1202.5 {}
L 1 620 -1240 870 -1240 {}
L 1 667.5 -1152.5 672.5 -1152.5 {}
L 1 667.5 -1150 672.5 -1150 {}
L 1 667.5 -1147.5 672.5 -1147.5 {}
L 1 667.5 -1145 672.5 -1145 {}
L 1 667.5 -1142.5 672.5 -1142.5 {}
L 1 667.5 -1140 672.5 -1140 {}
L 1 667.5 -1137.5 672.5 -1137.5 {}
L 1 667.5 -1135 672.5 -1135 {}
L 1 667.5 -1132.5 672.5 -1132.5 {}
L 1 787.5 -1152.5 792.5 -1152.5 {}
L 1 787.5 -1150 792.5 -1150 {}
L 1 787.5 -1147.5 792.5 -1147.5 {}
L 1 787.5 -1145 792.5 -1145 {}
L 1 787.5 -1142.5 792.5 -1142.5 {}
L 1 787.5 -1140 792.5 -1140 {}
L 1 787.5 -1137.5 792.5 -1137.5 {}
L 1 787.5 -1135 792.5 -1135 {}
L 1 787.5 -1132.5 792.5 -1132.5 {}
L 1 1647.5 177.5 1652.5 177.5 {}
L 1 1647.5 180 1652.5 180 {}
L 1 1647.5 182.5 1652.5 182.5 {}
L 1 1647.5 185 1652.5 185 {}
L 1 1647.5 187.5 1652.5 187.5 {}
L 1 1647.5 190 1652.5 190 {}
L 1 1647.5 192.5 1652.5 192.5 {}
L 1 1647.5 195 1652.5 195 {}
L 1 1647.5 197.5 1652.5 197.5 {}
L 1 620 -1420 870 -1420 {}
L 1 1160 -1420 1410 -1420 {}
L 1 1790 -1420 2040 -1420 {}
L 1 1830 -1590 1830 -1470 {}
L 1 457.5 -5092.5 462.5 -5092.5 {}
L 1 457.5 -5090 462.5 -5090 {}
L 1 457.5 -5087.5 462.5 -5087.5 {}
L 1 457.5 -5085 462.5 -5085 {}
L 1 457.5 -5082.5 462.5 -5082.5 {}
L 1 457.5 -5080 462.5 -5080 {}
L 1 457.5 -5077.5 462.5 -5077.5 {}
L 1 457.5 -5075 462.5 -5075 {}
L 1 457.5 -5072.5 462.5 -5072.5 {}
L 1 1060 -5280 1300 -5280 {}
L 1 997.5 -5272.5 1002.5 -5272.5 {}
L 1 997.5 -5270 1002.5 -5270 {}
L 1 997.5 -5267.5 1002.5 -5267.5 {}
L 1 997.5 -5265 1002.5 -5265 {}
L 1 997.5 -5262.5 1002.5 -5262.5 {}
L 1 997.5 -5260 1002.5 -5260 {}
L 1 997.5 -5257.5 1002.5 -5257.5 {}
L 1 997.5 -5255 1002.5 -5255 {}
L 1 997.5 -5252.5 1002.5 -5252.5 {}
L 1 1620 -5280 1860 -5280 {}
L 1 2007.5 -5062.5 2012.5 -5062.5 {}
L 1 2007.5 -5060 2012.5 -5060 {}
L 1 2007.5 -5057.5 2012.5 -5057.5 {}
L 1 2007.5 -5055 2012.5 -5055 {}
L 1 2007.5 -5052.5 2012.5 -5052.5 {}
L 1 2007.5 -5050 2012.5 -5050 {}
L 1 2007.5 -5047.5 2012.5 -5047.5 {}
L 1 2007.5 -5045 2012.5 -5045 {}
L 1 2007.5 -5042.5 2012.5 -5042.5 {}
L 1 1620 -5280 1620 -5100 {}
L 1 2190 -5280 2430 -5280 {}
L 1 2577.5 -5062.5 2582.5 -5062.5 {}
L 1 2577.5 -5060 2582.5 -5060 {}
L 1 2577.5 -5057.5 2582.5 -5057.5 {}
L 1 2577.5 -5055 2582.5 -5055 {}
L 1 2577.5 -5052.5 2582.5 -5052.5 {}
L 1 2577.5 -5050 2582.5 -5050 {}
L 1 2577.5 -5047.5 2582.5 -5047.5 {}
L 1 2577.5 -5045 2582.5 -5045 {}
L 1 2577.5 -5042.5 2582.5 -5042.5 {}
L 1 2190 -5280 2190 -5100 {}
L 1 2277.5 -5852.5 2282.5 -5852.5 {}
L 1 2277.5 -5850 2282.5 -5850 {}
L 1 2277.5 -5847.5 2282.5 -5847.5 {}
L 1 2277.5 -5845 2282.5 -5845 {}
L 1 2277.5 -5842.5 2282.5 -5842.5 {}
L 1 2277.5 -5840 2282.5 -5840 {}
L 1 2277.5 -5837.5 2282.5 -5837.5 {}
L 1 2277.5 -5835 2282.5 -5835 {}
L 1 2277.5 -5832.5 2282.5 -5832.5 {}
L 1 1977.5 -3512.5 1982.5 -3512.5 {}
L 1 1977.5 -3510 1982.5 -3510 {}
L 1 1977.5 -3507.5 1982.5 -3507.5 {}
L 1 1977.5 -3505 1982.5 -3505 {}
L 1 1977.5 -3502.5 1982.5 -3502.5 {}
L 1 1977.5 -3500 1982.5 -3500 {}
L 1 1977.5 -3497.5 1982.5 -3497.5 {}
L 1 1977.5 -3495 1982.5 -3495 {}
L 1 1977.5 -3492.5 1982.5 -3492.5 {}
L 1 2337.5 -1812.5 2342.5 -1812.5 {}
L 1 2337.5 -1810 2342.5 -1810 {}
L 1 2337.5 -1807.5 2342.5 -1807.5 {}
L 1 2337.5 -1805 2342.5 -1805 {}
L 1 2337.5 -1802.5 2342.5 -1802.5 {}
L 1 2337.5 -1800 2342.5 -1800 {}
L 1 2337.5 -1797.5 2342.5 -1797.5 {}
L 1 2337.5 -1795 2342.5 -1795 {}
L 1 2337.5 -1792.5 2342.5 -1792.5 {}
L 1 807.5 -1932.5 812.5 -1932.5 {}
L 1 807.5 -1930 812.5 -1930 {}
L 1 807.5 -1927.5 812.5 -1927.5 {}
L 1 807.5 -1925 812.5 -1925 {}
L 1 807.5 -1922.5 812.5 -1922.5 {}
L 1 807.5 -1920 812.5 -1920 {}
L 1 807.5 -1917.5 812.5 -1917.5 {}
L 1 807.5 -1915 812.5 -1915 {}
L 1 807.5 -1912.5 812.5 -1912.5 {}
L 1 1347.5 -1912.5 1352.5 -1912.5 {}
L 1 1347.5 -1910 1352.5 -1910 {}
L 1 1347.5 -1907.5 1352.5 -1907.5 {}
L 1 1347.5 -1905 1352.5 -1905 {}
L 1 1347.5 -1902.5 1352.5 -1902.5 {}
L 1 1347.5 -1900 1352.5 -1900 {}
L 1 1347.5 -1897.5 1352.5 -1897.5 {}
L 1 1347.5 -1895 1352.5 -1895 {}
L 1 1347.5 -1892.5 1352.5 -1892.5 {}
L 1 2320 -1590 2320 -1470 {}
L 1 1257.5 -1532.5 1262.5 -1532.5 {}
L 1 1257.5 -1530 1262.5 -1530 {}
L 1 1257.5 -1527.5 1262.5 -1527.5 {}
L 1 1257.5 -1525 1262.5 -1525 {}
L 1 1257.5 -1522.5 1262.5 -1522.5 {}
L 1 1257.5 -1520 1262.5 -1520 {}
L 1 1257.5 -1517.5 1262.5 -1517.5 {}
L 1 1257.5 -1515 1262.5 -1515 {}
L 1 1257.5 -1512.5 1262.5 -1512.5 {}
L 1 2517.5 -1482.5 2522.5 -1482.5 {}
L 1 2517.5 -1480 2522.5 -1480 {}
L 1 2517.5 -1477.5 2522.5 -1477.5 {}
L 1 2517.5 -1475 2522.5 -1475 {}
L 1 2517.5 -1472.5 2522.5 -1472.5 {}
L 1 2517.5 -1470 2522.5 -1470 {}
L 1 2517.5 -1467.5 2522.5 -1467.5 {}
L 1 2517.5 -1465 2522.5 -1465 {}
L 1 2517.5 -1462.5 2522.5 -1462.5 {}
L 1 2477.5 -72.5 2482.5 -72.5 {}
L 1 2477.5 -70 2482.5 -70 {}
L 1 2477.5 -67.5 2482.5 -67.5 {}
L 1 2477.5 -65 2482.5 -65 {}
L 1 2477.5 -62.5 2482.5 -62.5 {}
L 1 2477.5 -60 2482.5 -60 {}
L 1 2477.5 -57.5 2482.5 -57.5 {}
L 1 2477.5 -55 2482.5 -55 {}
L 1 2477.5 -52.5 2482.5 -52.5 {}
L 2 1255 -8250 1255 -8190 {}
L 2 1255 -8240 1270 -8240 {}
L 2 1270 -8250 1270 -8240 {}
L 2 1255 -8200 1270 -8200 {}
L 2 1270 -8200 1270 -8190 {}
L 2 1245 -8235 1245 -8205 {}
L 2 1245 -8220 1245 -8215 {}
L 2 1230 -8220 1237.5 -8220 {}
L 2 1230 -8220 1245 -8220 {}
L 2 1260 -8220 1270 -8220 {}
L 2 1255 -8225 1260 -8220 {}
L 2 1255 -8215 1260 -8220 {}
L 2 1270 -8290 1270 -8280 {}
L 2 1270 -8290 1277.5 -8292.5 {}
L 2 1262.5 -8297.5 1277.5 -8292.5 {}
L 2 1262.5 -8297.5 1277.5 -8302.5 {}
L 2 1262.5 -8307.5 1277.5 -8302.5 {}
L 2 1262.5 -8307.5 1277.5 -8312.5 {}
L 2 1262.5 -8317.5 1277.5 -8312.5 {}
L 2 1262.5 -8317.5 1277.5 -8322.5 {}
L 2 1262.5 -8327.5 1277.5 -8322.5 {}
L 2 1262.5 -8327.5 1270 -8330 {}
L 2 1270 -8340 1270 -8330 {}
L 2 1272.5 -8332.5 1277.5 -8332.5 {}
L 2 1275 -8335 1275 -8330 {}
L 2 1360 -8215 1360 -8190 {}
L 2 1360 -8250 1360 -8225 {}
L 2 1350 -8225 1370 -8225 {}
L 2 1350 -8215 1370 -8215 {}
L 2 1362.5 -8242.5 1367.5 -8242.5 {}
L 2 1365 -8245 1365 -8240 {}
L 2 1270 -8280 1270 -8250 {}
L 2 1270 -8370 1270 -8340 {}
L 2 1360 -8190 1360 -8110 {}
L 2 1270 -8220 1270 -8110 {}
L 2 1270 -8110 1360 -8110 {}
L 2 2035 -8260 2035 -8200 {}
L 2 2035 -8250 2050 -8250 {}
L 2 2050 -8260 2050 -8250 {}
L 2 2035 -8210 2050 -8210 {}
L 2 2050 -8210 2050 -8200 {}
L 2 2025 -8245 2025 -8215 {}
L 2 2025 -8230 2025 -8225 {}
L 2 2010 -8230 2017.5 -8230 {}
L 2 2010 -8230 2025 -8230 {}
L 2 2040 -8230 2050 -8230 {}
L 2 2035 -8235 2040 -8230 {}
L 2 2035 -8225 2040 -8230 {}
L 2 2050 -8300 2050 -8290 {}
L 2 2050 -8300 2057.5 -8302.5 {}
L 2 2042.5 -8307.5 2057.5 -8302.5 {}
L 2 2042.5 -8307.5 2057.5 -8312.5 {}
L 2 2042.5 -8317.5 2057.5 -8312.5 {}
L 2 2042.5 -8317.5 2057.5 -8322.5 {}
L 2 2042.5 -8327.5 2057.5 -8322.5 {}
L 2 2042.5 -8327.5 2057.5 -8332.5 {}
L 2 2042.5 -8337.5 2057.5 -8332.5 {}
L 2 2042.5 -8337.5 2050 -8340 {}
L 2 2050 -8350 2050 -8340 {}
L 2 2052.5 -8342.5 2057.5 -8342.5 {}
L 2 2055 -8345 2055 -8340 {}
L 2 2140 -8225 2140 -8200 {}
L 2 2140 -8260 2140 -8235 {}
L 2 2130 -8235 2150 -8235 {}
L 2 2130 -8225 2150 -8225 {}
L 2 2142.5 -8252.5 2147.5 -8252.5 {}
L 2 2145 -8255 2145 -8250 {}
L 2 2050 -8290 2050 -8260 {}
L 2 2050 -8380 2050 -8350 {}
L 2 2140 -8200 2140 -8120 {}
L 2 2050 -8230 2050 -8120 {}
L 2 2050 -8120 2140 -8120 {}
L 2 1360 -7830 1360 -7820 {}
L 2 1360 -7830 1367.5 -7832.5 {}
L 2 1352.5 -7837.5 1367.5 -7832.5 {}
L 2 1352.5 -7837.5 1367.5 -7842.5 {}
L 2 1352.5 -7847.5 1367.5 -7842.5 {}
L 2 1352.5 -7847.5 1367.5 -7852.5 {}
L 2 1352.5 -7857.5 1367.5 -7852.5 {}
L 2 1352.5 -7857.5 1367.5 -7862.5 {}
L 2 1352.5 -7867.5 1367.5 -7862.5 {}
L 2 1352.5 -7867.5 1360 -7870 {}
L 2 1360 -7880 1360 -7870 {}
L 2 1362.5 -7872.5 1367.5 -7872.5 {}
L 2 1365 -7875 1365 -7870 {}
L 2 1360 -7000 1360 -6990 {}
L 2 1360 -7000 1367.5 -7002.5 {}
L 2 1352.5 -7007.5 1367.5 -7002.5 {}
L 2 1352.5 -7007.5 1367.5 -7012.5 {}
L 2 1352.5 -7017.5 1367.5 -7012.5 {}
L 2 1352.5 -7017.5 1367.5 -7022.5 {}
L 2 1352.5 -7027.5 1367.5 -7022.5 {}
L 2 1352.5 -7027.5 1367.5 -7032.5 {}
L 2 1352.5 -7037.5 1367.5 -7032.5 {}
L 2 1352.5 -7037.5 1360 -7040 {}
L 2 1360 -7050 1360 -7040 {}
L 2 1362.5 -7042.5 1367.5 -7042.5 {}
L 2 1365 -7045 1365 -7040 {}
L 2 1280 -7050 1360 -7050 {}
L 2 1280 -6990 1360 -6990 {}
L 2 1360 -6510 1360 -6500 {}
L 2 1360 -6510 1367.5 -6512.5 {}
L 2 1352.5 -6517.5 1367.5 -6512.5 {}
L 2 1352.5 -6517.5 1367.5 -6522.5 {}
L 2 1352.5 -6527.5 1367.5 -6522.5 {}
L 2 1352.5 -6527.5 1367.5 -6532.5 {}
L 2 1352.5 -6537.5 1367.5 -6532.5 {}
L 2 1352.5 -6537.5 1367.5 -6542.5 {}
L 2 1352.5 -6547.5 1367.5 -6542.5 {}
L 2 1352.5 -6547.5 1360 -6550 {}
L 2 1360 -6560 1360 -6550 {}
L 2 1362.5 -6552.5 1367.5 -6552.5 {}
L 2 1365 -6555 1365 -6550 {}
L 2 1280 -6470 1360 -6500 {}
L 2 1280 -6590 1360 -6560 {}
L 2 725 -8250 725 -8190 {}
L 2 725 -8240 740 -8240 {}
L 2 740 -8250 740 -8240 {}
L 2 725 -8200 740 -8200 {}
L 2 740 -8200 740 -8190 {}
L 2 715 -8235 715 -8205 {}
L 2 715 -8220 715 -8215 {}
L 2 700 -8220 707.5 -8220 {}
L 2 700 -8220 715 -8220 {}
L 2 730 -8220 740 -8220 {}
L 2 725 -8225 730 -8220 {}
L 2 725 -8215 730 -8220 {}
L 2 740 -8290 740 -8280 {}
L 2 740 -8290 747.5 -8292.5 {}
L 2 732.5 -8297.5 747.5 -8292.5 {}
L 2 732.5 -8297.5 747.5 -8302.5 {}
L 2 732.5 -8307.5 747.5 -8302.5 {}
L 2 732.5 -8307.5 747.5 -8312.5 {}
L 2 732.5 -8317.5 747.5 -8312.5 {}
L 2 732.5 -8317.5 747.5 -8322.5 {}
L 2 732.5 -8327.5 747.5 -8322.5 {}
L 2 732.5 -8327.5 740 -8330 {}
L 2 740 -8340 740 -8330 {}
L 2 742.5 -8332.5 747.5 -8332.5 {}
L 2 745 -8335 745 -8330 {}
L 2 830 -8215 830 -8190 {}
L 2 830 -8250 830 -8225 {}
L 2 820 -8225 840 -8225 {}
L 2 820 -8215 840 -8215 {}
L 2 832.5 -8242.5 837.5 -8242.5 {}
L 2 835 -8245 835 -8240 {}
L 2 740 -8280 740 -8250 {}
L 2 740 -8370 740 -8340 {}
L 2 830 -8190 830 -8110 {}
L 2 740 -8220 740 -8110 {}
L 2 740 -8110 830 -8110 {}
L 2 725 -5980 725 -5920 {}
L 2 725 -5970 740 -5970 {}
L 2 740 -5980 740 -5970 {}
L 2 725 -5930 740 -5930 {}
L 2 740 -5930 740 -5920 {}
L 2 715 -5965 715 -5935 {}
L 2 715 -5950 715 -5945 {}
L 2 700 -5950 707.5 -5950 {}
L 2 700 -5950 715 -5950 {}
L 2 730 -5950 740 -5950 {}
L 2 725 -5955 730 -5950 {}
L 2 725 -5945 730 -5950 {}
L 2 740 -6020 740 -6010 {}
L 2 740 -6020 747.5 -6022.5 {}
L 2 732.5 -6027.5 747.5 -6022.5 {}
L 2 732.5 -6027.5 747.5 -6032.5 {}
L 2 732.5 -6037.5 747.5 -6032.5 {}
L 2 732.5 -6037.5 747.5 -6042.5 {}
L 2 732.5 -6047.5 747.5 -6042.5 {}
L 2 732.5 -6047.5 747.5 -6052.5 {}
L 2 732.5 -6057.5 747.5 -6052.5 {}
L 2 732.5 -6057.5 740 -6060 {}
L 2 740 -6070 740 -6060 {}
L 2 742.5 -6062.5 747.5 -6062.5 {}
L 2 745 -6065 745 -6060 {}
L 2 830 -5945 830 -5920 {}
L 2 830 -5980 830 -5955 {}
L 2 820 -5955 840 -5955 {}
L 2 820 -5945 840 -5945 {}
L 2 832.5 -5972.5 837.5 -5972.5 {}
L 2 835 -5975 835 -5970 {}
L 2 740 -6010 740 -5980 {}
L 2 740 -6100 740 -6070 {}
L 2 830 -5920 830 -5840 {}
L 2 740 -5950 740 -5840 {}
L 2 740 -5840 830 -5840 {}
L 2 880 -5980 888.75 -5980 {}
L 2 740 -5980 880 -5980 {}
L 2 1265 -5980 1265 -5920 {}
L 2 1265 -5970 1280 -5970 {}
L 2 1280 -5980 1280 -5970 {}
L 2 1265 -5930 1280 -5930 {}
L 2 1280 -5930 1280 -5920 {}
L 2 1255 -5965 1255 -5935 {}
L 2 1255 -5950 1255 -5945 {}
L 2 1240 -5950 1247.5 -5950 {}
L 2 1240 -5950 1255 -5950 {}
L 2 1270 -5950 1280 -5950 {}
L 2 1265 -5955 1270 -5950 {}
L 2 1265 -5945 1270 -5950 {}
L 2 1280 -6020 1280 -6010 {}
L 2 1280 -6020 1287.5 -6022.5 {}
L 2 1272.5 -6027.5 1287.5 -6022.5 {}
L 2 1272.5 -6027.5 1287.5 -6032.5 {}
L 2 1272.5 -6037.5 1287.5 -6032.5 {}
L 2 1272.5 -6037.5 1287.5 -6042.5 {}
L 2 1272.5 -6047.5 1287.5 -6042.5 {}
L 2 1272.5 -6047.5 1287.5 -6052.5 {}
L 2 1272.5 -6057.5 1287.5 -6052.5 {}
L 2 1272.5 -6057.5 1280 -6060 {}
L 2 1280 -6070 1280 -6060 {}
L 2 1282.5 -6062.5 1287.5 -6062.5 {}
L 2 1285 -6065 1285 -6060 {}
L 2 1370 -5945 1370 -5920 {}
L 2 1370 -5980 1370 -5955 {}
L 2 1360 -5955 1380 -5955 {}
L 2 1360 -5945 1380 -5945 {}
L 2 1372.5 -5972.5 1377.5 -5972.5 {}
L 2 1375 -5975 1375 -5970 {}
L 2 1420 -5980 1428.75 -5980 {}
L 2 1280 -6010 1280 -5980 {}
L 2 1280 -6100 1280 -6070 {}
L 2 1280 -5980 1420 -5980 {}
L 2 1370 -5920 1370 -5840 {}
L 2 1280 -5950 1280 -5840 {}
L 2 1280 -5840 1370 -5840 {}
L 2 2105 -5980 2105 -5920 {}
L 2 2105 -5970 2120 -5970 {}
L 2 2120 -5980 2120 -5970 {}
L 2 2105 -5930 2120 -5930 {}
L 2 2120 -5930 2120 -5920 {}
L 2 2095 -5965 2095 -5935 {}
L 2 2095 -5950 2095 -5945 {}
L 2 2080 -5950 2087.5 -5950 {}
L 2 2080 -5950 2095 -5950 {}
L 2 2110 -5950 2120 -5950 {}
L 2 2105 -5955 2110 -5950 {}
L 2 2105 -5945 2110 -5950 {}
L 2 2120 -6020 2120 -6010 {}
L 2 2120 -6020 2127.5 -6022.5 {}
L 2 2112.5 -6027.5 2127.5 -6022.5 {}
L 2 2112.5 -6027.5 2127.5 -6032.5 {}
L 2 2112.5 -6037.5 2127.5 -6032.5 {}
L 2 2112.5 -6037.5 2127.5 -6042.5 {}
L 2 2112.5 -6047.5 2127.5 -6042.5 {}
L 2 2112.5 -6047.5 2127.5 -6052.5 {}
L 2 2112.5 -6057.5 2127.5 -6052.5 {}
L 2 2112.5 -6057.5 2120 -6060 {}
L 2 2120 -6070 2120 -6060 {}
L 2 2122.5 -6062.5 2127.5 -6062.5 {}
L 2 2125 -6065 2125 -6060 {}
L 2 2210 -5945 2210 -5920 {}
L 2 2210 -5980 2210 -5955 {}
L 2 2200 -5955 2220 -5955 {}
L 2 2200 -5945 2220 -5945 {}
L 2 2212.5 -5972.5 2217.5 -5972.5 {}
L 2 2215 -5975 2215 -5970 {}
L 2 2260 -5980 2268.75 -5980 {}
L 2 2120 -6010 2120 -5980 {}
L 2 2120 -6100 2120 -6070 {}
L 2 2120 -5980 2260 -5980 {}
L 2 2210 -5920 2210 -5840 {}
L 2 2120 -5950 2120 -5840 {}
L 2 2120 -5840 2210 -5840 {}
L 2 1770 -5950 2080 -5950 {}
L 2 1690 -6100 2120 -6100 {}
L 2 1690 -5840 2120 -5840 {}
L 2 1255 -7420 1255 -7360 {}
L 2 1255 -7410 1270 -7410 {}
L 2 1270 -7420 1270 -7410 {}
L 2 1255 -7370 1270 -7370 {}
L 2 1270 -7370 1270 -7360 {}
L 2 1245 -7405 1245 -7375 {}
L 2 1245 -7390 1245 -7385 {}
L 2 1230 -7390 1237.5 -7390 {}
L 2 1230 -7390 1245 -7390 {}
L 2 1260 -7390 1270 -7390 {}
L 2 1255 -7395 1260 -7390 {}
L 2 1255 -7385 1260 -7390 {}
L 2 1270 -7460 1270 -7450 {}
L 2 1270 -7460 1277.5 -7462.5 {}
L 2 1262.5 -7467.5 1277.5 -7462.5 {}
L 2 1262.5 -7467.5 1277.5 -7472.5 {}
L 2 1262.5 -7477.5 1277.5 -7472.5 {}
L 2 1262.5 -7477.5 1277.5 -7482.5 {}
L 2 1262.5 -7487.5 1277.5 -7482.5 {}
L 2 1262.5 -7487.5 1277.5 -7492.5 {}
L 2 1262.5 -7497.5 1277.5 -7492.5 {}
L 2 1262.5 -7497.5 1270 -7500 {}
L 2 1270 -7510 1270 -7500 {}
L 2 1272.5 -7502.5 1277.5 -7502.5 {}
L 2 1275 -7505 1275 -7500 {}
L 2 1360 -7385 1360 -7360 {}
L 2 1360 -7420 1360 -7395 {}
L 2 1350 -7395 1370 -7395 {}
L 2 1350 -7385 1370 -7385 {}
L 2 1362.5 -7412.5 1367.5 -7412.5 {}
L 2 1365 -7415 1365 -7410 {}
L 2 1270 -7450 1270 -7420 {}
L 2 1270 -7540 1270 -7510 {}
L 2 1360 -7360 1360 -7280 {}
L 2 1270 -7390 1270 -7280 {}
L 2 1270 -7280 1360 -7280 {}
L 2 2035 -7430 2035 -7370 {}
L 2 2035 -7420 2050 -7420 {}
L 2 2050 -7430 2050 -7420 {}
L 2 2035 -7380 2050 -7380 {}
L 2 2050 -7380 2050 -7370 {}
L 2 2025 -7415 2025 -7385 {}
L 2 2025 -7400 2025 -7395 {}
L 2 2010 -7400 2017.5 -7400 {}
L 2 2010 -7400 2025 -7400 {}
L 2 2040 -7400 2050 -7400 {}
L 2 2035 -7405 2040 -7400 {}
L 2 2035 -7395 2040 -7400 {}
L 2 2050 -7470 2050 -7460 {}
L 2 2050 -7470 2057.5 -7472.5 {}
L 2 2042.5 -7477.5 2057.5 -7472.5 {}
L 2 2042.5 -7477.5 2057.5 -7482.5 {}
L 2 2042.5 -7487.5 2057.5 -7482.5 {}
L 2 2042.5 -7487.5 2057.5 -7492.5 {}
L 2 2042.5 -7497.5 2057.5 -7492.5 {}
L 2 2042.5 -7497.5 2057.5 -7502.5 {}
L 2 2042.5 -7507.5 2057.5 -7502.5 {}
L 2 2042.5 -7507.5 2050 -7510 {}
L 2 2050 -7520 2050 -7510 {}
L 2 2052.5 -7512.5 2057.5 -7512.5 {}
L 2 2055 -7515 2055 -7510 {}
L 2 2140 -7395 2140 -7370 {}
L 2 2140 -7430 2140 -7405 {}
L 2 2130 -7405 2150 -7405 {}
L 2 2130 -7395 2150 -7395 {}
L 2 2142.5 -7422.5 2147.5 -7422.5 {}
L 2 2145 -7425 2145 -7420 {}
L 2 2050 -7460 2050 -7430 {}
L 2 2050 -7550 2050 -7520 {}
L 2 2140 -7370 2140 -7290 {}
L 2 2050 -7400 2050 -7290 {}
L 2 2050 -7290 2140 -7290 {}
L 2 725 -7420 725 -7360 {}
L 2 725 -7410 740 -7410 {}
L 2 740 -7420 740 -7410 {}
L 2 725 -7370 740 -7370 {}
L 2 740 -7370 740 -7360 {}
L 2 715 -7405 715 -7375 {}
L 2 715 -7390 715 -7385 {}
L 2 700 -7390 707.5 -7390 {}
L 2 700 -7390 715 -7390 {}
L 2 730 -7390 740 -7390 {}
L 2 725 -7395 730 -7390 {}
L 2 725 -7385 730 -7390 {}
L 2 740 -7460 740 -7450 {}
L 2 740 -7460 747.5 -7462.5 {}
L 2 732.5 -7467.5 747.5 -7462.5 {}
L 2 732.5 -7467.5 747.5 -7472.5 {}
L 2 732.5 -7477.5 747.5 -7472.5 {}
L 2 732.5 -7477.5 747.5 -7482.5 {}
L 2 732.5 -7487.5 747.5 -7482.5 {}
L 2 732.5 -7487.5 747.5 -7492.5 {}
L 2 732.5 -7497.5 747.5 -7492.5 {}
L 2 732.5 -7497.5 740 -7500 {}
L 2 740 -7510 740 -7500 {}
L 2 742.5 -7502.5 747.5 -7502.5 {}
L 2 745 -7505 745 -7500 {}
L 2 830 -7385 830 -7360 {}
L 2 830 -7420 830 -7395 {}
L 2 820 -7395 840 -7395 {}
L 2 820 -7385 840 -7385 {}
L 2 832.5 -7412.5 837.5 -7412.5 {}
L 2 835 -7415 835 -7410 {}
L 2 740 -7450 740 -7420 {}
L 2 740 -7540 740 -7510 {}
L 2 830 -7360 830 -7280 {}
L 2 740 -7390 740 -7280 {}
L 2 740 -7280 830 -7280 {}
L 2 1795 -8720 1795 -8660 {}
L 2 1795 -8710 1810 -8710 {}
L 2 1810 -8720 1810 -8710 {}
L 2 1795 -8670 1810 -8670 {}
L 2 1810 -8670 1810 -8660 {}
L 2 1785 -8705 1785 -8675 {}
L 2 1785 -8690 1785 -8685 {}
L 2 1770 -8690 1777.5 -8690 {}
L 2 1770 -8690 1785 -8690 {}
L 2 1800 -8690 1810 -8690 {}
L 2 1795 -8695 1800 -8690 {}
L 2 1795 -8685 1800 -8690 {}
L 2 1810 -8760 1810 -8750 {}
L 2 1810 -8760 1817.5 -8762.5 {}
L 2 1802.5 -8767.5 1817.5 -8762.5 {}
L 2 1802.5 -8767.5 1817.5 -8772.5 {}
L 2 1802.5 -8777.5 1817.5 -8772.5 {}
L 2 1802.5 -8777.5 1817.5 -8782.5 {}
L 2 1802.5 -8787.5 1817.5 -8782.5 {}
L 2 1802.5 -8787.5 1817.5 -8792.5 {}
L 2 1802.5 -8797.5 1817.5 -8792.5 {}
L 2 1802.5 -8797.5 1810 -8800 {}
L 2 1810 -8810 1810 -8800 {}
L 2 1812.5 -8802.5 1817.5 -8802.5 {}
L 2 1815 -8805 1815 -8800 {}
L 2 1900 -8685 1900 -8660 {}
L 2 1900 -8720 1900 -8695 {}
L 2 1890 -8695 1910 -8695 {}
L 2 1890 -8685 1910 -8685 {}
L 2 1902.5 -8712.5 1907.5 -8712.5 {}
L 2 1905 -8715 1905 -8710 {}
L 2 1810 -8750 1810 -8720 {}
L 2 1810 -8840 1810 -8810 {}
L 2 1900 -8660 1900 -8580 {}
L 2 1810 -8690 1810 -8580 {}
L 2 1810 -8580 1900 -8580 {}
L 2 725 -8720 725 -8660 {}
L 2 725 -8710 740 -8710 {}
L 2 740 -8720 740 -8710 {}
L 2 725 -8670 740 -8670 {}
L 2 740 -8670 740 -8660 {}
L 2 715 -8705 715 -8675 {}
L 2 715 -8690 715 -8685 {}
L 2 700 -8690 707.5 -8690 {}
L 2 700 -8690 715 -8690 {}
L 2 730 -8690 740 -8690 {}
L 2 725 -8695 730 -8690 {}
L 2 725 -8685 730 -8690 {}
L 2 740 -8760 740 -8750 {}
L 2 740 -8760 747.5 -8762.5 {}
L 2 732.5 -8767.5 747.5 -8762.5 {}
L 2 732.5 -8767.5 747.5 -8772.5 {}
L 2 732.5 -8777.5 747.5 -8772.5 {}
L 2 732.5 -8777.5 747.5 -8782.5 {}
L 2 732.5 -8787.5 747.5 -8782.5 {}
L 2 732.5 -8787.5 747.5 -8792.5 {}
L 2 732.5 -8797.5 747.5 -8792.5 {}
L 2 732.5 -8797.5 740 -8800 {}
L 2 740 -8810 740 -8800 {}
L 2 742.5 -8802.5 747.5 -8802.5 {}
L 2 745 -8805 745 -8800 {}
L 2 830 -8685 830 -8660 {}
L 2 830 -8720 830 -8695 {}
L 2 820 -8695 840 -8695 {}
L 2 820 -8685 840 -8685 {}
L 2 832.5 -8712.5 837.5 -8712.5 {}
L 2 835 -8715 835 -8710 {}
L 2 740 -8750 740 -8720 {}
L 2 740 -8840 740 -8810 {}
L 2 830 -8660 830 -8580 {}
L 2 740 -8690 740 -8580 {}
L 2 740 -8580 830 -8580 {}
L 2 1572.5 -8652.5 1577.5 -8652.5 {}
L 2 1575 -8655 1575 -8650 {}
L 2 1570 -8660 1570 -8600 {}
L 2 1570 -8600 1570 -8580 {}
L 2 1570 -8840 1570 -8660 {}
L 2 2255 -8720 2255 -8660 {}
L 2 2255 -8710 2270 -8710 {}
L 2 2270 -8720 2270 -8710 {}
L 2 2255 -8670 2270 -8670 {}
L 2 2270 -8670 2270 -8660 {}
L 2 2245 -8705 2245 -8675 {}
L 2 2245 -8690 2245 -8685 {}
L 2 2230 -8690 2237.5 -8690 {}
L 2 2230 -8690 2245 -8690 {}
L 2 2260 -8690 2270 -8690 {}
L 2 2255 -8695 2260 -8690 {}
L 2 2255 -8685 2260 -8690 {}
L 2 2270 -8760 2270 -8750 {}
L 2 2270 -8760 2277.5 -8762.5 {}
L 2 2262.5 -8767.5 2277.5 -8762.5 {}
L 2 2262.5 -8767.5 2277.5 -8772.5 {}
L 2 2262.5 -8777.5 2277.5 -8772.5 {}
L 2 2262.5 -8777.5 2277.5 -8782.5 {}
L 2 2262.5 -8787.5 2277.5 -8782.5 {}
L 2 2262.5 -8787.5 2277.5 -8792.5 {}
L 2 2262.5 -8797.5 2277.5 -8792.5 {}
L 2 2262.5 -8797.5 2270 -8800 {}
L 2 2270 -8810 2270 -8800 {}
L 2 2272.5 -8802.5 2277.5 -8802.5 {}
L 2 2275 -8805 2275 -8800 {}
L 2 2270 -8750 2270 -8720 {}
L 2 2270 -8840 2270 -8810 {}
L 2 2270 -8690 2270 -8580 {}
L 2 2270 -8580 2360 -8580 {}
L 2 2032.5 -8652.5 2037.5 -8652.5 {}
L 2 2035 -8655 2035 -8650 {}
L 2 2030 -8660 2030 -8600 {}
L 2 2030 -8600 2030 -8580 {}
L 2 2030 -8840 2030 -8660 {}
L 2 1300 -5630 1430 -5630 {}
L 2 1860 -5630 1990 -5630 {}
L 2 2430 -5660 2560 -5660 {}
L 2 520 -4860 760 -4860 {}
L 2 1060 -4860 1300 -4860 {}
L 2 2190 -4860 2500 -4930 {}
L 2 760 -4370 760 -4360 {}
L 2 760 -4370 767.5 -4372.5 {}
L 2 752.5 -4377.5 767.5 -4372.5 {}
L 2 752.5 -4377.5 767.5 -4382.5 {}
L 2 752.5 -4387.5 767.5 -4382.5 {}
L 2 752.5 -4387.5 767.5 -4392.5 {}
L 2 752.5 -4397.5 767.5 -4392.5 {}
L 2 752.5 -4397.5 767.5 -4402.5 {}
L 2 752.5 -4407.5 767.5 -4402.5 {}
L 2 752.5 -4407.5 760 -4410 {}
L 2 760 -4420 760 -4410 {}
L 2 762.5 -4412.5 767.5 -4412.5 {}
L 2 765 -4415 765 -4410 {}
L 2 630 -4470 630 -4450 {}
L 2 620 -4470 640 -4470 {}
L 2 760 -4450 760 -4420 {}
L 2 520 -4450 760 -4450 {}
L 2 520 -4450 520 -4270 {}
L 2 760 -4360 760 -4330 {}
L 2 1860 -4400 1860 -4390 {}
L 2 1860 -4400 1867.5 -4402.5 {}
L 2 1852.5 -4407.5 1867.5 -4402.5 {}
L 2 1852.5 -4407.5 1867.5 -4412.5 {}
L 2 1852.5 -4417.5 1867.5 -4412.5 {}
L 2 1852.5 -4417.5 1867.5 -4422.5 {}
L 2 1852.5 -4427.5 1867.5 -4422.5 {}
L 2 1852.5 -4427.5 1867.5 -4432.5 {}
L 2 1852.5 -4437.5 1867.5 -4432.5 {}
L 2 1852.5 -4437.5 1860 -4440 {}
L 2 1860 -4450 1860 -4440 {}
L 2 1862.5 -4442.5 1867.5 -4442.5 {}
L 2 1865 -4445 1865 -4440 {}
L 2 1730 -4500 1730 -4480 {}
L 2 1720 -4500 1740 -4500 {}
L 2 1860 -4480 1860 -4450 {}
L 2 1620 -4480 1860 -4480 {}
L 2 1620 -4480 1620 -4270 {}
L 2 1860 -4390 1860 -4330 {}
L 2 1300 -4370 1300 -4360 {}
L 2 1300 -4370 1307.5 -4372.5 {}
L 2 1292.5 -4377.5 1307.5 -4372.5 {}
L 2 1292.5 -4377.5 1307.5 -4382.5 {}
L 2 1292.5 -4387.5 1307.5 -4382.5 {}
L 2 1292.5 -4387.5 1307.5 -4392.5 {}
L 2 1292.5 -4397.5 1307.5 -4392.5 {}
L 2 1292.5 -4397.5 1307.5 -4402.5 {}
L 2 1292.5 -4407.5 1307.5 -4402.5 {}
L 2 1292.5 -4407.5 1300 -4410 {}
L 2 1300 -4420 1300 -4410 {}
L 2 1302.5 -4412.5 1307.5 -4412.5 {}
L 2 1305 -4415 1305 -4410 {}
L 2 1170 -4470 1170 -4450 {}
L 2 1160 -4470 1180 -4470 {}
L 2 1300 -4450 1300 -4420 {}
L 2 1060 -4450 1300 -4450 {}
L 2 1060 -4450 1060 -4270 {}
L 2 1300 -4360 1300 -4330 {}
L 2 1360 -3510 1360 -3500 {}
L 2 1360 -3510 1367.5 -3512.5 {}
L 2 1352.5 -3517.5 1367.5 -3512.5 {}
L 2 1352.5 -3517.5 1367.5 -3522.5 {}
L 2 1352.5 -3527.5 1367.5 -3522.5 {}
L 2 1352.5 -3527.5 1367.5 -3532.5 {}
L 2 1352.5 -3537.5 1367.5 -3532.5 {}
L 2 1352.5 -3537.5 1367.5 -3542.5 {}
L 2 1352.5 -3547.5 1367.5 -3542.5 {}
L 2 1352.5 -3547.5 1360 -3550 {}
L 2 1360 -3560 1360 -3550 {}
L 2 1362.5 -3552.5 1367.5 -3552.5 {}
L 2 1365 -3555 1365 -3550 {}
L 2 1900 -3540 1900 -3500 {}
L 2 1360 -3890 1360 -3880 {}
L 2 1360 -3890 1367.5 -3892.5 {}
L 2 1352.5 -3897.5 1367.5 -3892.5 {}
L 2 1352.5 -3897.5 1367.5 -3902.5 {}
L 2 1352.5 -3907.5 1367.5 -3902.5 {}
L 2 1352.5 -3907.5 1367.5 -3912.5 {}
L 2 1352.5 -3917.5 1367.5 -3912.5 {}
L 2 1352.5 -3917.5 1367.5 -3922.5 {}
L 2 1352.5 -3927.5 1367.5 -3922.5 {}
L 2 1352.5 -3927.5 1360 -3930 {}
L 2 1360 -3940 1360 -3930 {}
L 2 1362.5 -3932.5 1367.5 -3932.5 {}
L 2 1365 -3935 1365 -3930 {}
L 2 1360 -3950 1360 -3940 {}
L 2 1780 -3940 1900 -3940 {}
L 2 1780 -3880 1900 -3880 {}
L 2 1780 -3890 1780 -3880 {}
L 2 1780 -3890 1787.5 -3892.5 {}
L 2 1772.5 -3897.5 1787.5 -3892.5 {}
L 2 1772.5 -3897.5 1787.5 -3902.5 {}
L 2 1772.5 -3907.5 1787.5 -3902.5 {}
L 2 1772.5 -3907.5 1787.5 -3912.5 {}
L 2 1772.5 -3917.5 1787.5 -3912.5 {}
L 2 1772.5 -3917.5 1787.5 -3922.5 {}
L 2 1772.5 -3927.5 1787.5 -3922.5 {}
L 2 1772.5 -3927.5 1780 -3930 {}
L 2 1780 -3940 1780 -3930 {}
L 2 1782.5 -3932.5 1787.5 -3932.5 {}
L 2 1785 -3935 1785 -3930 {}
L 2 1360 -2830 1360 -2730 {}
L 2 1250 -2830 1250 -2730 {}
L 2 1470 -2830 1470 -2730 {}
L 2 1900 -2830 1900 -2730 {}
L 2 1790 -2830 1790 -2730 {}
L 2 2010 -2830 2010 -2730 {}
L 2 2430 -2930 2430 -2730 {}
L 2 2320 -2930 2320 -2730 {}
L 2 2540 -2930 2540 -2730 {}
L 2 2380 -3940 2500 -3940 {}
L 2 2380 -3880 2500 -3880 {}
L 2 2380 -3890 2380 -3880 {}
L 2 2380 -3890 2387.5 -3892.5 {}
L 2 2372.5 -3897.5 2387.5 -3892.5 {}
L 2 2372.5 -3897.5 2387.5 -3902.5 {}
L 2 2372.5 -3907.5 2387.5 -3902.5 {}
L 2 2372.5 -3907.5 2387.5 -3912.5 {}
L 2 2372.5 -3917.5 2387.5 -3912.5 {}
L 2 2372.5 -3917.5 2387.5 -3922.5 {}
L 2 2372.5 -3927.5 2387.5 -3922.5 {}
L 2 2372.5 -3927.5 2380 -3930 {}
L 2 2380 -3940 2380 -3930 {}
L 2 2382.5 -3932.5 2387.5 -3932.5 {}
L 2 2385 -3935 2385 -3930 {}
L 2 1360 -900 1360 -800 {}
L 2 1250 -900 1250 -800 {}
L 2 1470 -900 1470 -800 {}
L 2 1250 -750 1250 -740 {}
L 2 1250 -750 1257.5 -752.5 {}
L 2 1242.5 -757.5 1257.5 -752.5 {}
L 2 1242.5 -757.5 1257.5 -762.5 {}
L 2 1242.5 -767.5 1257.5 -762.5 {}
L 2 1242.5 -767.5 1257.5 -772.5 {}
L 2 1242.5 -777.5 1257.5 -772.5 {}
L 2 1242.5 -777.5 1257.5 -782.5 {}
L 2 1242.5 -787.5 1257.5 -782.5 {}
L 2 1242.5 -787.5 1250 -790 {}
L 2 1250 -800 1250 -790 {}
L 2 1252.5 -792.5 1257.5 -792.5 {}
L 2 1255 -795 1255 -790 {}
L 2 1360 -750 1360 -740 {}
L 2 1360 -750 1367.5 -752.5 {}
L 2 1352.5 -757.5 1367.5 -752.5 {}
L 2 1352.5 -757.5 1367.5 -762.5 {}
L 2 1352.5 -767.5 1367.5 -762.5 {}
L 2 1352.5 -767.5 1367.5 -772.5 {}
L 2 1352.5 -777.5 1367.5 -772.5 {}
L 2 1352.5 -777.5 1367.5 -782.5 {}
L 2 1352.5 -787.5 1367.5 -782.5 {}
L 2 1352.5 -787.5 1360 -790 {}
L 2 1360 -800 1360 -790 {}
L 2 1362.5 -792.5 1367.5 -792.5 {}
L 2 1365 -795 1365 -790 {}
L 2 1470 -750 1470 -740 {}
L 2 1470 -750 1477.5 -752.5 {}
L 2 1462.5 -757.5 1477.5 -752.5 {}
L 2 1462.5 -757.5 1477.5 -762.5 {}
L 2 1462.5 -767.5 1477.5 -762.5 {}
L 2 1462.5 -767.5 1477.5 -772.5 {}
L 2 1462.5 -777.5 1477.5 -772.5 {}
L 2 1462.5 -777.5 1477.5 -782.5 {}
L 2 1462.5 -787.5 1477.5 -782.5 {}
L 2 1462.5 -787.5 1470 -790 {}
L 2 1470 -800 1470 -790 {}
L 2 1472.5 -792.5 1477.5 -792.5 {}
L 2 1475 -795 1475 -790 {}
L 2 1360 -740 1360 -710 {}
L 2 1250 -740 1250 -710 {}
L 2 1470 -740 1470 -710 {}
L 2 1900 -900 1900 -850 {}
L 2 1790 -900 1790 -850 {}
L 2 2010 -900 2010 -850 {}
L 2 1790 -800 1790 -790 {}
L 2 1790 -800 1797.5 -802.5 {}
L 2 1782.5 -807.5 1797.5 -802.5 {}
L 2 1782.5 -807.5 1797.5 -812.5 {}
L 2 1782.5 -817.5 1797.5 -812.5 {}
L 2 1782.5 -817.5 1797.5 -822.5 {}
L 2 1782.5 -827.5 1797.5 -822.5 {}
L 2 1782.5 -827.5 1797.5 -832.5 {}
L 2 1782.5 -837.5 1797.5 -832.5 {}
L 2 1782.5 -837.5 1790 -840 {}
L 2 1790 -850 1790 -840 {}
L 2 1792.5 -842.5 1797.5 -842.5 {}
L 2 1795 -845 1795 -840 {}
L 2 1900 -800 1900 -790 {}
L 2 1900 -800 1907.5 -802.5 {}
L 2 1892.5 -807.5 1907.5 -802.5 {}
L 2 1892.5 -807.5 1907.5 -812.5 {}
L 2 1892.5 -817.5 1907.5 -812.5 {}
L 2 1892.5 -817.5 1907.5 -822.5 {}
L 2 1892.5 -827.5 1907.5 -822.5 {}
L 2 1892.5 -827.5 1907.5 -832.5 {}
L 2 1892.5 -837.5 1907.5 -832.5 {}
L 2 1892.5 -837.5 1900 -840 {}
L 2 1900 -850 1900 -840 {}
L 2 1902.5 -842.5 1907.5 -842.5 {}
L 2 1905 -845 1905 -840 {}
L 2 2010 -800 2010 -790 {}
L 2 2010 -800 2017.5 -802.5 {}
L 2 2002.5 -807.5 2017.5 -802.5 {}
L 2 2002.5 -807.5 2017.5 -812.5 {}
L 2 2002.5 -817.5 2017.5 -812.5 {}
L 2 2002.5 -817.5 2017.5 -822.5 {}
L 2 2002.5 -827.5 2017.5 -822.5 {}
L 2 2002.5 -827.5 2017.5 -832.5 {}
L 2 2002.5 -837.5 2017.5 -832.5 {}
L 2 2002.5 -837.5 2010 -840 {}
L 2 2010 -850 2010 -840 {}
L 2 2012.5 -842.5 2017.5 -842.5 {}
L 2 2015 -845 2015 -840 {}
L 2 1900 -790 1900 -710 {}
L 2 1790 -790 1790 -710 {}
L 2 2010 -790 2010 -710 {}
L 2 635 -2470 635 -2410 {}
L 2 635 -2460 650 -2460 {}
L 2 650 -2470 650 -2460 {}
L 2 635 -2420 650 -2420 {}
L 2 650 -2420 650 -2410 {}
L 2 625 -2455 625 -2425 {}
L 2 625 -2440 625 -2435 {}
L 2 610 -2440 617.5 -2440 {}
L 2 610 -2440 625 -2440 {}
L 2 640 -2440 650 -2440 {}
L 2 635 -2445 640 -2440 {}
L 2 635 -2435 640 -2440 {}
L 2 1215 -2470 1215 -2410 {}
L 2 1215 -2460 1230 -2460 {}
L 2 1230 -2470 1230 -2460 {}
L 2 1215 -2420 1230 -2420 {}
L 2 1230 -2420 1230 -2410 {}
L 2 1205 -2455 1205 -2425 {}
L 2 1205 -2440 1205 -2435 {}
L 2 1190 -2440 1197.5 -2440 {}
L 2 1190 -2440 1205 -2440 {}
L 2 1220 -2440 1230 -2440 {}
L 2 1215 -2445 1220 -2440 {}
L 2 1215 -2435 1220 -2440 {}
L 2 1255 -8720 1255 -8660 {}
L 2 1255 -8710 1270 -8710 {}
L 2 1270 -8720 1270 -8710 {}
L 2 1255 -8670 1270 -8670 {}
L 2 1270 -8670 1270 -8660 {}
L 2 1245 -8705 1245 -8675 {}
L 2 1245 -8690 1245 -8685 {}
L 2 1230 -8690 1237.5 -8690 {}
L 2 1230 -8690 1245 -8690 {}
L 2 1260 -8690 1270 -8690 {}
L 2 1255 -8695 1260 -8690 {}
L 2 1255 -8685 1260 -8690 {}
L 2 1270 -8760 1270 -8750 {}
L 2 1270 -8760 1277.5 -8762.5 {}
L 2 1262.5 -8767.5 1277.5 -8762.5 {}
L 2 1262.5 -8767.5 1277.5 -8772.5 {}
L 2 1262.5 -8777.5 1277.5 -8772.5 {}
L 2 1262.5 -8777.5 1277.5 -8782.5 {}
L 2 1262.5 -8787.5 1277.5 -8782.5 {}
L 2 1262.5 -8787.5 1277.5 -8792.5 {}
L 2 1262.5 -8797.5 1277.5 -8792.5 {}
L 2 1262.5 -8797.5 1270 -8800 {}
L 2 1270 -8810 1270 -8800 {}
L 2 1272.5 -8802.5 1277.5 -8802.5 {}
L 2 1275 -8805 1275 -8800 {}
L 2 1360 -8685 1360 -8660 {}
L 2 1360 -8720 1360 -8695 {}
L 2 1350 -8695 1370 -8695 {}
L 2 1350 -8685 1370 -8685 {}
L 2 1362.5 -8712.5 1367.5 -8712.5 {}
L 2 1365 -8715 1365 -8710 {}
L 2 1270 -8750 1270 -8720 {}
L 2 1270 -8840 1270 -8810 {}
L 2 1360 -8660 1360 -8580 {}
L 2 1270 -8690 1270 -8580 {}
L 2 1270 -8580 1360 -8580 {}
L 2 1360 -520 1360 -420 {}
L 2 1250 -520 1250 -420 {}
L 2 1470 -520 1470 -420 {}
L 2 1250 -370 1250 -360 {}
L 2 1250 -370 1257.5 -372.5 {}
L 2 1242.5 -377.5 1257.5 -372.5 {}
L 2 1242.5 -377.5 1257.5 -382.5 {}
L 2 1242.5 -387.5 1257.5 -382.5 {}
L 2 1242.5 -387.5 1257.5 -392.5 {}
L 2 1242.5 -397.5 1257.5 -392.5 {}
L 2 1242.5 -397.5 1257.5 -402.5 {}
L 2 1242.5 -407.5 1257.5 -402.5 {}
L 2 1242.5 -407.5 1250 -410 {}
L 2 1250 -420 1250 -410 {}
L 2 1252.5 -412.5 1257.5 -412.5 {}
L 2 1255 -415 1255 -410 {}
L 2 1360 -370 1360 -360 {}
L 2 1360 -370 1367.5 -372.5 {}
L 2 1352.5 -377.5 1367.5 -372.5 {}
L 2 1352.5 -377.5 1367.5 -382.5 {}
L 2 1352.5 -387.5 1367.5 -382.5 {}
L 2 1352.5 -387.5 1367.5 -392.5 {}
L 2 1352.5 -397.5 1367.5 -392.5 {}
L 2 1352.5 -397.5 1367.5 -402.5 {}
L 2 1352.5 -407.5 1367.5 -402.5 {}
L 2 1352.5 -407.5 1360 -410 {}
L 2 1360 -420 1360 -410 {}
L 2 1362.5 -412.5 1367.5 -412.5 {}
L 2 1365 -415 1365 -410 {}
L 2 1470 -370 1470 -360 {}
L 2 1470 -370 1477.5 -372.5 {}
L 2 1462.5 -377.5 1477.5 -372.5 {}
L 2 1462.5 -377.5 1477.5 -382.5 {}
L 2 1462.5 -387.5 1477.5 -382.5 {}
L 2 1462.5 -387.5 1477.5 -392.5 {}
L 2 1462.5 -397.5 1477.5 -392.5 {}
L 2 1462.5 -397.5 1477.5 -402.5 {}
L 2 1462.5 -407.5 1477.5 -402.5 {}
L 2 1462.5 -407.5 1470 -410 {}
L 2 1470 -420 1470 -410 {}
L 2 1472.5 -412.5 1477.5 -412.5 {}
L 2 1475 -415 1475 -410 {}
L 2 1900 -520 1900 -470 {}
L 2 1790 -520 1790 -470 {}
L 2 2010 -520 2010 -470 {}
L 2 1790 -420 1790 -410 {}
L 2 1790 -420 1797.5 -422.5 {}
L 2 1782.5 -427.5 1797.5 -422.5 {}
L 2 1782.5 -427.5 1797.5 -432.5 {}
L 2 1782.5 -437.5 1797.5 -432.5 {}
L 2 1782.5 -437.5 1797.5 -442.5 {}
L 2 1782.5 -447.5 1797.5 -442.5 {}
L 2 1782.5 -447.5 1797.5 -452.5 {}
L 2 1782.5 -457.5 1797.5 -452.5 {}
L 2 1782.5 -457.5 1790 -460 {}
L 2 1790 -470 1790 -460 {}
L 2 1792.5 -462.5 1797.5 -462.5 {}
L 2 1795 -465 1795 -460 {}
L 2 1900 -420 1900 -410 {}
L 2 1900 -420 1907.5 -422.5 {}
L 2 1892.5 -427.5 1907.5 -422.5 {}
L 2 1892.5 -427.5 1907.5 -432.5 {}
L 2 1892.5 -437.5 1907.5 -432.5 {}
L 2 1892.5 -437.5 1907.5 -442.5 {}
L 2 1892.5 -447.5 1907.5 -442.5 {}
L 2 1892.5 -447.5 1907.5 -452.5 {}
L 2 1892.5 -457.5 1907.5 -452.5 {}
L 2 1892.5 -457.5 1900 -460 {}
L 2 1900 -470 1900 -460 {}
L 2 1902.5 -462.5 1907.5 -462.5 {}
L 2 1905 -465 1905 -460 {}
L 2 2010 -420 2010 -410 {}
L 2 2010 -420 2017.5 -422.5 {}
L 2 2002.5 -427.5 2017.5 -422.5 {}
L 2 2002.5 -427.5 2017.5 -432.5 {}
L 2 2002.5 -437.5 2017.5 -432.5 {}
L 2 2002.5 -437.5 2017.5 -442.5 {}
L 2 2002.5 -447.5 2017.5 -442.5 {}
L 2 2002.5 -447.5 2017.5 -452.5 {}
L 2 2002.5 -457.5 2017.5 -452.5 {}
L 2 2002.5 -457.5 2010 -460 {}
L 2 2010 -470 2010 -460 {}
L 2 2012.5 -462.5 2017.5 -462.5 {}
L 2 2015 -465 2015 -460 {}
L 2 1900 -410 1900 -330 {}
L 2 1790 -410 1790 -330 {}
L 2 2010 -410 2010 -330 {}
L 2 600 -2190 720 -2190 {}
L 2 1220 -2100 1340 -2100 {}
L 2 740 -1970 740 -1850 {}
L 2 1280 -1940 1280 -1820 {}
L 2 2280 -1860 2410 -1860 {}
L 2 2360 -3350 2440 -3180 {}
L 2 1900 -3350 1900 -3180 {}
L 2 1760 -1140 1880 -1140 {}
L 2 680 -1190 680 -1180 {}
L 2 680 -1190 687.5 -1192.5 {}
L 2 672.5 -1197.5 687.5 -1192.5 {}
L 2 672.5 -1197.5 687.5 -1202.5 {}
L 2 672.5 -1207.5 687.5 -1202.5 {}
L 2 672.5 -1207.5 687.5 -1212.5 {}
L 2 672.5 -1217.5 687.5 -1212.5 {}
L 2 672.5 -1217.5 687.5 -1222.5 {}
L 2 672.5 -1227.5 687.5 -1222.5 {}
L 2 672.5 -1227.5 680 -1230 {}
L 2 680 -1240 680 -1230 {}
L 2 682.5 -1232.5 687.5 -1232.5 {}
L 2 685 -1235 685 -1230 {}
L 2 800 -1190 800 -1180 {}
L 2 800 -1190 807.5 -1192.5 {}
L 2 792.5 -1197.5 807.5 -1192.5 {}
L 2 792.5 -1197.5 807.5 -1202.5 {}
L 2 792.5 -1207.5 807.5 -1202.5 {}
L 2 792.5 -1207.5 807.5 -1212.5 {}
L 2 792.5 -1217.5 807.5 -1212.5 {}
L 2 792.5 -1217.5 807.5 -1222.5 {}
L 2 792.5 -1227.5 807.5 -1222.5 {}
L 2 792.5 -1227.5 800 -1230 {}
L 2 800 -1240 800 -1230 {}
L 2 802.5 -1232.5 807.5 -1232.5 {}
L 2 805 -1235 805 -1230 {}
L 2 1220 -1190 1220 -1180 {}
L 2 1220 -1190 1227.5 -1192.5 {}
L 2 1212.5 -1197.5 1227.5 -1192.5 {}
L 2 1212.5 -1197.5 1227.5 -1202.5 {}
L 2 1212.5 -1207.5 1227.5 -1202.5 {}
L 2 1212.5 -1207.5 1227.5 -1212.5 {}
L 2 1212.5 -1217.5 1227.5 -1212.5 {}
L 2 1212.5 -1217.5 1227.5 -1222.5 {}
L 2 1212.5 -1227.5 1227.5 -1222.5 {}
L 2 1212.5 -1227.5 1220 -1230 {}
L 2 1220 -1240 1220 -1230 {}
L 2 1222.5 -1232.5 1227.5 -1232.5 {}
L 2 1225 -1235 1225 -1230 {}
L 2 1340 -1190 1340 -1180 {}
L 2 1340 -1190 1347.5 -1192.5 {}
L 2 1332.5 -1197.5 1347.5 -1192.5 {}
L 2 1332.5 -1197.5 1347.5 -1202.5 {}
L 2 1332.5 -1207.5 1347.5 -1202.5 {}
L 2 1332.5 -1207.5 1347.5 -1212.5 {}
L 2 1332.5 -1217.5 1347.5 -1212.5 {}
L 2 1332.5 -1217.5 1347.5 -1222.5 {}
L 2 1332.5 -1227.5 1347.5 -1222.5 {}
L 2 1332.5 -1227.5 1340 -1230 {}
L 2 1340 -1240 1340 -1230 {}
L 2 1342.5 -1232.5 1347.5 -1232.5 {}
L 2 1345 -1235 1345 -1230 {}
L 2 1560 75 1560 100 {}
L 2 1560 40 1560 65 {}
L 2 1550 65 1570 65 {}
L 2 1550 75 1570 75 {}
L 2 1562.5 47.5 1567.5 47.5 {}
L 2 1565 45 1565 50 {}
L 2 1560 100 1560 180 {}
L 2 1230 160 1230 180 {}
L 2 1470 70 1470 180 {}
L 2 1470 180 1560 180 {}
L 2 1230 180 1470 180 {}
L 2 1470 40 1610 40 {}
L 2 740 -1540 740 -1420 {}
L 2 1200 -1590 1200 -1470 {}
L 2 1060 -5280 1060 -5100 {}
L 2 2520 -5070 2520 -5020 {}
L 2 2360 -1500 2610 -1500 {}
L 2 2430 -105 2430 -80 {}
L 2 2430 -140 2430 -115 {}
L 2 2420 -115 2440 -115 {}
L 2 2420 -105 2440 -105 {}
L 2 2432.5 -132.5 2437.5 -132.5 {}
L 2 2435 -135 2435 -130 {}
L 2 2430 -80 2430 0 {}
L 2 2100 -20 2100 0 {}
L 2 2340 -110 2340 0 {}
L 2 2340 0 2430 0 {}
L 2 2100 0 2340 0 {}
L 2 2340 -140 2480 -140 {}
L 4 1032.5 -8182.5 1037.5 -8182.5 {}
L 4 1035 -8185 1035 -8180 {}
L 4 1030 -8190 1030 -8130 {}
L 4 1140 -8110 1140 -8097.5 {}
L 4 1135 -8097.5 1145 -8097.5 {}
L 4 1140 -8092.5 1145 -8097.5 {}
L 4 1135 -8097.5 1140 -8092.5 {}
L 4 1140 -8390 1140 -8370 {}
L 4 1130 -8390 1150 -8390 {}
L 4 1572.5 -8182.5 1577.5 -8182.5 {}
L 4 1575 -8185 1575 -8180 {}
L 4 1570 -8190 1570 -8130 {}
L 4 1680 -8110 1680 -8097.5 {}
L 4 1675 -8097.5 1685 -8097.5 {}
L 4 1680 -8092.5 1685 -8097.5 {}
L 4 1675 -8097.5 1680 -8092.5 {}
L 4 1680 -8390 1680 -8370 {}
L 4 1670 -8390 1690 -8390 {}
L 4 502.5 -8182.5 507.5 -8182.5 {}
L 4 505 -8185 505 -8180 {}
L 4 500 -8190 500 -8130 {}
L 4 610 -8110 610 -8097.5 {}
L 4 605 -8097.5 615 -8097.5 {}
L 4 610 -8092.5 615 -8097.5 {}
L 4 605 -8097.5 610 -8092.5 {}
L 4 610 -8390 610 -8370 {}
L 4 600 -8390 620 -8390 {}
L 4 725 -7790 725 -7730 {}
L 4 725 -7780 740 -7780 {}
L 4 740 -7790 740 -7780 {}
L 4 725 -7740 740 -7740 {}
L 4 740 -7740 740 -7730 {}
L 4 715 -7775 715 -7745 {}
L 4 715 -7760 715 -7755 {}
L 4 700 -7760 707.5 -7760 {}
L 4 700 -7760 715 -7760 {}
L 4 730 -7760 740 -7760 {}
L 4 725 -7765 730 -7760 {}
L 4 725 -7755 730 -7760 {}
L 4 740 -7830 740 -7820 {}
L 4 740 -7830 747.5 -7832.5 {}
L 4 732.5 -7837.5 747.5 -7832.5 {}
L 4 732.5 -7837.5 747.5 -7842.5 {}
L 4 732.5 -7847.5 747.5 -7842.5 {}
L 4 732.5 -7847.5 747.5 -7852.5 {}
L 4 732.5 -7857.5 747.5 -7852.5 {}
L 4 732.5 -7857.5 747.5 -7862.5 {}
L 4 732.5 -7867.5 747.5 -7862.5 {}
L 4 732.5 -7867.5 740 -7870 {}
L 4 740 -7880 740 -7870 {}
L 4 742.5 -7872.5 747.5 -7872.5 {}
L 4 745 -7875 745 -7870 {}
L 4 830 -7755 830 -7730 {}
L 4 830 -7790 830 -7765 {}
L 4 820 -7765 840 -7765 {}
L 4 820 -7755 840 -7755 {}
L 4 832.5 -7782.5 837.5 -7782.5 {}
L 4 835 -7785 835 -7780 {}
L 4 502.5 -7722.5 507.5 -7722.5 {}
L 4 505 -7725 505 -7720 {}
L 4 500 -7730 500 -7670 {}
L 4 610 -7650 610 -7637.5 {}
L 4 605 -7637.5 615 -7637.5 {}
L 4 610 -7632.5 615 -7637.5 {}
L 4 605 -7637.5 610 -7632.5 {}
L 4 610 -7930 610 -7910 {}
L 4 600 -7930 620 -7930 {}
L 4 1265 -7790 1265 -7730 {}
L 4 1265 -7780 1280 -7780 {}
L 4 1280 -7790 1280 -7780 {}
L 4 1265 -7740 1280 -7740 {}
L 4 1280 -7740 1280 -7730 {}
L 4 1255 -7775 1255 -7745 {}
L 4 1255 -7760 1255 -7755 {}
L 4 1240 -7760 1247.5 -7760 {}
L 4 1240 -7760 1255 -7760 {}
L 4 1270 -7760 1280 -7760 {}
L 4 1265 -7765 1270 -7760 {}
L 4 1265 -7755 1270 -7760 {}
L 4 1370 -7755 1370 -7730 {}
L 4 1370 -7790 1370 -7765 {}
L 4 1360 -7765 1380 -7765 {}
L 4 1360 -7755 1380 -7755 {}
L 4 1372.5 -7782.5 1377.5 -7782.5 {}
L 4 1375 -7785 1375 -7780 {}
L 4 1042.5 -7722.5 1047.5 -7722.5 {}
L 4 1045 -7725 1045 -7720 {}
L 4 1040 -7730 1040 -7670 {}
L 4 1150 -7650 1150 -7637.5 {}
L 4 1145 -7637.5 1155 -7637.5 {}
L 4 1150 -7632.5 1155 -7637.5 {}
L 4 1145 -7637.5 1150 -7632.5 {}
L 4 1150 -7930 1150 -7910 {}
L 4 1140 -7930 1160 -7930 {}
L 4 725 -6960 725 -6900 {}
L 4 725 -6950 740 -6950 {}
L 4 740 -6960 740 -6950 {}
L 4 725 -6910 740 -6910 {}
L 4 740 -6910 740 -6900 {}
L 4 715 -6945 715 -6915 {}
L 4 715 -6930 715 -6925 {}
L 4 700 -6930 707.5 -6930 {}
L 4 700 -6930 715 -6930 {}
L 4 730 -6930 740 -6930 {}
L 4 725 -6935 730 -6930 {}
L 4 725 -6925 730 -6930 {}
L 4 740 -7000 740 -6990 {}
L 4 740 -7000 747.5 -7002.5 {}
L 4 732.5 -7007.5 747.5 -7002.5 {}
L 4 732.5 -7007.5 747.5 -7012.5 {}
L 4 732.5 -7017.5 747.5 -7012.5 {}
L 4 732.5 -7017.5 747.5 -7022.5 {}
L 4 732.5 -7027.5 747.5 -7022.5 {}
L 4 732.5 -7027.5 747.5 -7032.5 {}
L 4 732.5 -7037.5 747.5 -7032.5 {}
L 4 732.5 -7037.5 740 -7040 {}
L 4 740 -7050 740 -7040 {}
L 4 742.5 -7042.5 747.5 -7042.5 {}
L 4 745 -7045 745 -7040 {}
L 4 830 -6925 830 -6900 {}
L 4 830 -6960 830 -6935 {}
L 4 820 -6935 840 -6935 {}
L 4 820 -6925 840 -6925 {}
L 4 832.5 -6952.5 837.5 -6952.5 {}
L 4 835 -6955 835 -6950 {}
L 4 502.5 -6892.5 507.5 -6892.5 {}
L 4 505 -6895 505 -6890 {}
L 4 500 -6900 500 -6840 {}
L 4 610 -6820 610 -6807.5 {}
L 4 605 -6807.5 615 -6807.5 {}
L 4 610 -6802.5 615 -6807.5 {}
L 4 605 -6807.5 610 -6802.5 {}
L 4 610 -7100 610 -7080 {}
L 4 600 -7100 620 -7100 {}
L 4 1265 -6960 1265 -6900 {}
L 4 1265 -6950 1280 -6950 {}
L 4 1280 -6960 1280 -6950 {}
L 4 1265 -6910 1280 -6910 {}
L 4 1280 -6910 1280 -6900 {}
L 4 1255 -6945 1255 -6915 {}
L 4 1255 -6930 1255 -6925 {}
L 4 1240 -6930 1247.5 -6930 {}
L 4 1240 -6930 1255 -6930 {}
L 4 1270 -6930 1280 -6930 {}
L 4 1265 -6935 1270 -6930 {}
L 4 1265 -6925 1270 -6930 {}
L 4 1370 -6925 1370 -6900 {}
L 4 1370 -6960 1370 -6935 {}
L 4 1360 -6935 1380 -6935 {}
L 4 1360 -6925 1380 -6925 {}
L 4 1372.5 -6952.5 1377.5 -6952.5 {}
L 4 1375 -6955 1375 -6950 {}
L 4 1042.5 -6892.5 1047.5 -6892.5 {}
L 4 1045 -6895 1045 -6890 {}
L 4 1040 -6900 1040 -6840 {}
L 4 1150 -6820 1150 -6807.5 {}
L 4 1145 -6807.5 1155 -6807.5 {}
L 4 1150 -6802.5 1155 -6807.5 {}
L 4 1145 -6807.5 1150 -6802.5 {}
L 4 1150 -7100 1150 -7080 {}
L 4 1140 -7100 1160 -7100 {}
L 4 725 -6470 725 -6410 {}
L 4 725 -6460 740 -6460 {}
L 4 740 -6470 740 -6460 {}
L 4 725 -6420 740 -6420 {}
L 4 740 -6420 740 -6410 {}
L 4 715 -6455 715 -6425 {}
L 4 715 -6440 715 -6435 {}
L 4 700 -6440 707.5 -6440 {}
L 4 700 -6440 715 -6440 {}
L 4 730 -6440 740 -6440 {}
L 4 725 -6445 730 -6440 {}
L 4 725 -6435 730 -6440 {}
L 4 740 -6510 740 -6500 {}
L 4 740 -6510 747.5 -6512.5 {}
L 4 732.5 -6517.5 747.5 -6512.5 {}
L 4 732.5 -6517.5 747.5 -6522.5 {}
L 4 732.5 -6527.5 747.5 -6522.5 {}
L 4 732.5 -6527.5 747.5 -6532.5 {}
L 4 732.5 -6537.5 747.5 -6532.5 {}
L 4 732.5 -6537.5 747.5 -6542.5 {}
L 4 732.5 -6547.5 747.5 -6542.5 {}
L 4 732.5 -6547.5 740 -6550 {}
L 4 740 -6560 740 -6550 {}
L 4 742.5 -6552.5 747.5 -6552.5 {}
L 4 745 -6555 745 -6550 {}
L 4 830 -6435 830 -6410 {}
L 4 830 -6470 830 -6445 {}
L 4 820 -6445 840 -6445 {}
L 4 820 -6435 840 -6435 {}
L 4 832.5 -6462.5 837.5 -6462.5 {}
L 4 835 -6465 835 -6460 {}
L 4 502.5 -6402.5 507.5 -6402.5 {}
L 4 505 -6405 505 -6400 {}
L 4 500 -6410 500 -6350 {}
L 4 610 -6330 610 -6317.5 {}
L 4 605 -6317.5 615 -6317.5 {}
L 4 610 -6312.5 615 -6317.5 {}
L 4 605 -6317.5 610 -6312.5 {}
L 4 610 -6610 610 -6590 {}
L 4 600 -6610 620 -6610 {}
L 4 1265 -6470 1265 -6410 {}
L 4 1265 -6460 1280 -6460 {}
L 4 1280 -6470 1280 -6460 {}
L 4 1265 -6420 1280 -6420 {}
L 4 1280 -6420 1280 -6410 {}
L 4 1255 -6455 1255 -6425 {}
L 4 1255 -6440 1255 -6435 {}
L 4 1240 -6440 1247.5 -6440 {}
L 4 1240 -6440 1255 -6440 {}
L 4 1270 -6440 1280 -6440 {}
L 4 1265 -6445 1270 -6440 {}
L 4 1265 -6435 1270 -6440 {}
L 4 1370 -6435 1370 -6410 {}
L 4 1370 -6470 1370 -6445 {}
L 4 1360 -6445 1380 -6445 {}
L 4 1360 -6435 1380 -6435 {}
L 4 1372.5 -6462.5 1377.5 -6462.5 {}
L 4 1375 -6465 1375 -6460 {}
L 4 1042.5 -6402.5 1047.5 -6402.5 {}
L 4 1045 -6405 1045 -6400 {}
L 4 1040 -6410 1040 -6350 {}
L 4 1150 -6330 1150 -6317.5 {}
L 4 1145 -6317.5 1155 -6317.5 {}
L 4 1150 -6312.5 1155 -6317.5 {}
L 4 1145 -6317.5 1150 -6312.5 {}
L 4 1150 -6610 1150 -6590 {}
L 4 1140 -6610 1160 -6610 {}
L 4 502.5 -5912.5 507.5 -5912.5 {}
L 4 505 -5915 505 -5910 {}
L 4 500 -5920 500 -5860 {}
L 4 610 -5840 610 -5827.5 {}
L 4 605 -5827.5 615 -5827.5 {}
L 4 610 -5822.5 615 -5827.5 {}
L 4 605 -5827.5 610 -5822.5 {}
L 4 610 -6120 610 -6100 {}
L 4 600 -6120 620 -6120 {}
L 4 1692.5 -5912.5 1697.5 -5912.5 {}
L 4 1695 -5915 1695 -5910 {}
L 4 1690 -5920 1690 -5860 {}
L 4 1800 -5840 1800 -5827.5 {}
L 4 1795 -5827.5 1805 -5827.5 {}
L 4 1800 -5822.5 1805 -5827.5 {}
L 4 1795 -5827.5 1800 -5822.5 {}
L 4 1800 -6120 1800 -6100 {}
L 4 1790 -6120 1810 -6120 {}
L 4 1042.5 -5912.5 1047.5 -5912.5 {}
L 4 1045 -5915 1045 -5910 {}
L 4 1040 -5920 1040 -5860 {}
L 4 1150 -5840 1150 -5827.5 {}
L 4 1145 -5827.5 1155 -5827.5 {}
L 4 1150 -5822.5 1155 -5827.5 {}
L 4 1145 -5827.5 1150 -5822.5 {}
L 4 1150 -6120 1150 -6100 {}
L 4 1140 -6120 1160 -6120 {}
L 4 1032.5 -7352.5 1037.5 -7352.5 {}
L 4 1035 -7355 1035 -7350 {}
L 4 1030 -7360 1030 -7300 {}
L 4 1140 -7280 1140 -7267.5 {}
L 4 1135 -7267.5 1145 -7267.5 {}
L 4 1140 -7262.5 1145 -7267.5 {}
L 4 1135 -7267.5 1140 -7262.5 {}
L 4 1140 -7560 1140 -7540 {}
L 4 1130 -7560 1150 -7560 {}
L 4 502.5 -7352.5 507.5 -7352.5 {}
L 4 505 -7355 505 -7350 {}
L 4 500 -7360 500 -7300 {}
L 4 610 -7280 610 -7267.5 {}
L 4 605 -7267.5 615 -7267.5 {}
L 4 610 -7262.5 615 -7267.5 {}
L 4 605 -7267.5 610 -7262.5 {}
L 4 610 -7560 610 -7540 {}
L 4 600 -7560 620 -7560 {}
L 4 1755 -7420 1755 -7360 {}
L 4 1755 -7410 1770 -7410 {}
L 4 1770 -7420 1770 -7410 {}
L 4 1755 -7370 1770 -7370 {}
L 4 1770 -7370 1770 -7360 {}
L 4 1745 -7405 1745 -7375 {}
L 4 1745 -7390 1745 -7385 {}
L 4 1730 -7390 1737.5 -7390 {}
L 4 1730 -7390 1745 -7390 {}
L 4 1760 -7390 1770 -7390 {}
L 4 1755 -7395 1760 -7390 {}
L 4 1755 -7385 1760 -7390 {}
L 4 1770 -7460 1770 -7450 {}
L 4 1770 -7460 1777.5 -7462.5 {}
L 4 1762.5 -7467.5 1777.5 -7462.5 {}
L 4 1762.5 -7467.5 1777.5 -7472.5 {}
L 4 1762.5 -7477.5 1777.5 -7472.5 {}
L 4 1762.5 -7477.5 1777.5 -7482.5 {}
L 4 1762.5 -7487.5 1777.5 -7482.5 {}
L 4 1762.5 -7487.5 1777.5 -7492.5 {}
L 4 1762.5 -7497.5 1777.5 -7492.5 {}
L 4 1762.5 -7497.5 1770 -7500 {}
L 4 1770 -7510 1770 -7500 {}
L 4 1772.5 -7502.5 1777.5 -7502.5 {}
L 4 1775 -7505 1775 -7500 {}
L 4 1860 -7385 1860 -7360 {}
L 4 1860 -7420 1860 -7395 {}
L 4 1850 -7395 1870 -7395 {}
L 4 1850 -7385 1870 -7385 {}
L 4 1862.5 -7412.5 1867.5 -7412.5 {}
L 4 1865 -7415 1865 -7410 {}
L 4 1532.5 -7352.5 1537.5 -7352.5 {}
L 4 1535 -7355 1535 -7350 {}
L 4 1530 -7360 1530 -7300 {}
L 4 1640 -7280 1640 -7267.5 {}
L 4 1635 -7267.5 1645 -7267.5 {}
L 4 1640 -7262.5 1645 -7267.5 {}
L 4 1635 -7267.5 1640 -7262.5 {}
L 4 1640 -7560 1640 -7540 {}
L 4 1630 -7560 1650 -7560 {}
L 4 1680 -8580 1680 -8567.5 {}
L 4 1675 -8567.5 1685 -8567.5 {}
L 4 1680 -8562.5 1685 -8567.5 {}
L 4 1675 -8567.5 1680 -8562.5 {}
L 4 1680 -8860 1680 -8840 {}
L 4 1670 -8860 1690 -8860 {}
L 4 502.5 -8652.5 507.5 -8652.5 {}
L 4 505 -8655 505 -8650 {}
L 4 500 -8660 500 -8600 {}
L 4 610 -8580 610 -8567.5 {}
L 4 605 -8567.5 615 -8567.5 {}
L 4 610 -8562.5 615 -8567.5 {}
L 4 605 -8567.5 610 -8562.5 {}
L 4 610 -8860 610 -8840 {}
L 4 600 -8860 620 -8860 {}
L 4 2140 -8580 2140 -8567.5 {}
L 4 2135 -8567.5 2145 -8567.5 {}
L 4 2140 -8562.5 2145 -8567.5 {}
L 4 2135 -8567.5 2140 -8562.5 {}
L 4 2140 -8860 2140 -8840 {}
L 4 2130 -8860 2150 -8860 {}
L 4 2360 -8685 2360 -8660 {}
L 4 2360 -8720 2360 -8695 {}
L 4 2350 -8695 2370 -8695 {}
L 4 2350 -8685 2370 -8685 {}
L 4 2362.5 -8712.5 2367.5 -8712.5 {}
L 4 2365 -8715 2365 -8710 {}
L 4 745 -5540 745 -5480 {}
L 4 745 -5530 760 -5530 {}
L 4 760 -5540 760 -5530 {}
L 4 745 -5490 760 -5490 {}
L 4 760 -5490 760 -5480 {}
L 4 735 -5525 735 -5495 {}
L 4 735 -5510 735 -5505 {}
L 4 720 -5510 727.5 -5510 {}
L 4 720 -5510 735 -5510 {}
L 4 750 -5510 760 -5510 {}
L 4 745 -5515 750 -5510 {}
L 4 745 -5505 750 -5510 {}
L 4 760 -5580 760 -5570 {}
L 4 760 -5580 767.5 -5582.5 {}
L 4 752.5 -5587.5 767.5 -5582.5 {}
L 4 752.5 -5587.5 767.5 -5592.5 {}
L 4 752.5 -5597.5 767.5 -5592.5 {}
L 4 752.5 -5597.5 767.5 -5602.5 {}
L 4 752.5 -5607.5 767.5 -5602.5 {}
L 4 752.5 -5607.5 767.5 -5612.5 {}
L 4 752.5 -5617.5 767.5 -5612.5 {}
L 4 752.5 -5617.5 760 -5620 {}
L 4 760 -5630 760 -5620 {}
L 4 762.5 -5622.5 767.5 -5622.5 {}
L 4 765 -5625 765 -5620 {}
L 4 850 -5505 850 -5480 {}
L 4 850 -5540 850 -5515 {}
L 4 840 -5515 860 -5515 {}
L 4 840 -5505 860 -5505 {}
L 4 852.5 -5532.5 857.5 -5532.5 {}
L 4 855 -5535 855 -5530 {}
L 4 522.5 -5472.5 527.5 -5472.5 {}
L 4 525 -5475 525 -5470 {}
L 4 520 -5480 520 -5420 {}
L 4 630 -5400 630 -5387.5 {}
L 4 625 -5387.5 635 -5387.5 {}
L 4 630 -5382.5 635 -5387.5 {}
L 4 625 -5387.5 630 -5382.5 {}
L 4 630 -5680 630 -5660 {}
L 4 620 -5680 640 -5680 {}
L 4 1285 -5540 1285 -5480 {}
L 4 1285 -5530 1300 -5530 {}
L 4 1300 -5540 1300 -5530 {}
L 4 1285 -5490 1300 -5490 {}
L 4 1300 -5490 1300 -5480 {}
L 4 1275 -5525 1275 -5495 {}
L 4 1275 -5510 1275 -5505 {}
L 4 1260 -5510 1267.5 -5510 {}
L 4 1260 -5510 1275 -5510 {}
L 4 1290 -5510 1300 -5510 {}
L 4 1285 -5515 1290 -5510 {}
L 4 1285 -5505 1290 -5510 {}
L 4 1300 -5580 1300 -5570 {}
L 4 1300 -5580 1307.5 -5582.5 {}
L 4 1292.5 -5587.5 1307.5 -5582.5 {}
L 4 1292.5 -5587.5 1307.5 -5592.5 {}
L 4 1292.5 -5597.5 1307.5 -5592.5 {}
L 4 1292.5 -5597.5 1307.5 -5602.5 {}
L 4 1292.5 -5607.5 1307.5 -5602.5 {}
L 4 1292.5 -5607.5 1307.5 -5612.5 {}
L 4 1292.5 -5617.5 1307.5 -5612.5 {}
L 4 1292.5 -5617.5 1300 -5620 {}
L 4 1300 -5630 1300 -5620 {}
L 4 1302.5 -5622.5 1307.5 -5622.5 {}
L 4 1305 -5625 1305 -5620 {}
L 4 1390 -5505 1390 -5480 {}
L 4 1390 -5540 1390 -5515 {}
L 4 1380 -5515 1400 -5515 {}
L 4 1380 -5505 1400 -5505 {}
L 4 1392.5 -5532.5 1397.5 -5532.5 {}
L 4 1395 -5535 1395 -5530 {}
L 4 1062.5 -5472.5 1067.5 -5472.5 {}
L 4 1065 -5475 1065 -5470 {}
L 4 1060 -5480 1060 -5420 {}
L 4 1170 -5400 1170 -5387.5 {}
L 4 1165 -5387.5 1175 -5387.5 {}
L 4 1170 -5382.5 1175 -5387.5 {}
L 4 1165 -5387.5 1170 -5382.5 {}
L 4 1170 -5680 1170 -5660 {}
L 4 1160 -5680 1180 -5680 {}
L 4 1845 -5540 1845 -5480 {}
L 4 1845 -5530 1860 -5530 {}
L 4 1860 -5540 1860 -5530 {}
L 4 1845 -5490 1860 -5490 {}
L 4 1860 -5490 1860 -5480 {}
L 4 1835 -5525 1835 -5495 {}
L 4 1835 -5510 1835 -5505 {}
L 4 1820 -5510 1827.5 -5510 {}
L 4 1820 -5510 1835 -5510 {}
L 4 1850 -5510 1860 -5510 {}
L 4 1845 -5515 1850 -5510 {}
L 4 1845 -5505 1850 -5510 {}
L 4 1860 -5580 1860 -5570 {}
L 4 1860 -5580 1867.5 -5582.5 {}
L 4 1852.5 -5587.5 1867.5 -5582.5 {}
L 4 1852.5 -5587.5 1867.5 -5592.5 {}
L 4 1852.5 -5597.5 1867.5 -5592.5 {}
L 4 1852.5 -5597.5 1867.5 -5602.5 {}
L 4 1852.5 -5607.5 1867.5 -5602.5 {}
L 4 1852.5 -5607.5 1867.5 -5612.5 {}
L 4 1852.5 -5617.5 1867.5 -5612.5 {}
L 4 1852.5 -5617.5 1860 -5620 {}
L 4 1860 -5630 1860 -5620 {}
L 4 1862.5 -5622.5 1867.5 -5622.5 {}
L 4 1865 -5625 1865 -5620 {}
L 4 1950 -5505 1950 -5480 {}
L 4 1950 -5540 1950 -5515 {}
L 4 1940 -5515 1960 -5515 {}
L 4 1940 -5505 1960 -5505 {}
L 4 1952.5 -5532.5 1957.5 -5532.5 {}
L 4 1955 -5535 1955 -5530 {}
L 4 1622.5 -5472.5 1627.5 -5472.5 {}
L 4 1625 -5475 1625 -5470 {}
L 4 1620 -5480 1620 -5420 {}
L 4 1730 -5400 1730 -5387.5 {}
L 4 1725 -5387.5 1735 -5387.5 {}
L 4 1730 -5382.5 1735 -5387.5 {}
L 4 1725 -5387.5 1730 -5382.5 {}
L 4 1730 -5680 1730 -5660 {}
L 4 1720 -5680 1740 -5680 {}
L 4 2415 -5540 2415 -5480 {}
L 4 2415 -5530 2430 -5530 {}
L 4 2430 -5540 2430 -5530 {}
L 4 2415 -5490 2430 -5490 {}
L 4 2430 -5490 2430 -5480 {}
L 4 2405 -5525 2405 -5495 {}
L 4 2405 -5510 2405 -5505 {}
L 4 2390 -5510 2397.5 -5510 {}
L 4 2390 -5510 2405 -5510 {}
L 4 2420 -5510 2430 -5510 {}
L 4 2415 -5515 2420 -5510 {}
L 4 2415 -5505 2420 -5510 {}
L 4 2430 -5580 2430 -5570 {}
L 4 2430 -5580 2437.5 -5582.5 {}
L 4 2422.5 -5587.5 2437.5 -5582.5 {}
L 4 2422.5 -5587.5 2437.5 -5592.5 {}
L 4 2422.5 -5597.5 2437.5 -5592.5 {}
L 4 2422.5 -5597.5 2437.5 -5602.5 {}
L 4 2422.5 -5607.5 2437.5 -5602.5 {}
L 4 2422.5 -5607.5 2437.5 -5612.5 {}
L 4 2422.5 -5617.5 2437.5 -5612.5 {}
L 4 2422.5 -5617.5 2430 -5620 {}
L 4 2430 -5630 2430 -5620 {}
L 4 2432.5 -5622.5 2437.5 -5622.5 {}
L 4 2435 -5625 2435 -5620 {}
L 4 2520 -5505 2520 -5480 {}
L 4 2520 -5540 2520 -5515 {}
L 4 2510 -5515 2530 -5515 {}
L 4 2510 -5505 2530 -5505 {}
L 4 2522.5 -5532.5 2527.5 -5532.5 {}
L 4 2525 -5535 2525 -5530 {}
L 4 2192.5 -5472.5 2197.5 -5472.5 {}
L 4 2195 -5475 2195 -5470 {}
L 4 2190 -5480 2190 -5420 {}
L 4 2300 -5400 2300 -5387.5 {}
L 4 2295 -5387.5 2305 -5387.5 {}
L 4 2300 -5382.5 2305 -5387.5 {}
L 4 2295 -5387.5 2300 -5382.5 {}
L 4 2300 -5680 2300 -5660 {}
L 4 2290 -5680 2310 -5680 {}
L 4 745 -4740 745 -4680 {}
L 4 745 -4730 760 -4730 {}
L 4 760 -4740 760 -4730 {}
L 4 745 -4690 760 -4690 {}
L 4 760 -4690 760 -4680 {}
L 4 735 -4725 735 -4695 {}
L 4 735 -4710 735 -4705 {}
L 4 720 -4710 727.5 -4710 {}
L 4 720 -4710 735 -4710 {}
L 4 750 -4710 760 -4710 {}
L 4 745 -4715 750 -4710 {}
L 4 745 -4705 750 -4710 {}
L 4 760 -4780 760 -4770 {}
L 4 760 -4780 767.5 -4782.5 {}
L 4 752.5 -4787.5 767.5 -4782.5 {}
L 4 752.5 -4787.5 767.5 -4792.5 {}
L 4 752.5 -4797.5 767.5 -4792.5 {}
L 4 752.5 -4797.5 767.5 -4802.5 {}
L 4 752.5 -4807.5 767.5 -4802.5 {}
L 4 752.5 -4807.5 767.5 -4812.5 {}
L 4 752.5 -4817.5 767.5 -4812.5 {}
L 4 752.5 -4817.5 760 -4820 {}
L 4 760 -4830 760 -4820 {}
L 4 762.5 -4822.5 767.5 -4822.5 {}
L 4 765 -4825 765 -4820 {}
L 4 850 -4705 850 -4680 {}
L 4 850 -4740 850 -4715 {}
L 4 840 -4715 860 -4715 {}
L 4 840 -4705 860 -4705 {}
L 4 852.5 -4732.5 857.5 -4732.5 {}
L 4 855 -4735 855 -4730 {}
L 4 522.5 -4672.5 527.5 -4672.5 {}
L 4 525 -4675 525 -4670 {}
L 4 520 -4680 520 -4620 {}
L 4 630 -4600 630 -4587.5 {}
L 4 625 -4587.5 635 -4587.5 {}
L 4 630 -4582.5 635 -4587.5 {}
L 4 625 -4587.5 630 -4582.5 {}
L 4 630 -4880 630 -4860 {}
L 4 620 -4880 640 -4880 {}
L 4 1285 -4740 1285 -4680 {}
L 4 1285 -4730 1300 -4730 {}
L 4 1300 -4740 1300 -4730 {}
L 4 1285 -4690 1300 -4690 {}
L 4 1300 -4690 1300 -4680 {}
L 4 1275 -4725 1275 -4695 {}
L 4 1275 -4710 1275 -4705 {}
L 4 1260 -4710 1267.5 -4710 {}
L 4 1260 -4710 1275 -4710 {}
L 4 1290 -4710 1300 -4710 {}
L 4 1285 -4715 1290 -4710 {}
L 4 1285 -4705 1290 -4710 {}
L 4 1300 -4780 1300 -4770 {}
L 4 1300 -4780 1307.5 -4782.5 {}
L 4 1292.5 -4787.5 1307.5 -4782.5 {}
L 4 1292.5 -4787.5 1307.5 -4792.5 {}
L 4 1292.5 -4797.5 1307.5 -4792.5 {}
L 4 1292.5 -4797.5 1307.5 -4802.5 {}
L 4 1292.5 -4807.5 1307.5 -4802.5 {}
L 4 1292.5 -4807.5 1307.5 -4812.5 {}
L 4 1292.5 -4817.5 1307.5 -4812.5 {}
L 4 1292.5 -4817.5 1300 -4820 {}
L 4 1300 -4830 1300 -4820 {}
L 4 1302.5 -4822.5 1307.5 -4822.5 {}
L 4 1305 -4825 1305 -4820 {}
L 4 1390 -4705 1390 -4680 {}
L 4 1390 -4740 1390 -4715 {}
L 4 1380 -4715 1400 -4715 {}
L 4 1380 -4705 1400 -4705 {}
L 4 1392.5 -4732.5 1397.5 -4732.5 {}
L 4 1395 -4735 1395 -4730 {}
L 4 1062.5 -4672.5 1067.5 -4672.5 {}
L 4 1065 -4675 1065 -4670 {}
L 4 1060 -4680 1060 -4620 {}
L 4 1170 -4600 1170 -4587.5 {}
L 4 1165 -4587.5 1175 -4587.5 {}
L 4 1170 -4582.5 1175 -4587.5 {}
L 4 1165 -4587.5 1170 -4582.5 {}
L 4 1170 -4880 1170 -4860 {}
L 4 1160 -4880 1180 -4880 {}
L 4 2415 -4740 2415 -4680 {}
L 4 2415 -4730 2430 -4730 {}
L 4 2430 -4740 2430 -4730 {}
L 4 2415 -4690 2430 -4690 {}
L 4 2430 -4690 2430 -4680 {}
L 4 2405 -4725 2405 -4695 {}
L 4 2405 -4710 2405 -4705 {}
L 4 2390 -4710 2397.5 -4710 {}
L 4 2390 -4710 2405 -4710 {}
L 4 2420 -4710 2430 -4710 {}
L 4 2415 -4715 2420 -4710 {}
L 4 2415 -4705 2420 -4710 {}
L 4 2430 -4780 2430 -4770 {}
L 4 2430 -4780 2437.5 -4782.5 {}
L 4 2422.5 -4787.5 2437.5 -4782.5 {}
L 4 2422.5 -4787.5 2437.5 -4792.5 {}
L 4 2422.5 -4797.5 2437.5 -4792.5 {}
L 4 2422.5 -4797.5 2437.5 -4802.5 {}
L 4 2422.5 -4807.5 2437.5 -4802.5 {}
L 4 2422.5 -4807.5 2437.5 -4812.5 {}
L 4 2422.5 -4817.5 2437.5 -4812.5 {}
L 4 2422.5 -4817.5 2430 -4820 {}
L 4 2430 -4830 2430 -4820 {}
L 4 2432.5 -4822.5 2437.5 -4822.5 {}
L 4 2435 -4825 2435 -4820 {}
L 4 2520 -4705 2520 -4680 {}
L 4 2520 -4740 2520 -4715 {}
L 4 2510 -4715 2530 -4715 {}
L 4 2510 -4705 2530 -4705 {}
L 4 2522.5 -4732.5 2527.5 -4732.5 {}
L 4 2525 -4735 2525 -4730 {}
L 4 2192.5 -4672.5 2197.5 -4672.5 {}
L 4 2195 -4675 2195 -4670 {}
L 4 2190 -4680 2190 -4620 {}
L 4 2300 -4600 2300 -4587.5 {}
L 4 2295 -4587.5 2305 -4587.5 {}
L 4 2300 -4582.5 2305 -4587.5 {}
L 4 2295 -4587.5 2300 -4582.5 {}
L 4 2300 -4880 2300 -4860 {}
L 4 2290 -4880 2310 -4880 {}
L 4 745 -5160 745 -5100 {}
L 4 745 -5150 760 -5150 {}
L 4 760 -5160 760 -5150 {}
L 4 745 -5110 760 -5110 {}
L 4 760 -5110 760 -5100 {}
L 4 735 -5145 735 -5115 {}
L 4 735 -5130 735 -5125 {}
L 4 720 -5130 727.5 -5130 {}
L 4 720 -5130 735 -5130 {}
L 4 750 -5130 760 -5130 {}
L 4 745 -5135 750 -5130 {}
L 4 745 -5125 750 -5130 {}
L 4 760 -5200 760 -5190 {}
L 4 760 -5200 767.5 -5202.5 {}
L 4 752.5 -5207.5 767.5 -5202.5 {}
L 4 752.5 -5207.5 767.5 -5212.5 {}
L 4 752.5 -5217.5 767.5 -5212.5 {}
L 4 752.5 -5217.5 767.5 -5222.5 {}
L 4 752.5 -5227.5 767.5 -5222.5 {}
L 4 752.5 -5227.5 767.5 -5232.5 {}
L 4 752.5 -5237.5 767.5 -5232.5 {}
L 4 752.5 -5237.5 760 -5240 {}
L 4 760 -5250 760 -5240 {}
L 4 762.5 -5242.5 767.5 -5242.5 {}
L 4 765 -5245 765 -5240 {}
L 4 850 -5125 850 -5100 {}
L 4 850 -5160 850 -5135 {}
L 4 840 -5135 860 -5135 {}
L 4 840 -5125 860 -5125 {}
L 4 852.5 -5152.5 857.5 -5152.5 {}
L 4 855 -5155 855 -5150 {}
L 4 522.5 -5092.5 527.5 -5092.5 {}
L 4 525 -5095 525 -5090 {}
L 4 520 -5100 520 -5040 {}
L 4 630 -5020 630 -5007.5 {}
L 4 625 -5007.5 635 -5007.5 {}
L 4 630 -5002.5 635 -5007.5 {}
L 4 625 -5007.5 630 -5002.5 {}
L 4 630 -5300 630 -5280 {}
L 4 620 -5300 640 -5300 {}
L 4 745 -4330 745 -4270 {}
L 4 745 -4320 760 -4320 {}
L 4 760 -4330 760 -4320 {}
L 4 745 -4280 760 -4280 {}
L 4 760 -4280 760 -4270 {}
L 4 735 -4315 735 -4285 {}
L 4 735 -4300 735 -4295 {}
L 4 720 -4300 727.5 -4300 {}
L 4 720 -4300 735 -4300 {}
L 4 750 -4300 760 -4300 {}
L 4 745 -4305 750 -4300 {}
L 4 745 -4295 750 -4300 {}
L 4 850 -4295 850 -4270 {}
L 4 850 -4330 850 -4305 {}
L 4 840 -4305 860 -4305 {}
L 4 840 -4295 860 -4295 {}
L 4 852.5 -4322.5 857.5 -4322.5 {}
L 4 855 -4325 855 -4320 {}
L 4 522.5 -4262.5 527.5 -4262.5 {}
L 4 525 -4265 525 -4260 {}
L 4 520 -4270 520 -4210 {}
L 4 630 -4190 630 -4177.5 {}
L 4 625 -4177.5 635 -4177.5 {}
L 4 630 -4172.5 635 -4177.5 {}
L 4 625 -4177.5 630 -4172.5 {}
L 4 1845 -4330 1845 -4270 {}
L 4 1845 -4320 1860 -4320 {}
L 4 1860 -4330 1860 -4320 {}
L 4 1845 -4280 1860 -4280 {}
L 4 1860 -4280 1860 -4270 {}
L 4 1835 -4315 1835 -4285 {}
L 4 1835 -4300 1835 -4295 {}
L 4 1820 -4300 1827.5 -4300 {}
L 4 1820 -4300 1835 -4300 {}
L 4 1850 -4300 1860 -4300 {}
L 4 1845 -4305 1850 -4300 {}
L 4 1845 -4295 1850 -4300 {}
L 4 1950 -4295 1950 -4270 {}
L 4 1950 -4330 1950 -4305 {}
L 4 1940 -4305 1960 -4305 {}
L 4 1940 -4295 1960 -4295 {}
L 4 1952.5 -4322.5 1957.5 -4322.5 {}
L 4 1955 -4325 1955 -4320 {}
L 4 1622.5 -4262.5 1627.5 -4262.5 {}
L 4 1625 -4265 1625 -4260 {}
L 4 1620 -4270 1620 -4210 {}
L 4 1730 -4190 1730 -4177.5 {}
L 4 1725 -4177.5 1735 -4177.5 {}
L 4 1730 -4172.5 1735 -4177.5 {}
L 4 1725 -4177.5 1730 -4172.5 {}
L 4 1285 -4330 1285 -4270 {}
L 4 1285 -4320 1300 -4320 {}
L 4 1300 -4330 1300 -4320 {}
L 4 1285 -4280 1300 -4280 {}
L 4 1300 -4280 1300 -4270 {}
L 4 1275 -4315 1275 -4285 {}
L 4 1275 -4300 1275 -4295 {}
L 4 1260 -4300 1267.5 -4300 {}
L 4 1260 -4300 1275 -4300 {}
L 4 1290 -4300 1300 -4300 {}
L 4 1285 -4305 1290 -4300 {}
L 4 1285 -4295 1290 -4300 {}
L 4 1390 -4295 1390 -4270 {}
L 4 1390 -4330 1390 -4305 {}
L 4 1380 -4305 1400 -4305 {}
L 4 1380 -4295 1400 -4295 {}
L 4 1392.5 -4322.5 1397.5 -4322.5 {}
L 4 1395 -4325 1395 -4320 {}
L 4 1062.5 -4262.5 1067.5 -4262.5 {}
L 4 1065 -4265 1065 -4260 {}
L 4 1060 -4270 1060 -4210 {}
L 4 1170 -4190 1170 -4177.5 {}
L 4 1165 -4177.5 1175 -4177.5 {}
L 4 1170 -4172.5 1175 -4177.5 {}
L 4 1165 -4177.5 1170 -4172.5 {}
L 4 820 -3510 820 -3500 {}
L 4 820 -3510 827.5 -3512.5 {}
L 4 812.5 -3517.5 827.5 -3512.5 {}
L 4 812.5 -3517.5 827.5 -3522.5 {}
L 4 812.5 -3527.5 827.5 -3522.5 {}
L 4 812.5 -3527.5 827.5 -3532.5 {}
L 4 812.5 -3537.5 827.5 -3532.5 {}
L 4 812.5 -3537.5 827.5 -3542.5 {}
L 4 812.5 -3547.5 827.5 -3542.5 {}
L 4 812.5 -3547.5 820 -3550 {}
L 4 820 -3560 820 -3550 {}
L 4 822.5 -3552.5 827.5 -3552.5 {}
L 4 825 -3555 825 -3550 {}
L 4 820 -3450 820 -3440 {}
L 4 820 -3450 827.5 -3452.5 {}
L 4 812.5 -3457.5 827.5 -3452.5 {}
L 4 812.5 -3457.5 827.5 -3462.5 {}
L 4 812.5 -3467.5 827.5 -3462.5 {}
L 4 812.5 -3467.5 827.5 -3472.5 {}
L 4 812.5 -3477.5 827.5 -3472.5 {}
L 4 812.5 -3477.5 827.5 -3482.5 {}
L 4 812.5 -3487.5 827.5 -3482.5 {}
L 4 812.5 -3487.5 820 -3490 {}
L 4 820 -3500 820 -3490 {}
L 4 822.5 -3492.5 827.5 -3492.5 {}
L 4 825 -3495 825 -3490 {}
L 4 1360 -3450 1360 -3440 {}
L 4 1360 -3450 1367.5 -3452.5 {}
L 4 1352.5 -3457.5 1367.5 -3452.5 {}
L 4 1352.5 -3457.5 1367.5 -3462.5 {}
L 4 1352.5 -3467.5 1367.5 -3462.5 {}
L 4 1352.5 -3467.5 1367.5 -3472.5 {}
L 4 1352.5 -3477.5 1367.5 -3472.5 {}
L 4 1352.5 -3477.5 1367.5 -3482.5 {}
L 4 1352.5 -3487.5 1367.5 -3482.5 {}
L 4 1352.5 -3487.5 1360 -3490 {}
L 4 1360 -3500 1360 -3490 {}
L 4 1362.5 -3492.5 1367.5 -3492.5 {}
L 4 1365 -3495 1365 -3490 {}
L 4 1900 -3550 1900 -3540 {}
L 4 1900 -3550 1907.5 -3552.5 {}
L 4 1892.5 -3557.5 1907.5 -3552.5 {}
L 4 1892.5 -3557.5 1907.5 -3562.5 {}
L 4 1892.5 -3567.5 1907.5 -3562.5 {}
L 4 1892.5 -3567.5 1907.5 -3572.5 {}
L 4 1892.5 -3577.5 1907.5 -3572.5 {}
L 4 1892.5 -3577.5 1907.5 -3582.5 {}
L 4 1892.5 -3587.5 1907.5 -3582.5 {}
L 4 1892.5 -3587.5 1900 -3590 {}
L 4 1900 -3600 1900 -3590 {}
L 4 1902.5 -3592.5 1907.5 -3592.5 {}
L 4 1905 -3595 1905 -3590 {}
L 4 1900 -3450 1900 -3440 {}
L 4 1900 -3450 1907.5 -3452.5 {}
L 4 1892.5 -3457.5 1907.5 -3452.5 {}
L 4 1892.5 -3457.5 1907.5 -3462.5 {}
L 4 1892.5 -3467.5 1907.5 -3462.5 {}
L 4 1892.5 -3467.5 1907.5 -3472.5 {}
L 4 1892.5 -3477.5 1907.5 -3472.5 {}
L 4 1892.5 -3477.5 1907.5 -3482.5 {}
L 4 1892.5 -3487.5 1907.5 -3482.5 {}
L 4 1892.5 -3487.5 1900 -3490 {}
L 4 1900 -3500 1900 -3490 {}
L 4 1902.5 -3492.5 1907.5 -3492.5 {}
L 4 1905 -3495 1905 -3490 {}
L 4 820 -3830 820 -3820 {}
L 4 820 -3830 827.5 -3832.5 {}
L 4 812.5 -3837.5 827.5 -3832.5 {}
L 4 812.5 -3837.5 827.5 -3842.5 {}
L 4 812.5 -3847.5 827.5 -3842.5 {}
L 4 812.5 -3847.5 827.5 -3852.5 {}
L 4 812.5 -3857.5 827.5 -3852.5 {}
L 4 812.5 -3857.5 827.5 -3862.5 {}
L 4 812.5 -3867.5 827.5 -3862.5 {}
L 4 812.5 -3867.5 820 -3870 {}
L 4 820 -3880 820 -3870 {}
L 4 822.5 -3872.5 827.5 -3872.5 {}
L 4 825 -3875 825 -3870 {}
L 4 820 -3890 820 -3880 {}
L 4 820 -3890 827.5 -3892.5 {}
L 4 812.5 -3897.5 827.5 -3892.5 {}
L 4 812.5 -3897.5 827.5 -3902.5 {}
L 4 812.5 -3907.5 827.5 -3902.5 {}
L 4 812.5 -3907.5 827.5 -3912.5 {}
L 4 812.5 -3917.5 827.5 -3912.5 {}
L 4 812.5 -3917.5 827.5 -3922.5 {}
L 4 812.5 -3927.5 827.5 -3922.5 {}
L 4 812.5 -3927.5 820 -3930 {}
L 4 820 -3940 820 -3930 {}
L 4 822.5 -3932.5 827.5 -3932.5 {}
L 4 825 -3935 825 -3930 {}
L 4 820 -3950 820 -3940 {}
L 4 820 -3950 827.5 -3952.5 {}
L 4 812.5 -3957.5 827.5 -3952.5 {}
L 4 812.5 -3957.5 827.5 -3962.5 {}
L 4 812.5 -3967.5 827.5 -3962.5 {}
L 4 812.5 -3967.5 827.5 -3972.5 {}
L 4 812.5 -3977.5 827.5 -3972.5 {}
L 4 812.5 -3977.5 827.5 -3982.5 {}
L 4 812.5 -3987.5 827.5 -3982.5 {}
L 4 812.5 -3987.5 820 -3990 {}
L 4 820 -4000 820 -3990 {}
L 4 822.5 -3992.5 827.5 -3992.5 {}
L 4 825 -3995 825 -3990 {}
L 4 1360 -3830 1360 -3820 {}
L 4 1360 -3830 1367.5 -3832.5 {}
L 4 1352.5 -3837.5 1367.5 -3832.5 {}
L 4 1352.5 -3837.5 1367.5 -3842.5 {}
L 4 1352.5 -3847.5 1367.5 -3842.5 {}
L 4 1352.5 -3847.5 1367.5 -3852.5 {}
L 4 1352.5 -3857.5 1367.5 -3852.5 {}
L 4 1352.5 -3857.5 1367.5 -3862.5 {}
L 4 1352.5 -3867.5 1367.5 -3862.5 {}
L 4 1352.5 -3867.5 1360 -3870 {}
L 4 1360 -3880 1360 -3870 {}
L 4 1362.5 -3872.5 1367.5 -3872.5 {}
L 4 1365 -3875 1365 -3870 {}
L 4 1360 -3950 1367.5 -3952.5 {}
L 4 1352.5 -3957.5 1367.5 -3952.5 {}
L 4 1352.5 -3957.5 1367.5 -3962.5 {}
L 4 1352.5 -3967.5 1367.5 -3962.5 {}
L 4 1352.5 -3967.5 1367.5 -3972.5 {}
L 4 1352.5 -3977.5 1367.5 -3972.5 {}
L 4 1352.5 -3977.5 1367.5 -3982.5 {}
L 4 1352.5 -3987.5 1367.5 -3982.5 {}
L 4 1352.5 -3987.5 1360 -3990 {}
L 4 1360 -4000 1360 -3990 {}
L 4 1362.5 -3992.5 1367.5 -3992.5 {}
L 4 1365 -3995 1365 -3990 {}
L 4 1900 -3830 1900 -3820 {}
L 4 1900 -3830 1907.5 -3832.5 {}
L 4 1892.5 -3837.5 1907.5 -3832.5 {}
L 4 1892.5 -3837.5 1907.5 -3842.5 {}
L 4 1892.5 -3847.5 1907.5 -3842.5 {}
L 4 1892.5 -3847.5 1907.5 -3852.5 {}
L 4 1892.5 -3857.5 1907.5 -3852.5 {}
L 4 1892.5 -3857.5 1907.5 -3862.5 {}
L 4 1892.5 -3867.5 1907.5 -3862.5 {}
L 4 1892.5 -3867.5 1900 -3870 {}
L 4 1900 -3880 1900 -3870 {}
L 4 1902.5 -3872.5 1907.5 -3872.5 {}
L 4 1905 -3875 1905 -3870 {}
L 4 1900 -3950 1900 -3940 {}
L 4 1900 -3950 1907.5 -3952.5 {}
L 4 1892.5 -3957.5 1907.5 -3952.5 {}
L 4 1892.5 -3957.5 1907.5 -3962.5 {}
L 4 1892.5 -3967.5 1907.5 -3962.5 {}
L 4 1892.5 -3967.5 1907.5 -3972.5 {}
L 4 1892.5 -3977.5 1907.5 -3972.5 {}
L 4 1892.5 -3977.5 1907.5 -3982.5 {}
L 4 1892.5 -3987.5 1907.5 -3982.5 {}
L 4 1892.5 -3987.5 1900 -3990 {}
L 4 1900 -4000 1900 -3990 {}
L 4 1902.5 -3992.5 1907.5 -3992.5 {}
L 4 1905 -3995 1905 -3990 {}
L 4 710 -2680 710 -2670 {}
L 4 710 -2680 717.5 -2682.5 {}
L 4 702.5 -2687.5 717.5 -2682.5 {}
L 4 702.5 -2687.5 717.5 -2692.5 {}
L 4 702.5 -2697.5 717.5 -2692.5 {}
L 4 702.5 -2697.5 717.5 -2702.5 {}
L 4 702.5 -2707.5 717.5 -2702.5 {}
L 4 702.5 -2707.5 717.5 -2712.5 {}
L 4 702.5 -2717.5 717.5 -2712.5 {}
L 4 702.5 -2717.5 710 -2720 {}
L 4 710 -2730 710 -2720 {}
L 4 712.5 -2722.5 717.5 -2722.5 {}
L 4 715 -2725 715 -2720 {}
L 4 820 -2680 820 -2670 {}
L 4 820 -2680 827.5 -2682.5 {}
L 4 812.5 -2687.5 827.5 -2682.5 {}
L 4 812.5 -2687.5 827.5 -2692.5 {}
L 4 812.5 -2697.5 827.5 -2692.5 {}
L 4 812.5 -2697.5 827.5 -2702.5 {}
L 4 812.5 -2707.5 827.5 -2702.5 {}
L 4 812.5 -2707.5 827.5 -2712.5 {}
L 4 812.5 -2717.5 827.5 -2712.5 {}
L 4 812.5 -2717.5 820 -2720 {}
L 4 820 -2730 820 -2720 {}
L 4 822.5 -2722.5 827.5 -2722.5 {}
L 4 825 -2725 825 -2720 {}
L 4 930 -2680 930 -2670 {}
L 4 930 -2680 937.5 -2682.5 {}
L 4 922.5 -2687.5 937.5 -2682.5 {}
L 4 922.5 -2687.5 937.5 -2692.5 {}
L 4 922.5 -2697.5 937.5 -2692.5 {}
L 4 922.5 -2697.5 937.5 -2702.5 {}
L 4 922.5 -2707.5 937.5 -2702.5 {}
L 4 922.5 -2707.5 937.5 -2712.5 {}
L 4 922.5 -2717.5 937.5 -2712.5 {}
L 4 922.5 -2717.5 930 -2720 {}
L 4 930 -2730 930 -2720 {}
L 4 932.5 -2722.5 937.5 -2722.5 {}
L 4 935 -2725 935 -2720 {}
L 4 1250 -2680 1250 -2670 {}
L 4 1250 -2680 1257.5 -2682.5 {}
L 4 1242.5 -2687.5 1257.5 -2682.5 {}
L 4 1242.5 -2687.5 1257.5 -2692.5 {}
L 4 1242.5 -2697.5 1257.5 -2692.5 {}
L 4 1242.5 -2697.5 1257.5 -2702.5 {}
L 4 1242.5 -2707.5 1257.5 -2702.5 {}
L 4 1242.5 -2707.5 1257.5 -2712.5 {}
L 4 1242.5 -2717.5 1257.5 -2712.5 {}
L 4 1242.5 -2717.5 1250 -2720 {}
L 4 1250 -2730 1250 -2720 {}
L 4 1252.5 -2722.5 1257.5 -2722.5 {}
L 4 1255 -2725 1255 -2720 {}
L 4 1360 -2680 1360 -2670 {}
L 4 1360 -2680 1367.5 -2682.5 {}
L 4 1352.5 -2687.5 1367.5 -2682.5 {}
L 4 1352.5 -2687.5 1367.5 -2692.5 {}
L 4 1352.5 -2697.5 1367.5 -2692.5 {}
L 4 1352.5 -2697.5 1367.5 -2702.5 {}
L 4 1352.5 -2707.5 1367.5 -2702.5 {}
L 4 1352.5 -2707.5 1367.5 -2712.5 {}
L 4 1352.5 -2717.5 1367.5 -2712.5 {}
L 4 1352.5 -2717.5 1360 -2720 {}
L 4 1360 -2730 1360 -2720 {}
L 4 1362.5 -2722.5 1367.5 -2722.5 {}
L 4 1365 -2725 1365 -2720 {}
L 4 1470 -2680 1470 -2670 {}
L 4 1470 -2680 1477.5 -2682.5 {}
L 4 1462.5 -2687.5 1477.5 -2682.5 {}
L 4 1462.5 -2687.5 1477.5 -2692.5 {}
L 4 1462.5 -2697.5 1477.5 -2692.5 {}
L 4 1462.5 -2697.5 1477.5 -2702.5 {}
L 4 1462.5 -2707.5 1477.5 -2702.5 {}
L 4 1462.5 -2707.5 1477.5 -2712.5 {}
L 4 1462.5 -2717.5 1477.5 -2712.5 {}
L 4 1462.5 -2717.5 1470 -2720 {}
L 4 1470 -2730 1470 -2720 {}
L 4 1472.5 -2722.5 1477.5 -2722.5 {}
L 4 1475 -2725 1475 -2720 {}
L 4 1790 -2680 1790 -2670 {}
L 4 1790 -2680 1797.5 -2682.5 {}
L 4 1782.5 -2687.5 1797.5 -2682.5 {}
L 4 1782.5 -2687.5 1797.5 -2692.5 {}
L 4 1782.5 -2697.5 1797.5 -2692.5 {}
L 4 1782.5 -2697.5 1797.5 -2702.5 {}
L 4 1782.5 -2707.5 1797.5 -2702.5 {}
L 4 1782.5 -2707.5 1797.5 -2712.5 {}
L 4 1782.5 -2717.5 1797.5 -2712.5 {}
L 4 1782.5 -2717.5 1790 -2720 {}
L 4 1790 -2730 1790 -2720 {}
L 4 1792.5 -2722.5 1797.5 -2722.5 {}
L 4 1795 -2725 1795 -2720 {}
L 4 1900 -2680 1900 -2670 {}
L 4 1900 -2680 1907.5 -2682.5 {}
L 4 1892.5 -2687.5 1907.5 -2682.5 {}
L 4 1892.5 -2687.5 1907.5 -2692.5 {}
L 4 1892.5 -2697.5 1907.5 -2692.5 {}
L 4 1892.5 -2697.5 1907.5 -2702.5 {}
L 4 1892.5 -2707.5 1907.5 -2702.5 {}
L 4 1892.5 -2707.5 1907.5 -2712.5 {}
L 4 1892.5 -2717.5 1907.5 -2712.5 {}
L 4 1892.5 -2717.5 1900 -2720 {}
L 4 1900 -2730 1900 -2720 {}
L 4 1902.5 -2722.5 1907.5 -2722.5 {}
L 4 1905 -2725 1905 -2720 {}
L 4 2010 -2680 2010 -2670 {}
L 4 2010 -2680 2017.5 -2682.5 {}
L 4 2002.5 -2687.5 2017.5 -2682.5 {}
L 4 2002.5 -2687.5 2017.5 -2692.5 {}
L 4 2002.5 -2697.5 2017.5 -2692.5 {}
L 4 2002.5 -2697.5 2017.5 -2702.5 {}
L 4 2002.5 -2707.5 2017.5 -2702.5 {}
L 4 2002.5 -2707.5 2017.5 -2712.5 {}
L 4 2002.5 -2717.5 2017.5 -2712.5 {}
L 4 2002.5 -2717.5 2010 -2720 {}
L 4 2010 -2730 2010 -2720 {}
L 4 2012.5 -2722.5 2017.5 -2722.5 {}
L 4 2015 -2725 2015 -2720 {}
L 4 2320 -2680 2320 -2670 {}
L 4 2320 -2680 2327.5 -2682.5 {}
L 4 2312.5 -2687.5 2327.5 -2682.5 {}
L 4 2312.5 -2687.5 2327.5 -2692.5 {}
L 4 2312.5 -2697.5 2327.5 -2692.5 {}
L 4 2312.5 -2697.5 2327.5 -2702.5 {}
L 4 2312.5 -2707.5 2327.5 -2702.5 {}
L 4 2312.5 -2707.5 2327.5 -2712.5 {}
L 4 2312.5 -2717.5 2327.5 -2712.5 {}
L 4 2312.5 -2717.5 2320 -2720 {}
L 4 2320 -2730 2320 -2720 {}
L 4 2322.5 -2722.5 2327.5 -2722.5 {}
L 4 2325 -2725 2325 -2720 {}
L 4 2430 -2680 2430 -2670 {}
L 4 2430 -2680 2437.5 -2682.5 {}
L 4 2422.5 -2687.5 2437.5 -2682.5 {}
L 4 2422.5 -2687.5 2437.5 -2692.5 {}
L 4 2422.5 -2697.5 2437.5 -2692.5 {}
L 4 2422.5 -2697.5 2437.5 -2702.5 {}
L 4 2422.5 -2707.5 2437.5 -2702.5 {}
L 4 2422.5 -2707.5 2437.5 -2712.5 {}
L 4 2422.5 -2717.5 2437.5 -2712.5 {}
L 4 2422.5 -2717.5 2430 -2720 {}
L 4 2430 -2730 2430 -2720 {}
L 4 2432.5 -2722.5 2437.5 -2722.5 {}
L 4 2435 -2725 2435 -2720 {}
L 4 2540 -2680 2540 -2670 {}
L 4 2540 -2680 2547.5 -2682.5 {}
L 4 2532.5 -2687.5 2547.5 -2682.5 {}
L 4 2532.5 -2687.5 2547.5 -2692.5 {}
L 4 2532.5 -2697.5 2547.5 -2692.5 {}
L 4 2532.5 -2697.5 2547.5 -2702.5 {}
L 4 2532.5 -2707.5 2547.5 -2702.5 {}
L 4 2532.5 -2707.5 2547.5 -2712.5 {}
L 4 2532.5 -2717.5 2547.5 -2712.5 {}
L 4 2532.5 -2717.5 2540 -2720 {}
L 4 2540 -2730 2540 -2720 {}
L 4 2542.5 -2722.5 2547.5 -2722.5 {}
L 4 2545 -2725 2545 -2720 {}
L 4 2500 -3830 2500 -3820 {}
L 4 2500 -3830 2507.5 -3832.5 {}
L 4 2492.5 -3837.5 2507.5 -3832.5 {}
L 4 2492.5 -3837.5 2507.5 -3842.5 {}
L 4 2492.5 -3847.5 2507.5 -3842.5 {}
L 4 2492.5 -3847.5 2507.5 -3852.5 {}
L 4 2492.5 -3857.5 2507.5 -3852.5 {}
L 4 2492.5 -3857.5 2507.5 -3862.5 {}
L 4 2492.5 -3867.5 2507.5 -3862.5 {}
L 4 2492.5 -3867.5 2500 -3870 {}
L 4 2500 -3880 2500 -3870 {}
L 4 2502.5 -3872.5 2507.5 -3872.5 {}
L 4 2505 -3875 2505 -3870 {}
L 4 2500 -3950 2500 -3940 {}
L 4 2500 -3950 2507.5 -3952.5 {}
L 4 2492.5 -3957.5 2507.5 -3952.5 {}
L 4 2492.5 -3957.5 2507.5 -3962.5 {}
L 4 2492.5 -3967.5 2507.5 -3962.5 {}
L 4 2492.5 -3967.5 2507.5 -3972.5 {}
L 4 2492.5 -3977.5 2507.5 -3972.5 {}
L 4 2492.5 -3977.5 2507.5 -3982.5 {}
L 4 2492.5 -3987.5 2507.5 -3982.5 {}
L 4 2492.5 -3987.5 2500 -3990 {}
L 4 2500 -4000 2500 -3990 {}
L 4 2502.5 -3992.5 2507.5 -3992.5 {}
L 4 2505 -3995 2505 -3990 {}
L 4 710 -750 710 -740 {}
L 4 710 -750 717.5 -752.5 {}
L 4 702.5 -757.5 717.5 -752.5 {}
L 4 702.5 -757.5 717.5 -762.5 {}
L 4 702.5 -767.5 717.5 -762.5 {}
L 4 702.5 -767.5 717.5 -772.5 {}
L 4 702.5 -777.5 717.5 -772.5 {}
L 4 702.5 -777.5 717.5 -782.5 {}
L 4 702.5 -787.5 717.5 -782.5 {}
L 4 702.5 -787.5 710 -790 {}
L 4 710 -800 710 -790 {}
L 4 712.5 -792.5 717.5 -792.5 {}
L 4 715 -795 715 -790 {}
L 4 820 -750 820 -740 {}
L 4 820 -750 827.5 -752.5 {}
L 4 812.5 -757.5 827.5 -752.5 {}
L 4 812.5 -757.5 827.5 -762.5 {}
L 4 812.5 -767.5 827.5 -762.5 {}
L 4 812.5 -767.5 827.5 -772.5 {}
L 4 812.5 -777.5 827.5 -772.5 {}
L 4 812.5 -777.5 827.5 -782.5 {}
L 4 812.5 -787.5 827.5 -782.5 {}
L 4 812.5 -787.5 820 -790 {}
L 4 820 -800 820 -790 {}
L 4 822.5 -792.5 827.5 -792.5 {}
L 4 825 -795 825 -790 {}
L 4 930 -750 930 -740 {}
L 4 930 -750 937.5 -752.5 {}
L 4 922.5 -757.5 937.5 -752.5 {}
L 4 922.5 -757.5 937.5 -762.5 {}
L 4 922.5 -767.5 937.5 -762.5 {}
L 4 922.5 -767.5 937.5 -772.5 {}
L 4 922.5 -777.5 937.5 -772.5 {}
L 4 922.5 -777.5 937.5 -782.5 {}
L 4 922.5 -787.5 937.5 -782.5 {}
L 4 922.5 -787.5 930 -790 {}
L 4 930 -800 930 -790 {}
L 4 932.5 -792.5 937.5 -792.5 {}
L 4 935 -795 935 -790 {}
L 4 710 -660 710 -650 {}
L 4 710 -660 717.5 -662.5 {}
L 4 702.5 -667.5 717.5 -662.5 {}
L 4 702.5 -667.5 717.5 -672.5 {}
L 4 702.5 -677.5 717.5 -672.5 {}
L 4 702.5 -677.5 717.5 -682.5 {}
L 4 702.5 -687.5 717.5 -682.5 {}
L 4 702.5 -687.5 717.5 -692.5 {}
L 4 702.5 -697.5 717.5 -692.5 {}
L 4 702.5 -697.5 710 -700 {}
L 4 710 -710 710 -700 {}
L 4 712.5 -702.5 717.5 -702.5 {}
L 4 715 -705 715 -700 {}
L 4 820 -660 820 -650 {}
L 4 820 -660 827.5 -662.5 {}
L 4 812.5 -667.5 827.5 -662.5 {}
L 4 812.5 -667.5 827.5 -672.5 {}
L 4 812.5 -677.5 827.5 -672.5 {}
L 4 812.5 -677.5 827.5 -682.5 {}
L 4 812.5 -687.5 827.5 -682.5 {}
L 4 812.5 -687.5 827.5 -692.5 {}
L 4 812.5 -697.5 827.5 -692.5 {}
L 4 812.5 -697.5 820 -700 {}
L 4 820 -710 820 -700 {}
L 4 822.5 -702.5 827.5 -702.5 {}
L 4 825 -705 825 -700 {}
L 4 930 -660 930 -650 {}
L 4 930 -660 937.5 -662.5 {}
L 4 922.5 -667.5 937.5 -662.5 {}
L 4 922.5 -667.5 937.5 -672.5 {}
L 4 922.5 -677.5 937.5 -672.5 {}
L 4 922.5 -677.5 937.5 -682.5 {}
L 4 922.5 -687.5 937.5 -682.5 {}
L 4 922.5 -687.5 937.5 -692.5 {}
L 4 922.5 -697.5 937.5 -692.5 {}
L 4 922.5 -697.5 930 -700 {}
L 4 930 -710 930 -700 {}
L 4 932.5 -702.5 937.5 -702.5 {}
L 4 935 -705 935 -700 {}
L 4 1250 -660 1250 -650 {}
L 4 1250 -660 1257.5 -662.5 {}
L 4 1242.5 -667.5 1257.5 -662.5 {}
L 4 1242.5 -667.5 1257.5 -672.5 {}
L 4 1242.5 -677.5 1257.5 -672.5 {}
L 4 1242.5 -677.5 1257.5 -682.5 {}
L 4 1242.5 -687.5 1257.5 -682.5 {}
L 4 1242.5 -687.5 1257.5 -692.5 {}
L 4 1242.5 -697.5 1257.5 -692.5 {}
L 4 1242.5 -697.5 1250 -700 {}
L 4 1250 -710 1250 -700 {}
L 4 1252.5 -702.5 1257.5 -702.5 {}
L 4 1255 -705 1255 -700 {}
L 4 1360 -660 1360 -650 {}
L 4 1360 -660 1367.5 -662.5 {}
L 4 1352.5 -667.5 1367.5 -662.5 {}
L 4 1352.5 -667.5 1367.5 -672.5 {}
L 4 1352.5 -677.5 1367.5 -672.5 {}
L 4 1352.5 -677.5 1367.5 -682.5 {}
L 4 1352.5 -687.5 1367.5 -682.5 {}
L 4 1352.5 -687.5 1367.5 -692.5 {}
L 4 1352.5 -697.5 1367.5 -692.5 {}
L 4 1352.5 -697.5 1360 -700 {}
L 4 1360 -710 1360 -700 {}
L 4 1362.5 -702.5 1367.5 -702.5 {}
L 4 1365 -705 1365 -700 {}
L 4 1470 -660 1470 -650 {}
L 4 1470 -660 1477.5 -662.5 {}
L 4 1462.5 -667.5 1477.5 -662.5 {}
L 4 1462.5 -667.5 1477.5 -672.5 {}
L 4 1462.5 -677.5 1477.5 -672.5 {}
L 4 1462.5 -677.5 1477.5 -682.5 {}
L 4 1462.5 -687.5 1477.5 -682.5 {}
L 4 1462.5 -687.5 1477.5 -692.5 {}
L 4 1462.5 -697.5 1477.5 -692.5 {}
L 4 1462.5 -697.5 1470 -700 {}
L 4 1470 -710 1470 -700 {}
L 4 1472.5 -702.5 1477.5 -702.5 {}
L 4 1475 -705 1475 -700 {}
L 4 1790 -660 1790 -650 {}
L 4 1790 -660 1797.5 -662.5 {}
L 4 1782.5 -667.5 1797.5 -662.5 {}
L 4 1782.5 -667.5 1797.5 -672.5 {}
L 4 1782.5 -677.5 1797.5 -672.5 {}
L 4 1782.5 -677.5 1797.5 -682.5 {}
L 4 1782.5 -687.5 1797.5 -682.5 {}
L 4 1782.5 -687.5 1797.5 -692.5 {}
L 4 1782.5 -697.5 1797.5 -692.5 {}
L 4 1782.5 -697.5 1790 -700 {}
L 4 1790 -710 1790 -700 {}
L 4 1792.5 -702.5 1797.5 -702.5 {}
L 4 1795 -705 1795 -700 {}
L 4 1900 -660 1900 -650 {}
L 4 1900 -660 1907.5 -662.5 {}
L 4 1892.5 -667.5 1907.5 -662.5 {}
L 4 1892.5 -667.5 1907.5 -672.5 {}
L 4 1892.5 -677.5 1907.5 -672.5 {}
L 4 1892.5 -677.5 1907.5 -682.5 {}
L 4 1892.5 -687.5 1907.5 -682.5 {}
L 4 1892.5 -687.5 1907.5 -692.5 {}
L 4 1892.5 -697.5 1907.5 -692.5 {}
L 4 1892.5 -697.5 1900 -700 {}
L 4 1900 -710 1900 -700 {}
L 4 1902.5 -702.5 1907.5 -702.5 {}
L 4 1905 -705 1905 -700 {}
L 4 2010 -660 2010 -650 {}
L 4 2010 -660 2017.5 -662.5 {}
L 4 2002.5 -667.5 2017.5 -662.5 {}
L 4 2002.5 -667.5 2017.5 -672.5 {}
L 4 2002.5 -677.5 2017.5 -672.5 {}
L 4 2002.5 -677.5 2017.5 -682.5 {}
L 4 2002.5 -687.5 2017.5 -682.5 {}
L 4 2002.5 -687.5 2017.5 -692.5 {}
L 4 2002.5 -697.5 2017.5 -692.5 {}
L 4 2002.5 -697.5 2010 -700 {}
L 4 2010 -710 2010 -700 {}
L 4 2012.5 -702.5 2017.5 -702.5 {}
L 4 2015 -705 2015 -700 {}
L 4 1865 -2470 1865 -2410 {}
L 4 1865 -2460 1880 -2460 {}
L 4 1880 -2470 1880 -2460 {}
L 4 1865 -2420 1880 -2420 {}
L 4 1880 -2420 1880 -2410 {}
L 4 1855 -2455 1855 -2425 {}
L 4 1855 -2440 1855 -2435 {}
L 4 1840 -2440 1847.5 -2440 {}
L 4 1840 -2440 1855 -2440 {}
L 4 1870 -2440 1880 -2440 {}
L 4 1865 -2445 1870 -2440 {}
L 4 1865 -2435 1870 -2440 {}
L 4 1140 -8580 1140 -8567.5 {}
L 4 1135 -8567.5 1145 -8567.5 {}
L 4 1140 -8562.5 1145 -8567.5 {}
L 4 1135 -8567.5 1140 -8562.5 {}
L 4 1140 -8860 1140 -8840 {}
L 4 1130 -8860 1150 -8860 {}
L 4 1032.5 -8652.5 1037.5 -8652.5 {}
L 4 1035 -8655 1035 -8650 {}
L 4 1030 -8660 1030 -8600 {}
L 4 710 -370 710 -360 {}
L 4 710 -370 717.5 -372.5 {}
L 4 702.5 -377.5 717.5 -372.5 {}
L 4 702.5 -377.5 717.5 -382.5 {}
L 4 702.5 -387.5 717.5 -382.5 {}
L 4 702.5 -387.5 717.5 -392.5 {}
L 4 702.5 -397.5 717.5 -392.5 {}
L 4 702.5 -397.5 717.5 -402.5 {}
L 4 702.5 -407.5 717.5 -402.5 {}
L 4 702.5 -407.5 710 -410 {}
L 4 710 -420 710 -410 {}
L 4 712.5 -412.5 717.5 -412.5 {}
L 4 715 -415 715 -410 {}
L 4 820 -370 820 -360 {}
L 4 820 -370 827.5 -372.5 {}
L 4 812.5 -377.5 827.5 -372.5 {}
L 4 812.5 -377.5 827.5 -382.5 {}
L 4 812.5 -387.5 827.5 -382.5 {}
L 4 812.5 -387.5 827.5 -392.5 {}
L 4 812.5 -397.5 827.5 -392.5 {}
L 4 812.5 -397.5 827.5 -402.5 {}
L 4 812.5 -407.5 827.5 -402.5 {}
L 4 812.5 -407.5 820 -410 {}
L 4 820 -420 820 -410 {}
L 4 822.5 -412.5 827.5 -412.5 {}
L 4 825 -415 825 -410 {}
L 4 930 -370 930 -360 {}
L 4 930 -370 937.5 -372.5 {}
L 4 922.5 -377.5 937.5 -372.5 {}
L 4 922.5 -377.5 937.5 -382.5 {}
L 4 922.5 -387.5 937.5 -382.5 {}
L 4 922.5 -387.5 937.5 -392.5 {}
L 4 922.5 -397.5 937.5 -392.5 {}
L 4 922.5 -397.5 937.5 -402.5 {}
L 4 922.5 -407.5 937.5 -402.5 {}
L 4 922.5 -407.5 930 -410 {}
L 4 930 -420 930 -410 {}
L 4 932.5 -412.5 937.5 -412.5 {}
L 4 935 -415 935 -410 {}
L 4 710 -310 710 -300 {}
L 4 710 -310 717.5 -312.5 {}
L 4 702.5 -317.5 717.5 -312.5 {}
L 4 702.5 -317.5 717.5 -322.5 {}
L 4 702.5 -327.5 717.5 -322.5 {}
L 4 702.5 -327.5 717.5 -332.5 {}
L 4 702.5 -337.5 717.5 -332.5 {}
L 4 702.5 -337.5 717.5 -342.5 {}
L 4 702.5 -347.5 717.5 -342.5 {}
L 4 702.5 -347.5 710 -350 {}
L 4 710 -360 710 -350 {}
L 4 712.5 -352.5 717.5 -352.5 {}
L 4 715 -355 715 -350 {}
L 4 820 -310 820 -300 {}
L 4 820 -310 827.5 -312.5 {}
L 4 812.5 -317.5 827.5 -312.5 {}
L 4 812.5 -317.5 827.5 -322.5 {}
L 4 812.5 -327.5 827.5 -322.5 {}
L 4 812.5 -327.5 827.5 -332.5 {}
L 4 812.5 -337.5 827.5 -332.5 {}
L 4 812.5 -337.5 827.5 -342.5 {}
L 4 812.5 -347.5 827.5 -342.5 {}
L 4 812.5 -347.5 820 -350 {}
L 4 820 -360 820 -350 {}
L 4 822.5 -352.5 827.5 -352.5 {}
L 4 825 -355 825 -350 {}
L 4 930 -310 930 -300 {}
L 4 930 -310 937.5 -312.5 {}
L 4 922.5 -317.5 937.5 -312.5 {}
L 4 922.5 -317.5 937.5 -322.5 {}
L 4 922.5 -327.5 937.5 -322.5 {}
L 4 922.5 -327.5 937.5 -332.5 {}
L 4 922.5 -337.5 937.5 -332.5 {}
L 4 922.5 -337.5 937.5 -342.5 {}
L 4 922.5 -347.5 937.5 -342.5 {}
L 4 922.5 -347.5 930 -350 {}
L 4 930 -360 930 -350 {}
L 4 932.5 -352.5 937.5 -352.5 {}
L 4 935 -355 935 -350 {}
L 4 1250 -310 1250 -300 {}
L 4 1250 -310 1257.5 -312.5 {}
L 4 1242.5 -317.5 1257.5 -312.5 {}
L 4 1242.5 -317.5 1257.5 -322.5 {}
L 4 1242.5 -327.5 1257.5 -322.5 {}
L 4 1242.5 -327.5 1257.5 -332.5 {}
L 4 1242.5 -337.5 1257.5 -332.5 {}
L 4 1242.5 -337.5 1257.5 -342.5 {}
L 4 1242.5 -347.5 1257.5 -342.5 {}
L 4 1242.5 -347.5 1250 -350 {}
L 4 1250 -360 1250 -350 {}
L 4 1252.5 -352.5 1257.5 -352.5 {}
L 4 1255 -355 1255 -350 {}
L 4 1360 -310 1360 -300 {}
L 4 1360 -310 1367.5 -312.5 {}
L 4 1352.5 -317.5 1367.5 -312.5 {}
L 4 1352.5 -317.5 1367.5 -322.5 {}
L 4 1352.5 -327.5 1367.5 -322.5 {}
L 4 1352.5 -327.5 1367.5 -332.5 {}
L 4 1352.5 -337.5 1367.5 -332.5 {}
L 4 1352.5 -337.5 1367.5 -342.5 {}
L 4 1352.5 -347.5 1367.5 -342.5 {}
L 4 1352.5 -347.5 1360 -350 {}
L 4 1360 -360 1360 -350 {}
L 4 1362.5 -352.5 1367.5 -352.5 {}
L 4 1365 -355 1365 -350 {}
L 4 1470 -310 1470 -300 {}
L 4 1470 -310 1477.5 -312.5 {}
L 4 1462.5 -317.5 1477.5 -312.5 {}
L 4 1462.5 -317.5 1477.5 -322.5 {}
L 4 1462.5 -327.5 1477.5 -322.5 {}
L 4 1462.5 -327.5 1477.5 -332.5 {}
L 4 1462.5 -337.5 1477.5 -332.5 {}
L 4 1462.5 -337.5 1477.5 -342.5 {}
L 4 1462.5 -347.5 1477.5 -342.5 {}
L 4 1462.5 -347.5 1470 -350 {}
L 4 1470 -360 1470 -350 {}
L 4 1472.5 -352.5 1477.5 -352.5 {}
L 4 1475 -355 1475 -350 {}
L 4 1790 -280 1790 -270 {}
L 4 1790 -280 1797.5 -282.5 {}
L 4 1782.5 -287.5 1797.5 -282.5 {}
L 4 1782.5 -287.5 1797.5 -292.5 {}
L 4 1782.5 -297.5 1797.5 -292.5 {}
L 4 1782.5 -297.5 1797.5 -302.5 {}
L 4 1782.5 -307.5 1797.5 -302.5 {}
L 4 1782.5 -307.5 1797.5 -312.5 {}
L 4 1782.5 -317.5 1797.5 -312.5 {}
L 4 1782.5 -317.5 1790 -320 {}
L 4 1790 -330 1790 -320 {}
L 4 1792.5 -322.5 1797.5 -322.5 {}
L 4 1795 -325 1795 -320 {}
L 4 1900 -280 1900 -270 {}
L 4 1900 -280 1907.5 -282.5 {}
L 4 1892.5 -287.5 1907.5 -282.5 {}
L 4 1892.5 -287.5 1907.5 -292.5 {}
L 4 1892.5 -297.5 1907.5 -292.5 {}
L 4 1892.5 -297.5 1907.5 -302.5 {}
L 4 1892.5 -307.5 1907.5 -302.5 {}
L 4 1892.5 -307.5 1907.5 -312.5 {}
L 4 1892.5 -317.5 1907.5 -312.5 {}
L 4 1892.5 -317.5 1900 -320 {}
L 4 1900 -330 1900 -320 {}
L 4 1902.5 -322.5 1907.5 -322.5 {}
L 4 1905 -325 1905 -320 {}
L 4 2010 -280 2010 -270 {}
L 4 2010 -280 2017.5 -282.5 {}
L 4 2002.5 -287.5 2017.5 -282.5 {}
L 4 2002.5 -287.5 2017.5 -292.5 {}
L 4 2002.5 -297.5 2017.5 -292.5 {}
L 4 2002.5 -297.5 2017.5 -302.5 {}
L 4 2002.5 -307.5 2017.5 -302.5 {}
L 4 2002.5 -307.5 2017.5 -312.5 {}
L 4 2002.5 -317.5 2017.5 -312.5 {}
L 4 2002.5 -317.5 2010 -320 {}
L 4 2010 -330 2010 -320 {}
L 4 2012.5 -322.5 2017.5 -322.5 {}
L 4 2015 -325 2015 -320 {}
L 4 1760 -1060 1760 -1050 {}
L 4 1760 -1060 1767.5 -1062.5 {}
L 4 1752.5 -1067.5 1767.5 -1062.5 {}
L 4 1752.5 -1067.5 1767.5 -1072.5 {}
L 4 1752.5 -1077.5 1767.5 -1072.5 {}
L 4 1752.5 -1077.5 1767.5 -1082.5 {}
L 4 1752.5 -1087.5 1767.5 -1082.5 {}
L 4 1752.5 -1087.5 1767.5 -1092.5 {}
L 4 1752.5 -1097.5 1767.5 -1092.5 {}
L 4 1752.5 -1097.5 1760 -1100 {}
L 4 1760 -1110 1760 -1100 {}
L 4 1762.5 -1102.5 1767.5 -1102.5 {}
L 4 1765 -1105 1765 -1100 {}
L 4 1880 -1060 1880 -1050 {}
L 4 1880 -1060 1887.5 -1062.5 {}
L 4 1872.5 -1067.5 1887.5 -1062.5 {}
L 4 1872.5 -1067.5 1887.5 -1072.5 {}
L 4 1872.5 -1077.5 1887.5 -1072.5 {}
L 4 1872.5 -1077.5 1887.5 -1082.5 {}
L 4 1872.5 -1087.5 1887.5 -1082.5 {}
L 4 1872.5 -1087.5 1887.5 -1092.5 {}
L 4 1872.5 -1097.5 1887.5 -1092.5 {}
L 4 1872.5 -1097.5 1880 -1100 {}
L 4 1880 -1110 1880 -1100 {}
L 4 1882.5 -1102.5 1887.5 -1102.5 {}
L 4 1885 -1105 1885 -1100 {}
L 4 805 40 805 100 {}
L 4 805 50 820 50 {}
L 4 820 40 820 50 {}
L 4 805 90 820 90 {}
L 4 820 90 820 100 {}
L 4 795 55 795 85 {}
L 4 795 70 795 75 {}
L 4 780 70 787.5 70 {}
L 4 780 70 795 70 {}
L 4 810 70 820 70 {}
L 4 805 65 810 70 {}
L 4 805 75 810 70 {}
L 4 820 0 820 10 {}
L 4 820 0 827.5 -2.5 {}
L 4 812.5 -7.5 827.5 -2.5 {}
L 4 812.5 -7.5 827.5 -12.5 {}
L 4 812.5 -17.5 827.5 -12.5 {}
L 4 812.5 -17.5 827.5 -22.5 {}
L 4 812.5 -27.5 827.5 -22.5 {}
L 4 812.5 -27.5 827.5 -32.5 {}
L 4 812.5 -37.5 827.5 -32.5 {}
L 4 812.5 -37.5 820 -40 {}
L 4 820 -50 820 -40 {}
L 4 822.5 -42.5 827.5 -42.5 {}
L 4 825 -45 825 -40 {}
L 4 910 75 910 100 {}
L 4 910 40 910 65 {}
L 4 900 65 920 65 {}
L 4 900 75 920 75 {}
L 4 912.5 47.5 917.5 47.5 {}
L 4 915 45 915 50 {}
L 4 582.5 107.5 587.5 107.5 {}
L 4 585 105 585 110 {}
L 4 580 100 580 160 {}
L 4 690 180 690 192.5 {}
L 4 685 192.5 695 192.5 {}
L 4 690 197.5 695 192.5 {}
L 4 685 192.5 690 197.5 {}
L 4 690 -100 690 -80 {}
L 4 680 -100 700 -100 {}
L 4 1455 40 1455 100 {}
L 4 1455 50 1470 50 {}
L 4 1470 40 1470 50 {}
L 4 1455 90 1470 90 {}
L 4 1470 90 1470 100 {}
L 4 1445 55 1445 85 {}
L 4 1445 70 1445 75 {}
L 4 1430 70 1437.5 70 {}
L 4 1430 70 1445 70 {}
L 4 1460 70 1470 70 {}
L 4 1455 65 1460 70 {}
L 4 1455 75 1460 70 {}
L 4 1470 0 1470 10 {}
L 4 1470 0 1477.5 -2.5 {}
L 4 1462.5 -7.5 1477.5 -2.5 {}
L 4 1462.5 -7.5 1477.5 -12.5 {}
L 4 1462.5 -17.5 1477.5 -12.5 {}
L 4 1462.5 -17.5 1477.5 -22.5 {}
L 4 1462.5 -27.5 1477.5 -22.5 {}
L 4 1462.5 -27.5 1477.5 -32.5 {}
L 4 1462.5 -37.5 1477.5 -32.5 {}
L 4 1462.5 -37.5 1470 -40 {}
L 4 1470 -50 1470 -40 {}
L 4 1472.5 -42.5 1477.5 -42.5 {}
L 4 1475 -45 1475 -40 {}
L 4 1232.5 107.5 1237.5 107.5 {}
L 4 1235 105 1235 110 {}
L 4 1230 100 1230 160 {}
L 4 1340 180 1340 192.5 {}
L 4 1335 192.5 1345 192.5 {}
L 4 1340 197.5 1345 192.5 {}
L 4 1335 192.5 1340 197.5 {}
L 4 1340 -100 1340 -80 {}
L 4 1330 -100 1350 -100 {}
L 4 1285 -5160 1285 -5100 {}
L 4 1285 -5150 1300 -5150 {}
L 4 1300 -5160 1300 -5150 {}
L 4 1285 -5110 1300 -5110 {}
L 4 1300 -5110 1300 -5100 {}
L 4 1275 -5145 1275 -5115 {}
L 4 1275 -5130 1275 -5125 {}
L 4 1260 -5130 1267.5 -5130 {}
L 4 1260 -5130 1275 -5130 {}
L 4 1290 -5130 1300 -5130 {}
L 4 1285 -5135 1290 -5130 {}
L 4 1285 -5125 1290 -5130 {}
L 4 1300 -5200 1300 -5190 {}
L 4 1300 -5200 1307.5 -5202.5 {}
L 4 1292.5 -5207.5 1307.5 -5202.5 {}
L 4 1292.5 -5207.5 1307.5 -5212.5 {}
L 4 1292.5 -5217.5 1307.5 -5212.5 {}
L 4 1292.5 -5217.5 1307.5 -5222.5 {}
L 4 1292.5 -5227.5 1307.5 -5222.5 {}
L 4 1292.5 -5227.5 1307.5 -5232.5 {}
L 4 1292.5 -5237.5 1307.5 -5232.5 {}
L 4 1292.5 -5237.5 1300 -5240 {}
L 4 1300 -5250 1300 -5240 {}
L 4 1302.5 -5242.5 1307.5 -5242.5 {}
L 4 1305 -5245 1305 -5240 {}
L 4 1390 -5125 1390 -5100 {}
L 4 1390 -5160 1390 -5135 {}
L 4 1380 -5135 1400 -5135 {}
L 4 1380 -5125 1400 -5125 {}
L 4 1392.5 -5152.5 1397.5 -5152.5 {}
L 4 1395 -5155 1395 -5150 {}
L 4 1062.5 -5092.5 1067.5 -5092.5 {}
L 4 1065 -5095 1065 -5090 {}
L 4 1060 -5100 1060 -5040 {}
L 4 1170 -5020 1170 -5007.5 {}
L 4 1165 -5007.5 1175 -5007.5 {}
L 4 1170 -5002.5 1175 -5007.5 {}
L 4 1165 -5007.5 1170 -5002.5 {}
L 4 1170 -5300 1170 -5280 {}
L 4 1160 -5300 1180 -5300 {}
L 4 1845 -5160 1845 -5100 {}
L 4 1845 -5150 1860 -5150 {}
L 4 1860 -5160 1860 -5150 {}
L 4 1845 -5110 1860 -5110 {}
L 4 1860 -5110 1860 -5100 {}
L 4 1835 -5145 1835 -5115 {}
L 4 1835 -5130 1835 -5125 {}
L 4 1820 -5130 1827.5 -5130 {}
L 4 1820 -5130 1835 -5130 {}
L 4 1850 -5130 1860 -5130 {}
L 4 1845 -5135 1850 -5130 {}
L 4 1845 -5125 1850 -5130 {}
L 4 1860 -5200 1860 -5190 {}
L 4 1860 -5200 1867.5 -5202.5 {}
L 4 1852.5 -5207.5 1867.5 -5202.5 {}
L 4 1852.5 -5207.5 1867.5 -5212.5 {}
L 4 1852.5 -5217.5 1867.5 -5212.5 {}
L 4 1852.5 -5217.5 1867.5 -5222.5 {}
L 4 1852.5 -5227.5 1867.5 -5222.5 {}
L 4 1852.5 -5227.5 1867.5 -5232.5 {}
L 4 1852.5 -5237.5 1867.5 -5232.5 {}
L 4 1852.5 -5237.5 1860 -5240 {}
L 4 1860 -5250 1860 -5240 {}
L 4 1862.5 -5242.5 1867.5 -5242.5 {}
L 4 1865 -5245 1865 -5240 {}
L 4 1950 -5125 1950 -5100 {}
L 4 1950 -5160 1950 -5135 {}
L 4 1940 -5135 1960 -5135 {}
L 4 1940 -5125 1960 -5125 {}
L 4 1952.5 -5152.5 1957.5 -5152.5 {}
L 4 1955 -5155 1955 -5150 {}
L 4 1622.5 -5092.5 1627.5 -5092.5 {}
L 4 1625 -5095 1625 -5090 {}
L 4 1620 -5100 1620 -5040 {}
L 4 1730 -5020 1730 -5007.5 {}
L 4 1725 -5007.5 1735 -5007.5 {}
L 4 1730 -5002.5 1735 -5007.5 {}
L 4 1725 -5007.5 1730 -5002.5 {}
L 4 1730 -5300 1730 -5280 {}
L 4 1720 -5300 1740 -5300 {}
L 4 2415 -5160 2415 -5100 {}
L 4 2415 -5150 2430 -5150 {}
L 4 2430 -5160 2430 -5150 {}
L 4 2415 -5110 2430 -5110 {}
L 4 2430 -5110 2430 -5100 {}
L 4 2405 -5145 2405 -5115 {}
L 4 2405 -5130 2405 -5125 {}
L 4 2390 -5130 2397.5 -5130 {}
L 4 2390 -5130 2405 -5130 {}
L 4 2420 -5130 2430 -5130 {}
L 4 2415 -5135 2420 -5130 {}
L 4 2415 -5125 2420 -5130 {}
L 4 2430 -5200 2430 -5190 {}
L 4 2430 -5200 2437.5 -5202.5 {}
L 4 2422.5 -5207.5 2437.5 -5202.5 {}
L 4 2422.5 -5207.5 2437.5 -5212.5 {}
L 4 2422.5 -5217.5 2437.5 -5212.5 {}
L 4 2422.5 -5217.5 2437.5 -5222.5 {}
L 4 2422.5 -5227.5 2437.5 -5222.5 {}
L 4 2422.5 -5227.5 2437.5 -5232.5 {}
L 4 2422.5 -5237.5 2437.5 -5232.5 {}
L 4 2422.5 -5237.5 2430 -5240 {}
L 4 2430 -5250 2430 -5240 {}
L 4 2432.5 -5242.5 2437.5 -5242.5 {}
L 4 2435 -5245 2435 -5240 {}
L 4 2520 -5125 2520 -5100 {}
L 4 2520 -5160 2520 -5135 {}
L 4 2510 -5135 2530 -5135 {}
L 4 2510 -5125 2530 -5125 {}
L 4 2522.5 -5152.5 2527.5 -5152.5 {}
L 4 2525 -5155 2525 -5150 {}
L 4 2192.5 -5092.5 2197.5 -5092.5 {}
L 4 2195 -5095 2195 -5090 {}
L 4 2190 -5100 2190 -5040 {}
L 4 2300 -5020 2300 -5007.5 {}
L 4 2295 -5007.5 2305 -5007.5 {}
L 4 2300 -5002.5 2305 -5007.5 {}
L 4 2295 -5007.5 2300 -5002.5 {}
L 4 2300 -5300 2300 -5280 {}
L 4 2290 -5300 2310 -5300 {}
L 4 2015 40 2015 100 {}
L 4 2015 50 2030 50 {}
L 4 2030 40 2030 50 {}
L 4 2015 90 2030 90 {}
L 4 2030 90 2030 100 {}
L 4 2005 55 2005 85 {}
L 4 2005 70 2005 75 {}
L 4 1990 70 1997.5 70 {}
L 4 1990 70 2005 70 {}
L 4 2020 70 2030 70 {}
L 4 2015 65 2020 70 {}
L 4 2015 75 2020 70 {}
L 4 2030 0 2030 10 {}
L 4 2030 0 2037.5 -2.5 {}
L 4 2022.5 -7.5 2037.5 -2.5 {}
L 4 2022.5 -7.5 2037.5 -12.5 {}
L 4 2022.5 -17.5 2037.5 -12.5 {}
L 4 2022.5 -17.5 2037.5 -22.5 {}
L 4 2022.5 -27.5 2037.5 -22.5 {}
L 4 2022.5 -27.5 2037.5 -32.5 {}
L 4 2022.5 -37.5 2037.5 -32.5 {}
L 4 2022.5 -37.5 2030 -40 {}
L 4 2030 -50 2030 -40 {}
L 4 2032.5 -42.5 2037.5 -42.5 {}
L 4 2035 -45 2035 -40 {}
L 4 1792.5 107.5 1797.5 107.5 {}
L 4 1795 105 1795 110 {}
L 4 1790 100 1790 160 {}
L 4 1900 180 1900 192.5 {}
L 4 1895 192.5 1905 192.5 {}
L 4 1900 197.5 1905 192.5 {}
L 4 1895 192.5 1900 197.5 {}
L 4 1900 -100 1900 -80 {}
L 4 1890 -100 1910 -100 {}
L 5 1105 -8220 1110 -8220 {}
L 5 1410 -8250 1418.75 -8250 {}
L 5 1645 -8220 1650 -8220 {}
L 5 1950 -8250 1958.75 -8250 {}
L 5 575 -8220 580 -8220 {}
L 5 880 -8250 888.75 -8250 {}
L 5 575 -7760 580 -7760 {}
L 5 880 -7790 888.75 -7790 {}
L 5 1115 -7760 1120 -7760 {}
L 5 1420 -7790 1428.75 -7790 {}
L 5 575 -6930 580 -6930 {}
L 5 880 -6960 888.75 -6960 {}
L 5 1115 -6930 1120 -6930 {}
L 5 1420 -6960 1428.75 -6960 {}
L 5 575 -6440 580 -6440 {}
L 5 880 -6470 888.75 -6470 {}
L 5 1115 -6440 1120 -6440 {}
L 5 1420 -6470 1428.75 -6470 {}
L 5 575 -5950 580 -5950 {}
L 5 1765 -5950 1770 -5950 {}
L 5 1115 -5950 1120 -5950 {}
L 5 1105 -7390 1110 -7390 {}
L 5 1410 -7420 1418.75 -7420 {}
L 5 575 -7390 580 -7390 {}
L 5 880 -7420 888.75 -7420 {}
L 5 1605 -7390 1610 -7390 {}
L 5 1910 -7420 1918.75 -7420 {}
L 5 1645 -8690 1650 -8690 {}
L 5 1950 -8720 1958.75 -8720 {}
L 5 575 -8690 580 -8690 {}
L 5 880 -8720 888.75 -8720 {}
L 5 2105 -8690 2110 -8690 {}
L 5 2410 -8720 2418.75 -8720 {}
L 5 595 -5510 600 -5510 {}
L 5 900 -5540 908.75 -5540 {}
L 5 1135 -5510 1140 -5510 {}
L 5 1440 -5540 1448.75 -5540 {}
L 5 1695 -5510 1700 -5510 {}
L 5 2000 -5540 2008.75 -5540 {}
L 5 2265 -5510 2270 -5510 {}
L 5 2570 -5540 2578.75 -5540 {}
L 5 595 -4710 600 -4710 {}
L 5 900 -4740 908.75 -4740 {}
L 5 1135 -4710 1140 -4710 {}
L 5 1440 -4740 1448.75 -4740 {}
L 5 2265 -4710 2270 -4710 {}
L 5 2570 -4740 2578.75 -4740 {}
L 5 595 -5130 600 -5130 {}
L 5 900 -5160 908.75 -5160 {}
L 5 595 -4300 600 -4300 {}
L 5 900 -4330 908.75 -4330 {}
L 5 1695 -4300 1700 -4300 {}
L 5 2000 -4330 2008.75 -4330 {}
L 5 1135 -4300 1140 -4300 {}
L 5 1440 -4330 1448.75 -4330 {}
L 5 1105 -8690 1110 -8690 {}
L 5 1410 -8720 1418.75 -8720 {}
L 5 655 70 660 70 {}
L 5 960 40 968.75 40 {}
L 5 1305 70 1310 70 {}
L 5 1610 40 1618.75 40 {}
L 5 1135 -5130 1140 -5130 {}
L 5 1440 -5160 1448.75 -5160 {}
L 5 1695 -5130 1700 -5130 {}
L 5 2000 -5160 2008.75 -5160 {}
L 5 2265 -5130 2270 -5130 {}
L 5 2570 -5160 2578.75 -5160 {}
L 5 1865 70 1870 70 {}
L 5 2170 40 2178.75 40 {}
L 6 1110 -8220 1230 -8220 {}
L 6 1030 -8370 1270 -8370 {}
L 6 1270 -8250 1410 -8250 {}
L 6 1030 -8130 1030 -8110 {}
L 6 1030 -8370 1030 -8190 {}
L 6 1030 -8110 1270 -8110 {}
L 6 1650 -8220 1770 -8220 {}
L 6 1570 -8370 1810 -8370 {}
L 6 1810 -8250 1950 -8250 {}
L 6 1570 -8130 1570 -8110 {}
L 6 1570 -8370 1570 -8190 {}
L 6 1570 -8110 1810 -8110 {}
L 6 580 -8220 700 -8220 {}
L 6 500 -8370 740 -8370 {}
L 6 740 -8250 880 -8250 {}
L 6 500 -8130 500 -8110 {}
L 6 500 -8370 500 -8190 {}
L 6 500 -8110 740 -8110 {}
L 6 580 -7760 700 -7760 {}
L 6 740 -7820 740 -7790 {}
L 6 740 -7910 740 -7880 {}
L 6 500 -7910 740 -7910 {}
L 6 740 -7790 880 -7790 {}
L 6 830 -7730 830 -7650 {}
L 6 500 -7670 500 -7650 {}
L 6 500 -7910 500 -7730 {}
L 6 740 -7760 740 -7650 {}
L 6 740 -7650 830 -7650 {}
L 6 500 -7650 740 -7650 {}
L 6 1120 -7760 1240 -7760 {}
L 6 1280 -7820 1280 -7790 {}
L 6 1280 -7910 1280 -7880 {}
L 6 1040 -7910 1280 -7910 {}
L 6 1280 -7790 1420 -7790 {}
L 6 1370 -7730 1370 -7650 {}
L 6 1040 -7670 1040 -7650 {}
L 6 1040 -7910 1040 -7730 {}
L 6 1280 -7760 1280 -7650 {}
L 6 1280 -7650 1370 -7650 {}
L 6 1040 -7650 1280 -7650 {}
L 6 580 -6930 700 -6930 {}
L 6 740 -6990 740 -6960 {}
L 6 740 -7080 740 -7050 {}
L 6 500 -7080 740 -7080 {}
L 6 740 -6960 880 -6960 {}
L 6 830 -6900 830 -6820 {}
L 6 500 -6840 500 -6820 {}
L 6 500 -7080 500 -6900 {}
L 6 740 -6930 740 -6820 {}
L 6 740 -6820 830 -6820 {}
L 6 500 -6820 740 -6820 {}
L 6 1120 -6930 1240 -6930 {}
L 6 1280 -6990 1280 -6960 {}
L 6 1280 -7080 1280 -7050 {}
L 6 1040 -7080 1280 -7080 {}
L 6 1280 -6960 1420 -6960 {}
L 6 1370 -6900 1370 -6820 {}
L 6 1040 -6840 1040 -6820 {}
L 6 1040 -7080 1040 -6900 {}
L 6 1280 -6930 1280 -6820 {}
L 6 1280 -6820 1370 -6820 {}
L 6 1040 -6820 1280 -6820 {}
L 6 580 -6440 700 -6440 {}
L 6 740 -6500 740 -6470 {}
L 6 740 -6590 740 -6560 {}
L 6 500 -6590 740 -6590 {}
L 6 740 -6470 880 -6470 {}
L 6 830 -6410 830 -6330 {}
L 6 500 -6350 500 -6330 {}
L 6 500 -6590 500 -6410 {}
L 6 740 -6440 740 -6330 {}
L 6 740 -6330 830 -6330 {}
L 6 500 -6330 740 -6330 {}
L 6 1120 -6440 1240 -6440 {}
L 6 1040 -6590 1280 -6590 {}
L 6 1280 -6470 1420 -6470 {}
L 6 1370 -6410 1370 -6330 {}
L 6 1040 -6350 1040 -6330 {}
L 6 1040 -6590 1040 -6410 {}
L 6 1280 -6440 1280 -6330 {}
L 6 1280 -6330 1370 -6330 {}
L 6 1040 -6330 1280 -6330 {}
L 6 580 -5950 700 -5950 {}
L 6 500 -6100 740 -6100 {}
L 6 500 -5860 500 -5840 {}
L 6 500 -6100 500 -5920 {}
L 6 500 -5840 740 -5840 {}
L 6 1690 -5860 1690 -5840 {}
L 6 1690 -6100 1690 -5920 {}
L 6 1120 -5950 1240 -5950 {}
L 6 1040 -5860 1040 -5840 {}
L 6 1040 -6100 1040 -5920 {}
L 6 1110 -7390 1230 -7390 {}
L 6 1030 -7540 1270 -7540 {}
L 6 1270 -7420 1410 -7420 {}
L 6 1030 -7300 1030 -7280 {}
L 6 1030 -7540 1030 -7360 {}
L 6 1030 -7280 1270 -7280 {}
L 6 580 -7390 700 -7390 {}
L 6 500 -7540 740 -7540 {}
L 6 740 -7420 880 -7420 {}
L 6 500 -7300 500 -7280 {}
L 6 500 -7540 500 -7360 {}
L 6 500 -7280 740 -7280 {}
L 6 1610 -7390 1730 -7390 {}
L 6 1770 -7450 1770 -7420 {}
L 6 1770 -7540 1770 -7510 {}
L 6 1530 -7540 1770 -7540 {}
L 6 1770 -7420 1910 -7420 {}
L 6 1860 -7360 1860 -7280 {}
L 6 1530 -7300 1530 -7280 {}
L 6 1530 -7540 1530 -7360 {}
L 6 1770 -7390 1770 -7280 {}
L 6 1770 -7280 1860 -7280 {}
L 6 1530 -7280 1770 -7280 {}
L 6 1650 -8690 1770 -8690 {}
L 6 1570 -8840 1810 -8840 {}
L 6 1810 -8720 1950 -8720 {}
L 6 1570 -8580 1810 -8580 {}
L 6 580 -8690 700 -8690 {}
L 6 500 -8840 740 -8840 {}
L 6 740 -8720 880 -8720 {}
L 6 500 -8600 500 -8580 {}
L 6 500 -8840 500 -8660 {}
L 6 500 -8580 740 -8580 {}
L 6 2110 -8690 2230 -8690 {}
L 6 2030 -8840 2270 -8840 {}
L 6 2270 -8720 2410 -8720 {}
L 6 2030 -8580 2270 -8580 {}
L 6 2360 -8660 2360 -8580 {}
L 6 600 -5510 720 -5510 {}
L 6 760 -5570 760 -5540 {}
L 6 760 -5660 760 -5630 {}
L 6 520 -5660 760 -5660 {}
L 6 760 -5540 900 -5540 {}
L 6 850 -5480 850 -5400 {}
L 6 520 -5420 520 -5400 {}
L 6 520 -5660 520 -5480 {}
L 6 760 -5510 760 -5400 {}
L 6 760 -5400 850 -5400 {}
L 6 520 -5400 760 -5400 {}
L 6 1140 -5510 1260 -5510 {}
L 6 1300 -5570 1300 -5540 {}
L 6 1300 -5660 1300 -5630 {}
L 6 1060 -5660 1300 -5660 {}
L 6 1300 -5540 1440 -5540 {}
L 6 1390 -5480 1390 -5400 {}
L 6 1060 -5420 1060 -5400 {}
L 6 1060 -5660 1060 -5480 {}
L 6 1300 -5510 1300 -5400 {}
L 6 1300 -5400 1390 -5400 {}
L 6 1060 -5400 1300 -5400 {}
L 6 1700 -5510 1820 -5510 {}
L 6 1860 -5570 1860 -5540 {}
L 6 1860 -5660 1860 -5630 {}
L 6 1620 -5660 1860 -5660 {}
L 6 1860 -5540 2000 -5540 {}
L 6 1950 -5480 1950 -5400 {}
L 6 1620 -5420 1620 -5400 {}
L 6 1620 -5660 1620 -5480 {}
L 6 1860 -5510 1860 -5400 {}
L 6 1860 -5400 1950 -5400 {}
L 6 1620 -5400 1860 -5400 {}
L 6 2270 -5510 2390 -5510 {}
L 6 2430 -5570 2430 -5540 {}
L 6 2430 -5660 2430 -5630 {}
L 6 2190 -5660 2430 -5660 {}
L 6 2430 -5540 2570 -5540 {}
L 6 2520 -5480 2520 -5400 {}
L 6 2190 -5420 2190 -5400 {}
L 6 2190 -5660 2190 -5480 {}
L 6 2430 -5510 2430 -5400 {}
L 6 2430 -5400 2520 -5400 {}
L 6 2190 -5400 2430 -5400 {}
L 6 600 -4710 720 -4710 {}
L 6 760 -4770 760 -4740 {}
L 6 760 -4860 760 -4830 {}
L 6 760 -4740 900 -4740 {}
L 6 850 -4680 850 -4600 {}
L 6 520 -4620 520 -4600 {}
L 6 520 -4860 520 -4680 {}
L 6 760 -4710 760 -4600 {}
L 6 760 -4600 850 -4600 {}
L 6 520 -4600 760 -4600 {}
L 6 1140 -4710 1260 -4710 {}
L 6 1300 -4770 1300 -4740 {}
L 6 1300 -4860 1300 -4830 {}
L 6 1300 -4740 1440 -4740 {}
L 6 1390 -4680 1390 -4600 {}
L 6 1060 -4620 1060 -4600 {}
L 6 1060 -4860 1060 -4680 {}
L 6 1300 -4710 1300 -4600 {}
L 6 1300 -4600 1390 -4600 {}
L 6 1060 -4600 1300 -4600 {}
L 6 2270 -4710 2390 -4710 {}
L 6 2430 -4770 2430 -4740 {}
L 6 2430 -4860 2430 -4830 {}
L 6 2430 -4740 2570 -4740 {}
L 6 2520 -4680 2520 -4600 {}
L 6 2190 -4620 2190 -4600 {}
L 6 2190 -4860 2190 -4680 {}
L 6 2430 -4710 2430 -4600 {}
L 6 2430 -4600 2520 -4600 {}
L 6 2190 -4600 2430 -4600 {}
L 6 600 -5130 720 -5130 {}
L 6 760 -5190 760 -5160 {}
L 6 760 -5280 760 -5250 {}
L 6 760 -5160 900 -5160 {}
L 6 520 -5040 520 -5020 {}
L 6 760 -5130 760 -5020 {}
L 6 760 -5020 850 -5020 {}
L 6 520 -5020 760 -5020 {}
L 6 600 -4300 720 -4300 {}
L 6 760 -4330 900 -4330 {}
L 6 850 -4270 850 -4190 {}
L 6 520 -4210 520 -4190 {}
L 6 760 -4300 760 -4190 {}
L 6 760 -4190 850 -4190 {}
L 6 520 -4190 760 -4190 {}
L 6 1700 -4300 1820 -4300 {}
L 6 1860 -4330 2000 -4330 {}
L 6 1950 -4270 1950 -4190 {}
L 6 1620 -4210 1620 -4190 {}
L 6 1860 -4300 1860 -4190 {}
L 6 1860 -4190 1950 -4190 {}
L 6 1620 -4190 1860 -4190 {}
L 6 1140 -4300 1260 -4300 {}
L 6 1300 -4330 1440 -4330 {}
L 6 1390 -4270 1390 -4190 {}
L 6 1060 -4210 1060 -4190 {}
L 6 1300 -4300 1300 -4190 {}
L 6 1300 -4190 1390 -4190 {}
L 6 1060 -4190 1300 -4190 {}
L 6 690 -2530 690 -2350 {}
L 6 1230 -2530 1230 -2350 {}
L 6 1880 -2530 1880 -2470 {}
L 6 1880 -2410 1880 -2350 {}
L 6 1110 -8690 1230 -8690 {}
L 6 1030 -8840 1270 -8840 {}
L 6 1270 -8720 1410 -8720 {}
L 6 1030 -8580 1270 -8580 {}
L 6 1030 -8600 1030 -8580 {}
L 6 1030 -8840 1030 -8660 {}
L 6 660 70 780 70 {}
L 6 820 10 820 40 {}
L 6 820 -80 820 -50 {}
L 6 580 -80 820 -80 {}
L 6 820 40 960 40 {}
L 6 910 100 910 180 {}
L 6 580 160 580 180 {}
L 6 580 -80 580 100 {}
L 6 820 70 820 180 {}
L 6 820 180 910 180 {}
L 6 580 180 820 180 {}
L 6 1310 70 1430 70 {}
L 6 1470 10 1470 40 {}
L 6 1470 -80 1470 -50 {}
L 6 1230 -80 1470 -80 {}
L 6 1230 -80 1230 100 {}
L 6 1140 -5130 1260 -5130 {}
L 6 1300 -5190 1300 -5160 {}
L 6 1300 -5280 1300 -5250 {}
L 6 1300 -5160 1440 -5160 {}
L 6 1060 -5040 1060 -5020 {}
L 6 1300 -5130 1300 -5020 {}
L 6 1300 -5020 1390 -5020 {}
L 6 1060 -5020 1300 -5020 {}
L 6 1700 -5130 1820 -5130 {}
L 6 1860 -5190 1860 -5160 {}
L 6 1860 -5280 1860 -5250 {}
L 6 1860 -5160 2000 -5160 {}
L 6 1620 -5040 1620 -5020 {}
L 6 1860 -5130 1860 -5020 {}
L 6 1860 -5020 1950 -5020 {}
L 6 1620 -5020 1860 -5020 {}
L 6 2270 -5130 2390 -5130 {}
L 6 2430 -5190 2430 -5160 {}
L 6 2430 -5280 2430 -5250 {}
L 6 2430 -5160 2570 -5160 {}
L 6 2190 -5040 2190 -5020 {}
L 6 2430 -5130 2430 -5020 {}
L 6 2430 -5020 2520 -5020 {}
L 6 2190 -5020 2430 -5020 {}
L 6 1870 70 1990 70 {}
L 6 2030 10 2030 40 {}
L 6 2030 -80 2030 -50 {}
L 6 1790 -80 2030 -80 {}
L 6 1790 -80 1790 100 {}
L 9 0 -5760 2670 -5760 {dash=4}
L 9 0 -6290 2670 -6290 {dash=4}
L 9 0 -6770 2670 -6770 {dash=4}
L 9 0 -7170 2670 -7170 {dash=4}
L 9 0 -8000 2670 -8000 {dash=4}
L 9 0 -7610 2670 -7610 {dash=4}
L 9 0 -8450 2670 -8450 {dash=4}
L 9 0 -3400 2670 -3400 {dash=4}
L 9 0 -3780 2670 -3780 {dash=4}
L 9 0 -4130 2670 -4130 {dash=4}
L 9 0 -4570 2670 -4570 {dash=4}
L 9 0 -4990 2670 -4990 {dash=4}
L 9 0 -5360 2670 -5360 {dash=4}
L 9 0 -2980 2670 -2980 {dash=4}
L 9 0 -2600 2670 -2600 {dash=4}
L 9 0 -570 2670 -570 {dash=4}
L 9 0 -2280 2670 -2280 {dash=4}
L 9 0 -1340 2670 -1340 {dash=4}
L 9 0 -970 2670 -970 {dash=4}
L 9 0 -170 2670 -170 {dash=4}
L 9 0 260 2670 260 {dash=4}
L 9 0 -2050 2670 -2050 {dash=4}
L 9 0 -1680 2670 -1680 {dash=4}
B 1 1790 -4770 1820 -4620 {}
B 2 660 -8390 860 -8070 {}
B 2 1267.5 -8252.5 1272.5 -8247.5 {name=d dir=inout}
B 2 1227.5 -8222.5 1232.5 -8217.5 {name=g dir=in}
B 2 1267.5 -8192.5 1272.5 -8187.5 {name=s dir=inout}
B 2 1267.5 -8222.5 1272.5 -8217.5 {name=b dir=in}
B 2 1267.5 -8342.5 1272.5 -8337.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -8282.5 1272.5 -8277.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -8252.5 1362.5 -8247.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -8192.5 1362.5 -8187.5 {name=m dir=inout pinnumber=2}
B 2 2047.5 -8262.5 2052.5 -8257.5 {name=d dir=inout}
B 2 2007.5 -8232.5 2012.5 -8227.5 {name=g dir=in}
B 2 2047.5 -8202.5 2052.5 -8197.5 {name=s dir=inout}
B 2 2047.5 -8232.5 2052.5 -8227.5 {name=b dir=in}
B 2 2047.5 -8352.5 2052.5 -8347.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2047.5 -8292.5 2052.5 -8287.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2137.5 -8262.5 2142.5 -8257.5 {name=p dir=inout pinnumber=1}
B 2 2137.5 -8202.5 2142.5 -8197.5 {name=m dir=inout pinnumber=2}
B 2 1357.5 -7882.5 1362.5 -7877.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -7822.5 1362.5 -7817.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -7052.5 1362.5 -7047.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -6992.5 1362.5 -6987.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -6562.5 1362.5 -6557.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -6502.5 1362.5 -6497.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 660 -6130 900 -5810 {}
B 2 737.5 -8252.5 742.5 -8247.5 {name=d dir=inout}
B 2 737.5 -8192.5 742.5 -8187.5 {name=s dir=inout}
B 2 737.5 -8222.5 742.5 -8217.5 {name=b dir=in}
B 2 737.5 -8342.5 742.5 -8337.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -8282.5 742.5 -8277.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -8252.5 832.5 -8247.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -8192.5 832.5 -8187.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -5982.5 742.5 -5977.5 {name=d dir=inout}
B 2 737.5 -5922.5 742.5 -5917.5 {name=s dir=inout}
B 2 737.5 -5952.5 742.5 -5947.5 {name=b dir=in}
B 2 737.5 -6072.5 742.5 -6067.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -6012.5 742.5 -6007.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -5982.5 832.5 -5977.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -5922.5 832.5 -5917.5 {name=m dir=inout pinnumber=2}
B 2 878.75 -5981.25 881.25 -5978.75 {name=p dir=in}
B 2 1277.5 -5982.5 1282.5 -5977.5 {name=d dir=inout}
B 2 1237.5 -5952.5 1242.5 -5947.5 {name=g dir=in}
B 2 1277.5 -5922.5 1282.5 -5917.5 {name=s dir=inout}
B 2 1277.5 -5952.5 1282.5 -5947.5 {name=b dir=in}
B 2 1277.5 -6072.5 1282.5 -6067.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1277.5 -6012.5 1282.5 -6007.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1367.5 -5982.5 1372.5 -5977.5 {name=p dir=inout pinnumber=1}
B 2 1367.5 -5922.5 1372.5 -5917.5 {name=m dir=inout pinnumber=2}
B 2 1418.75 -5981.25 1421.25 -5978.75 {name=p dir=in}
B 2 2117.5 -5982.5 2122.5 -5977.5 {name=d dir=inout}
B 2 2077.5 -5952.5 2082.5 -5947.5 {name=g dir=in}
B 2 2117.5 -5922.5 2122.5 -5917.5 {name=s dir=inout}
B 2 2117.5 -5952.5 2122.5 -5947.5 {name=b dir=in}
B 2 2117.5 -6072.5 2122.5 -6067.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2117.5 -6012.5 2122.5 -6007.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2207.5 -5982.5 2212.5 -5977.5 {name=p dir=inout pinnumber=1}
B 2 2207.5 -5922.5 2212.5 -5917.5 {name=m dir=inout pinnumber=2}
B 2 2258.75 -5981.25 2261.25 -5978.75 {name=p dir=in}
B 2 660 -7560 860 -7240 {}
B 2 1267.5 -7422.5 1272.5 -7417.5 {name=d dir=inout}
B 2 1227.5 -7392.5 1232.5 -7387.5 {name=g dir=in}
B 2 1267.5 -7362.5 1272.5 -7357.5 {name=s dir=inout}
B 2 1267.5 -7392.5 1272.5 -7387.5 {name=b dir=in}
B 2 1267.5 -7512.5 1272.5 -7507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -7452.5 1272.5 -7447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -7422.5 1362.5 -7417.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -7362.5 1362.5 -7357.5 {name=m dir=inout pinnumber=2}
B 2 2047.5 -7432.5 2052.5 -7427.5 {name=d dir=inout}
B 2 2007.5 -7402.5 2012.5 -7397.5 {name=g dir=in}
B 2 2047.5 -7372.5 2052.5 -7367.5 {name=s dir=inout}
B 2 2047.5 -7402.5 2052.5 -7397.5 {name=b dir=in}
B 2 2047.5 -7522.5 2052.5 -7517.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2047.5 -7462.5 2052.5 -7457.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2137.5 -7432.5 2142.5 -7427.5 {name=p dir=inout pinnumber=1}
B 2 2137.5 -7372.5 2142.5 -7367.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -7422.5 742.5 -7417.5 {name=d dir=inout}
B 2 737.5 -7362.5 742.5 -7357.5 {name=s dir=inout}
B 2 737.5 -7392.5 742.5 -7387.5 {name=b dir=in}
B 2 737.5 -7512.5 742.5 -7507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -7452.5 742.5 -7447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -7422.5 832.5 -7417.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -7362.5 832.5 -7357.5 {name=m dir=inout pinnumber=2}
B 2 660 -8860 860 -8540 {}
B 2 1807.5 -8722.5 1812.5 -8717.5 {name=d dir=inout}
B 2 1767.5 -8692.5 1772.5 -8687.5 {name=g dir=in}
B 2 1807.5 -8662.5 1812.5 -8657.5 {name=s dir=inout}
B 2 1807.5 -8692.5 1812.5 -8687.5 {name=b dir=in}
B 2 1807.5 -8812.5 1812.5 -8807.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1807.5 -8752.5 1812.5 -8747.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -8722.5 1902.5 -8717.5 {name=p dir=inout pinnumber=1}
B 2 1897.5 -8662.5 1902.5 -8657.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -8722.5 742.5 -8717.5 {name=d dir=inout}
B 2 737.5 -8662.5 742.5 -8657.5 {name=s dir=inout}
B 2 737.5 -8692.5 742.5 -8687.5 {name=b dir=in}
B 2 737.5 -8812.5 742.5 -8807.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -8752.5 742.5 -8747.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -8722.5 832.5 -8717.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -8662.5 832.5 -8657.5 {name=m dir=inout pinnumber=2}
B 2 1530 -8850 1610 -8570 {}
B 2 1567.5 -8662.5 1572.5 -8657.5 {name=p dir=inout}
B 2 1567.5 -8602.5 1572.5 -8597.5 {name=m dir=inout}
B 2 2267.5 -8722.5 2272.5 -8717.5 {name=d dir=inout}
B 2 2227.5 -8692.5 2232.5 -8687.5 {name=g dir=in}
B 2 2267.5 -8662.5 2272.5 -8657.5 {name=s dir=inout}
B 2 2267.5 -8692.5 2272.5 -8687.5 {name=b dir=in}
B 2 2267.5 -8812.5 2272.5 -8807.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2267.5 -8752.5 2272.5 -8747.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2027.5 -8662.5 2032.5 -8657.5 {name=p dir=inout}
B 2 2027.5 -8602.5 2032.5 -8597.5 {name=m dir=inout}
B 2 2320 -8740 2390 -8560 {}
B 2 1670 -4800 1820 -4770 {}
B 2 460 -4490 800 -4340 {}
B 2 757.5 -4422.5 762.5 -4417.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 757.5 -4362.5 762.5 -4357.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 627.5 -4452.5 632.5 -4447.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1857.5 -4452.5 1862.5 -4447.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1857.5 -4392.5 1862.5 -4387.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1727.5 -4482.5 1732.5 -4477.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1297.5 -4422.5 1302.5 -4417.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1297.5 -4362.5 1302.5 -4357.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1167.5 -4452.5 1172.5 -4447.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1357.5 -3562.5 1362.5 -3557.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -3502.5 1362.5 -3497.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -3882.5 1362.5 -3877.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -3942.5 1362.5 -3937.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -3882.5 1362.5 -3877.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -3942.5 1362.5 -3937.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1777.5 -3882.5 1782.5 -3877.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1777.5 -3942.5 1782.5 -3937.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1210 -2890 1500 -2820 {}
B 2 2377.5 -3882.5 2382.5 -3877.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2377.5 -3942.5 2382.5 -3937.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1210 -810 1500 -730 {}
B 2 1247.5 -802.5 1252.5 -797.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1247.5 -742.5 1252.5 -737.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -802.5 1362.5 -797.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -742.5 1362.5 -737.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1467.5 -802.5 1472.5 -797.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1467.5 -742.5 1472.5 -737.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1787.5 -852.5 1792.5 -847.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1787.5 -792.5 1792.5 -787.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -852.5 1902.5 -847.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1897.5 -792.5 1902.5 -787.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2007.5 -852.5 2012.5 -847.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2007.5 -792.5 2012.5 -787.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 647.5 -2472.5 652.5 -2467.5 {name=d dir=inout}
B 2 607.5 -2442.5 612.5 -2437.5 {name=g dir=in}
B 2 647.5 -2412.5 652.5 -2407.5 {name=s dir=inout}
B 2 647.5 -2442.5 652.5 -2437.5 {name=b dir=in}
B 2 1227.5 -2472.5 1232.5 -2467.5 {name=d dir=inout}
B 2 1187.5 -2442.5 1192.5 -2437.5 {name=g dir=in}
B 2 1227.5 -2412.5 1232.5 -2407.5 {name=s dir=inout}
B 2 1227.5 -2442.5 1232.5 -2437.5 {name=b dir=in}
B 2 1267.5 -8722.5 1272.5 -8717.5 {name=d dir=inout}
B 2 1227.5 -8692.5 1232.5 -8687.5 {name=g dir=in}
B 2 1267.5 -8662.5 1272.5 -8657.5 {name=s dir=inout}
B 2 1267.5 -8692.5 1272.5 -8687.5 {name=b dir=in}
B 2 1267.5 -8812.5 1272.5 -8807.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -8752.5 1272.5 -8747.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -8722.5 1362.5 -8717.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -8662.5 1362.5 -8657.5 {name=m dir=inout pinnumber=2}
B 2 1210 -430 1500 -350 {}
B 2 1247.5 -422.5 1252.5 -417.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1247.5 -362.5 1252.5 -357.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -422.5 1362.5 -417.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -362.5 1362.5 -357.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1467.5 -422.5 1472.5 -417.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1467.5 -362.5 1472.5 -357.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1787.5 -472.5 1792.5 -467.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1787.5 -412.5 1792.5 -407.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -472.5 1902.5 -467.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1897.5 -412.5 1902.5 -407.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2007.5 -472.5 2012.5 -467.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2007.5 -412.5 2012.5 -407.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 677.5 -1242.5 682.5 -1237.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 677.5 -1182.5 682.5 -1177.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 797.5 -1242.5 802.5 -1237.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1217.5 -1242.5 1222.5 -1237.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1217.5 -1182.5 1222.5 -1177.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1337.5 -1242.5 1342.5 -1237.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1337.5 -1182.5 1342.5 -1177.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1557.5 37.5 1562.5 42.5 {name=p dir=inout pinnumber=1}
B 2 1557.5 97.5 1562.5 102.5 {name=m dir=inout pinnumber=2}
B 2 2427.5 -142.5 2432.5 -137.5 {name=p dir=inout pinnumber=1}
B 2 2427.5 -82.5 2432.5 -77.5 {name=m dir=inout pinnumber=2}
B 5 1027.5 -8192.5 1032.5 -8187.5 {name=p dir=inout}
B 5 1027.5 -8132.5 1032.5 -8127.5 {name=m dir=inout}
B 5 1108.75 -8221.25 1111.25 -8218.75 {name=p dir=out}
B 5 1137.5 -8112.5 1142.5 -8107.5 {name=p dir=inout goto=0}
B 5 1137.5 -8372.5 1142.5 -8367.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -8251.25 1411.25 -8248.75 {name=p dir=in}
B 5 1567.5 -8192.5 1572.5 -8187.5 {name=p dir=inout}
B 5 1567.5 -8132.5 1572.5 -8127.5 {name=m dir=inout}
B 5 1648.75 -8221.25 1651.25 -8218.75 {name=p dir=out}
B 5 1677.5 -8112.5 1682.5 -8107.5 {name=p dir=inout goto=0}
B 5 1677.5 -8372.5 1682.5 -8367.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1948.75 -8251.25 1951.25 -8248.75 {name=p dir=in}
B 5 697.5 -8222.5 702.5 -8217.5 {name=g dir=in}
B 5 497.5 -8192.5 502.5 -8187.5 {name=p dir=inout}
B 5 497.5 -8132.5 502.5 -8127.5 {name=m dir=inout}
B 5 578.75 -8221.25 581.25 -8218.75 {name=p dir=out}
B 5 607.5 -8112.5 612.5 -8107.5 {name=p dir=inout goto=0}
B 5 607.5 -8372.5 612.5 -8367.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -8251.25 881.25 -8248.75 {name=p dir=in}
B 5 737.5 -7792.5 742.5 -7787.5 {name=d dir=inout}
B 5 697.5 -7762.5 702.5 -7757.5 {name=g dir=in}
B 5 737.5 -7732.5 742.5 -7727.5 {name=s dir=inout}
B 5 737.5 -7762.5 742.5 -7757.5 {name=b dir=in}
B 5 737.5 -7882.5 742.5 -7877.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -7822.5 742.5 -7817.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -7792.5 832.5 -7787.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -7732.5 832.5 -7727.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -7732.5 502.5 -7727.5 {name=p dir=inout}
B 5 497.5 -7672.5 502.5 -7667.5 {name=m dir=inout}
B 5 578.75 -7761.25 581.25 -7758.75 {name=p dir=out}
B 5 607.5 -7652.5 612.5 -7647.5 {name=p dir=inout goto=0}
B 5 607.5 -7912.5 612.5 -7907.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -7791.25 881.25 -7788.75 {name=p dir=in}
B 5 1277.5 -7792.5 1282.5 -7787.5 {name=d dir=inout}
B 5 1237.5 -7762.5 1242.5 -7757.5 {name=g dir=in}
B 5 1277.5 -7732.5 1282.5 -7727.5 {name=s dir=inout}
B 5 1277.5 -7762.5 1282.5 -7757.5 {name=b dir=in}
B 5 1367.5 -7792.5 1372.5 -7787.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -7732.5 1372.5 -7727.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -7732.5 1042.5 -7727.5 {name=p dir=inout}
B 5 1037.5 -7672.5 1042.5 -7667.5 {name=m dir=inout}
B 5 1118.75 -7761.25 1121.25 -7758.75 {name=p dir=out}
B 5 1147.5 -7652.5 1152.5 -7647.5 {name=p dir=inout goto=0}
B 5 1147.5 -7912.5 1152.5 -7907.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -7791.25 1421.25 -7788.75 {name=p dir=in}
B 5 737.5 -6962.5 742.5 -6957.5 {name=d dir=inout}
B 5 697.5 -6932.5 702.5 -6927.5 {name=g dir=in}
B 5 737.5 -6902.5 742.5 -6897.5 {name=s dir=inout}
B 5 737.5 -6932.5 742.5 -6927.5 {name=b dir=in}
B 5 737.5 -7052.5 742.5 -7047.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -6992.5 742.5 -6987.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -6962.5 832.5 -6957.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -6902.5 832.5 -6897.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -6902.5 502.5 -6897.5 {name=p dir=inout}
B 5 497.5 -6842.5 502.5 -6837.5 {name=m dir=inout}
B 5 578.75 -6931.25 581.25 -6928.75 {name=p dir=out}
B 5 607.5 -6822.5 612.5 -6817.5 {name=p dir=inout goto=0}
B 5 607.5 -7082.5 612.5 -7077.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -6961.25 881.25 -6958.75 {name=p dir=in}
B 5 1277.5 -6962.5 1282.5 -6957.5 {name=d dir=inout}
B 5 1237.5 -6932.5 1242.5 -6927.5 {name=g dir=in}
B 5 1277.5 -6902.5 1282.5 -6897.5 {name=s dir=inout}
B 5 1277.5 -6932.5 1282.5 -6927.5 {name=b dir=in}
B 5 1367.5 -6962.5 1372.5 -6957.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -6902.5 1372.5 -6897.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -6902.5 1042.5 -6897.5 {name=p dir=inout}
B 5 1037.5 -6842.5 1042.5 -6837.5 {name=m dir=inout}
B 5 1118.75 -6931.25 1121.25 -6928.75 {name=p dir=out}
B 5 1147.5 -6822.5 1152.5 -6817.5 {name=p dir=inout goto=0}
B 5 1147.5 -7082.5 1152.5 -7077.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -6961.25 1421.25 -6958.75 {name=p dir=in}
B 5 737.5 -6472.5 742.5 -6467.5 {name=d dir=inout}
B 5 697.5 -6442.5 702.5 -6437.5 {name=g dir=in}
B 5 737.5 -6412.5 742.5 -6407.5 {name=s dir=inout}
B 5 737.5 -6442.5 742.5 -6437.5 {name=b dir=in}
B 5 737.5 -6562.5 742.5 -6557.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -6502.5 742.5 -6497.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -6472.5 832.5 -6467.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -6412.5 832.5 -6407.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -6412.5 502.5 -6407.5 {name=p dir=inout}
B 5 497.5 -6352.5 502.5 -6347.5 {name=m dir=inout}
B 5 578.75 -6441.25 581.25 -6438.75 {name=p dir=out}
B 5 607.5 -6332.5 612.5 -6327.5 {name=p dir=inout goto=0}
B 5 607.5 -6592.5 612.5 -6587.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -6471.25 881.25 -6468.75 {name=p dir=in}
B 5 1277.5 -6472.5 1282.5 -6467.5 {name=d dir=inout}
B 5 1237.5 -6442.5 1242.5 -6437.5 {name=g dir=in}
B 5 1277.5 -6412.5 1282.5 -6407.5 {name=s dir=inout}
B 5 1277.5 -6442.5 1282.5 -6437.5 {name=b dir=in}
B 5 1367.5 -6472.5 1372.5 -6467.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -6412.5 1372.5 -6407.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -6412.5 1042.5 -6407.5 {name=p dir=inout}
B 5 1037.5 -6352.5 1042.5 -6347.5 {name=m dir=inout}
B 5 1118.75 -6441.25 1121.25 -6438.75 {name=p dir=out}
B 5 1147.5 -6332.5 1152.5 -6327.5 {name=p dir=inout goto=0}
B 5 1147.5 -6592.5 1152.5 -6587.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -6471.25 1421.25 -6468.75 {name=p dir=in}
B 5 697.5 -5952.5 702.5 -5947.5 {name=g dir=in}
B 5 497.5 -5922.5 502.5 -5917.5 {name=p dir=inout}
B 5 497.5 -5862.5 502.5 -5857.5 {name=m dir=inout}
B 5 578.75 -5951.25 581.25 -5948.75 {name=p dir=out}
B 5 607.5 -5842.5 612.5 -5837.5 {name=p dir=inout goto=0}
B 5 607.5 -6102.5 612.5 -6097.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1687.5 -5922.5 1692.5 -5917.5 {name=p dir=inout}
B 5 1687.5 -5862.5 1692.5 -5857.5 {name=m dir=inout}
B 5 1768.75 -5951.25 1771.25 -5948.75 {name=p dir=out}
B 5 1797.5 -5842.5 1802.5 -5837.5 {name=p dir=inout goto=0}
B 5 1797.5 -6102.5 1802.5 -6097.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1037.5 -5922.5 1042.5 -5917.5 {name=p dir=inout}
B 5 1037.5 -5862.5 1042.5 -5857.5 {name=m dir=inout}
B 5 1118.75 -5951.25 1121.25 -5948.75 {name=p dir=out}
B 5 1147.5 -5842.5 1152.5 -5837.5 {name=p dir=inout goto=0}
B 5 1147.5 -6102.5 1152.5 -6097.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1027.5 -7362.5 1032.5 -7357.5 {name=p dir=inout}
B 5 1027.5 -7302.5 1032.5 -7297.5 {name=m dir=inout}
B 5 1108.75 -7391.25 1111.25 -7388.75 {name=p dir=out}
B 5 1137.5 -7282.5 1142.5 -7277.5 {name=p dir=inout goto=0}
B 5 1137.5 -7542.5 1142.5 -7537.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -7421.25 1411.25 -7418.75 {name=p dir=in}
B 5 697.5 -7392.5 702.5 -7387.5 {name=g dir=in}
B 5 497.5 -7362.5 502.5 -7357.5 {name=p dir=inout}
B 5 497.5 -7302.5 502.5 -7297.5 {name=m dir=inout}
B 5 578.75 -7391.25 581.25 -7388.75 {name=p dir=out}
B 5 607.5 -7282.5 612.5 -7277.5 {name=p dir=inout goto=0}
B 5 607.5 -7542.5 612.5 -7537.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -7421.25 881.25 -7418.75 {name=p dir=in}
B 5 1767.5 -7422.5 1772.5 -7417.5 {name=d dir=inout}
B 5 1727.5 -7392.5 1732.5 -7387.5 {name=g dir=in}
B 5 1767.5 -7362.5 1772.5 -7357.5 {name=s dir=inout}
B 5 1767.5 -7392.5 1772.5 -7387.5 {name=b dir=in}
B 5 1767.5 -7512.5 1772.5 -7507.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1767.5 -7452.5 1772.5 -7447.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1857.5 -7422.5 1862.5 -7417.5 {name=p dir=inout pinnumber=1}
B 5 1857.5 -7362.5 1862.5 -7357.5 {name=m dir=inout pinnumber=2}
B 5 1527.5 -7362.5 1532.5 -7357.5 {name=p dir=inout}
B 5 1527.5 -7302.5 1532.5 -7297.5 {name=m dir=inout}
B 5 1608.75 -7391.25 1611.25 -7388.75 {name=p dir=out}
B 5 1637.5 -7282.5 1642.5 -7277.5 {name=p dir=inout goto=0}
B 5 1637.5 -7542.5 1642.5 -7537.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1908.75 -7421.25 1911.25 -7418.75 {name=p dir=in}
B 5 1648.75 -8691.25 1651.25 -8688.75 {name=p dir=out}
B 5 1677.5 -8582.5 1682.5 -8577.5 {name=p dir=inout goto=0}
B 5 1677.5 -8842.5 1682.5 -8837.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1948.75 -8721.25 1951.25 -8718.75 {name=p dir=in}
B 5 697.5 -8692.5 702.5 -8687.5 {name=g dir=in}
B 5 497.5 -8662.5 502.5 -8657.5 {name=p dir=inout}
B 5 497.5 -8602.5 502.5 -8597.5 {name=m dir=inout}
B 5 578.75 -8691.25 581.25 -8688.75 {name=p dir=out}
B 5 607.5 -8582.5 612.5 -8577.5 {name=p dir=inout goto=0}
B 5 607.5 -8842.5 612.5 -8837.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -8721.25 881.25 -8718.75 {name=p dir=in}
B 5 2108.75 -8691.25 2111.25 -8688.75 {name=p dir=out}
B 5 2137.5 -8582.5 2142.5 -8577.5 {name=p dir=inout goto=0}
B 5 2137.5 -8842.5 2142.5 -8837.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2408.75 -8721.25 2411.25 -8718.75 {name=p dir=in}
B 5 2357.5 -8722.5 2362.5 -8717.5 {name=p dir=inout pinnumber=1}
B 5 2357.5 -8662.5 2362.5 -8657.5 {name=m dir=inout pinnumber=2}
B 5 757.5 -5542.5 762.5 -5537.5 {name=d dir=inout}
B 5 717.5 -5512.5 722.5 -5507.5 {name=g dir=in}
B 5 757.5 -5482.5 762.5 -5477.5 {name=s dir=inout}
B 5 757.5 -5512.5 762.5 -5507.5 {name=b dir=in}
B 5 757.5 -5632.5 762.5 -5627.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -5572.5 762.5 -5567.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 847.5 -5542.5 852.5 -5537.5 {name=p dir=inout pinnumber=1}
B 5 847.5 -5482.5 852.5 -5477.5 {name=m dir=inout pinnumber=2}
B 5 517.5 -5482.5 522.5 -5477.5 {name=p dir=inout}
B 5 517.5 -5422.5 522.5 -5417.5 {name=m dir=inout}
B 5 598.75 -5511.25 601.25 -5508.75 {name=p dir=out}
B 5 627.5 -5402.5 632.5 -5397.5 {name=p dir=inout goto=0}
B 5 627.5 -5662.5 632.5 -5657.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 898.75 -5541.25 901.25 -5538.75 {name=p dir=in}
B 5 1297.5 -5542.5 1302.5 -5537.5 {name=d dir=inout}
B 5 1257.5 -5512.5 1262.5 -5507.5 {name=g dir=in}
B 5 1297.5 -5482.5 1302.5 -5477.5 {name=s dir=inout}
B 5 1297.5 -5512.5 1302.5 -5507.5 {name=b dir=in}
B 5 1297.5 -5632.5 1302.5 -5627.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1297.5 -5572.5 1302.5 -5567.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1387.5 -5542.5 1392.5 -5537.5 {name=p dir=inout pinnumber=1}
B 5 1387.5 -5482.5 1392.5 -5477.5 {name=m dir=inout pinnumber=2}
B 5 1057.5 -5482.5 1062.5 -5477.5 {name=p dir=inout}
B 5 1057.5 -5422.5 1062.5 -5417.5 {name=m dir=inout}
B 5 1138.75 -5511.25 1141.25 -5508.75 {name=p dir=out}
B 5 1167.5 -5402.5 1172.5 -5397.5 {name=p dir=inout goto=0}
B 5 1167.5 -5662.5 1172.5 -5657.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1438.75 -5541.25 1441.25 -5538.75 {name=p dir=in}
B 5 1857.5 -5542.5 1862.5 -5537.5 {name=d dir=inout}
B 5 1817.5 -5512.5 1822.5 -5507.5 {name=g dir=in}
B 5 1857.5 -5482.5 1862.5 -5477.5 {name=s dir=inout}
B 5 1857.5 -5512.5 1862.5 -5507.5 {name=b dir=in}
B 5 1857.5 -5632.5 1862.5 -5627.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1857.5 -5572.5 1862.5 -5567.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1947.5 -5542.5 1952.5 -5537.5 {name=p dir=inout pinnumber=1}
B 5 1947.5 -5482.5 1952.5 -5477.5 {name=m dir=inout pinnumber=2}
B 5 1617.5 -5482.5 1622.5 -5477.5 {name=p dir=inout}
B 5 1617.5 -5422.5 1622.5 -5417.5 {name=m dir=inout}
B 5 1698.75 -5511.25 1701.25 -5508.75 {name=p dir=out}
B 5 1727.5 -5402.5 1732.5 -5397.5 {name=p dir=inout goto=0}
B 5 1727.5 -5662.5 1732.5 -5657.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1998.75 -5541.25 2001.25 -5538.75 {name=p dir=in}
B 5 2427.5 -5542.5 2432.5 -5537.5 {name=d dir=inout}
B 5 2387.5 -5512.5 2392.5 -5507.5 {name=g dir=in}
B 5 2427.5 -5482.5 2432.5 -5477.5 {name=s dir=inout}
B 5 2427.5 -5512.5 2432.5 -5507.5 {name=b dir=in}
B 5 2427.5 -5632.5 2432.5 -5627.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -5572.5 2432.5 -5567.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2517.5 -5542.5 2522.5 -5537.5 {name=p dir=inout pinnumber=1}
B 5 2517.5 -5482.5 2522.5 -5477.5 {name=m dir=inout pinnumber=2}
B 5 2187.5 -5482.5 2192.5 -5477.5 {name=p dir=inout}
B 5 2187.5 -5422.5 2192.5 -5417.5 {name=m dir=inout}
B 5 2268.75 -5511.25 2271.25 -5508.75 {name=p dir=out}
B 5 2297.5 -5402.5 2302.5 -5397.5 {name=p dir=inout goto=0}
B 5 2297.5 -5662.5 2302.5 -5657.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2568.75 -5541.25 2571.25 -5538.75 {name=p dir=in}
B 5 757.5 -4742.5 762.5 -4737.5 {name=d dir=inout}
B 5 717.5 -4712.5 722.5 -4707.5 {name=g dir=in}
B 5 757.5 -4682.5 762.5 -4677.5 {name=s dir=inout}
B 5 757.5 -4712.5 762.5 -4707.5 {name=b dir=in}
B 5 757.5 -4832.5 762.5 -4827.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -4772.5 762.5 -4767.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 847.5 -4742.5 852.5 -4737.5 {name=p dir=inout pinnumber=1}
B 5 847.5 -4682.5 852.5 -4677.5 {name=m dir=inout pinnumber=2}
B 5 517.5 -4682.5 522.5 -4677.5 {name=p dir=inout}
B 5 517.5 -4622.5 522.5 -4617.5 {name=m dir=inout}
B 5 598.75 -4711.25 601.25 -4708.75 {name=p dir=out}
B 5 627.5 -4602.5 632.5 -4597.5 {name=p dir=inout goto=0}
B 5 627.5 -4862.5 632.5 -4857.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 898.75 -4741.25 901.25 -4738.75 {name=p dir=in}
B 5 1297.5 -4742.5 1302.5 -4737.5 {name=d dir=inout}
B 5 1257.5 -4712.5 1262.5 -4707.5 {name=g dir=in}
B 5 1297.5 -4682.5 1302.5 -4677.5 {name=s dir=inout}
B 5 1297.5 -4712.5 1302.5 -4707.5 {name=b dir=in}
B 5 1297.5 -4832.5 1302.5 -4827.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1297.5 -4772.5 1302.5 -4767.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1387.5 -4742.5 1392.5 -4737.5 {name=p dir=inout pinnumber=1}
B 5 1387.5 -4682.5 1392.5 -4677.5 {name=m dir=inout pinnumber=2}
B 5 1057.5 -4682.5 1062.5 -4677.5 {name=p dir=inout}
B 5 1057.5 -4622.5 1062.5 -4617.5 {name=m dir=inout}
B 5 1138.75 -4711.25 1141.25 -4708.75 {name=p dir=out}
B 5 1167.5 -4602.5 1172.5 -4597.5 {name=p dir=inout goto=0}
B 5 1167.5 -4862.5 1172.5 -4857.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1438.75 -4741.25 1441.25 -4738.75 {name=p dir=in}
B 5 2427.5 -4742.5 2432.5 -4737.5 {name=d dir=inout}
B 5 2387.5 -4712.5 2392.5 -4707.5 {name=g dir=in}
B 5 2427.5 -4682.5 2432.5 -4677.5 {name=s dir=inout}
B 5 2427.5 -4712.5 2432.5 -4707.5 {name=b dir=in}
B 5 2427.5 -4832.5 2432.5 -4827.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -4772.5 2432.5 -4767.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2517.5 -4742.5 2522.5 -4737.5 {name=p dir=inout pinnumber=1}
B 5 2517.5 -4682.5 2522.5 -4677.5 {name=m dir=inout pinnumber=2}
B 5 2187.5 -4682.5 2192.5 -4677.5 {name=p dir=inout}
B 5 2187.5 -4622.5 2192.5 -4617.5 {name=m dir=inout}
B 5 2268.75 -4711.25 2271.25 -4708.75 {name=p dir=out}
B 5 2297.5 -4602.5 2302.5 -4597.5 {name=p dir=inout goto=0}
B 5 2297.5 -4862.5 2302.5 -4857.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2568.75 -4741.25 2571.25 -4738.75 {name=p dir=in}
B 5 757.5 -5162.5 762.5 -5157.5 {name=d dir=inout}
B 5 717.5 -5132.5 722.5 -5127.5 {name=g dir=in}
B 5 757.5 -5102.5 762.5 -5097.5 {name=s dir=inout}
B 5 757.5 -5132.5 762.5 -5127.5 {name=b dir=in}
B 5 757.5 -5252.5 762.5 -5247.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -5192.5 762.5 -5187.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 847.5 -5162.5 852.5 -5157.5 {name=p dir=inout pinnumber=1}
B 5 847.5 -5102.5 852.5 -5097.5 {name=m dir=inout pinnumber=2}
B 5 517.5 -5102.5 522.5 -5097.5 {name=p dir=inout}
B 5 517.5 -5042.5 522.5 -5037.5 {name=m dir=inout}
B 5 598.75 -5131.25 601.25 -5128.75 {name=p dir=out}
B 5 627.5 -5022.5 632.5 -5017.5 {name=p dir=inout goto=0}
B 5 627.5 -5282.5 632.5 -5277.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 898.75 -5161.25 901.25 -5158.75 {name=p dir=in}
B 5 757.5 -4332.5 762.5 -4327.5 {name=d dir=inout}
B 5 717.5 -4302.5 722.5 -4297.5 {name=g dir=in}
B 5 757.5 -4272.5 762.5 -4267.5 {name=s dir=inout}
B 5 757.5 -4302.5 762.5 -4297.5 {name=b dir=in}
B 5 847.5 -4332.5 852.5 -4327.5 {name=p dir=inout pinnumber=1}
B 5 847.5 -4272.5 852.5 -4267.5 {name=m dir=inout pinnumber=2}
B 5 517.5 -4272.5 522.5 -4267.5 {name=p dir=inout}
B 5 517.5 -4212.5 522.5 -4207.5 {name=m dir=inout}
B 5 598.75 -4301.25 601.25 -4298.75 {name=p dir=out}
B 5 627.5 -4192.5 632.5 -4187.5 {name=p dir=inout goto=0}
B 5 898.75 -4331.25 901.25 -4328.75 {name=p dir=in}
B 5 1857.5 -4332.5 1862.5 -4327.5 {name=d dir=inout}
B 5 1817.5 -4302.5 1822.5 -4297.5 {name=g dir=in}
B 5 1857.5 -4272.5 1862.5 -4267.5 {name=s dir=inout}
B 5 1857.5 -4302.5 1862.5 -4297.5 {name=b dir=in}
B 5 1947.5 -4332.5 1952.5 -4327.5 {name=p dir=inout pinnumber=1}
B 5 1947.5 -4272.5 1952.5 -4267.5 {name=m dir=inout pinnumber=2}
B 5 1617.5 -4272.5 1622.5 -4267.5 {name=p dir=inout}
B 5 1617.5 -4212.5 1622.5 -4207.5 {name=m dir=inout}
B 5 1698.75 -4301.25 1701.25 -4298.75 {name=p dir=out}
B 5 1727.5 -4192.5 1732.5 -4187.5 {name=p dir=inout goto=0}
B 5 1998.75 -4331.25 2001.25 -4328.75 {name=p dir=in}
B 5 1297.5 -4332.5 1302.5 -4327.5 {name=d dir=inout}
B 5 1257.5 -4302.5 1262.5 -4297.5 {name=g dir=in}
B 5 1297.5 -4272.5 1302.5 -4267.5 {name=s dir=inout}
B 5 1297.5 -4302.5 1302.5 -4297.5 {name=b dir=in}
B 5 1387.5 -4332.5 1392.5 -4327.5 {name=p dir=inout pinnumber=1}
B 5 1387.5 -4272.5 1392.5 -4267.5 {name=m dir=inout pinnumber=2}
B 5 1057.5 -4272.5 1062.5 -4267.5 {name=p dir=inout}
B 5 1057.5 -4212.5 1062.5 -4207.5 {name=m dir=inout}
B 5 1138.75 -4301.25 1141.25 -4298.75 {name=p dir=out}
B 5 1167.5 -4192.5 1172.5 -4187.5 {name=p dir=inout goto=0}
B 5 1438.75 -4331.25 1441.25 -4328.75 {name=p dir=in}
B 5 817.5 -3562.5 822.5 -3557.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -3502.5 822.5 -3497.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -3502.5 822.5 -3497.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -3442.5 822.5 -3437.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -3442.5 1362.5 -3437.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -3602.5 1902.5 -3597.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -3542.5 1902.5 -3537.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -3502.5 1902.5 -3497.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -3442.5 1902.5 -3437.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -3882.5 822.5 -3877.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -3822.5 822.5 -3817.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -3942.5 822.5 -3937.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -3882.5 822.5 -3877.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -4002.5 822.5 -3997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -3942.5 822.5 -3937.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -3822.5 1362.5 -3817.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -4002.5 1362.5 -3997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -3822.5 1902.5 -3817.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -3882.5 1902.5 -3877.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -4002.5 1902.5 -3997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -3942.5 1902.5 -3937.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -2732.5 712.5 -2727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -2672.5 712.5 -2667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -2732.5 822.5 -2727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -2672.5 822.5 -2667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -2732.5 932.5 -2727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -2672.5 932.5 -2667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -2732.5 1252.5 -2727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -2672.5 1252.5 -2667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -2732.5 1362.5 -2727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -2672.5 1362.5 -2667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -2732.5 1472.5 -2727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -2672.5 1472.5 -2667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -2732.5 1792.5 -2727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -2672.5 1792.5 -2667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -2732.5 1902.5 -2727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -2672.5 1902.5 -2667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -2732.5 2012.5 -2727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -2672.5 2012.5 -2667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2317.5 -2732.5 2322.5 -2727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2317.5 -2672.5 2322.5 -2667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2427.5 -2732.5 2432.5 -2727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -2672.5 2432.5 -2667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2537.5 -2732.5 2542.5 -2727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2537.5 -2672.5 2542.5 -2667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2497.5 -3822.5 2502.5 -3817.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2497.5 -3882.5 2502.5 -3877.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2497.5 -4002.5 2502.5 -3997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2497.5 -3942.5 2502.5 -3937.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -802.5 712.5 -797.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -742.5 712.5 -737.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -802.5 822.5 -797.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -742.5 822.5 -737.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -802.5 932.5 -797.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -742.5 932.5 -737.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -712.5 712.5 -707.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -652.5 712.5 -647.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -712.5 822.5 -707.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -652.5 822.5 -647.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -712.5 932.5 -707.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -652.5 932.5 -647.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -712.5 1252.5 -707.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -652.5 1252.5 -647.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -712.5 1362.5 -707.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -652.5 1362.5 -647.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -712.5 1472.5 -707.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -652.5 1472.5 -647.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -712.5 1792.5 -707.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -652.5 1792.5 -647.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -712.5 1902.5 -707.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -652.5 1902.5 -647.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -712.5 2012.5 -707.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -652.5 2012.5 -647.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1877.5 -2472.5 1882.5 -2467.5 {name=d dir=inout}
B 5 1837.5 -2442.5 1842.5 -2437.5 {name=g dir=in}
B 5 1877.5 -2412.5 1882.5 -2407.5 {name=s dir=inout}
B 5 1877.5 -2442.5 1882.5 -2437.5 {name=b dir=in}
B 5 1108.75 -8691.25 1111.25 -8688.75 {name=p dir=out}
B 5 1137.5 -8582.5 1142.5 -8577.5 {name=p dir=inout goto=0}
B 5 1137.5 -8842.5 1142.5 -8837.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -8721.25 1411.25 -8718.75 {name=p dir=in}
B 5 1027.5 -8662.5 1032.5 -8657.5 {name=p dir=inout}
B 5 1027.5 -8602.5 1032.5 -8597.5 {name=m dir=inout}
B 5 707.5 -422.5 712.5 -417.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -362.5 712.5 -357.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -422.5 822.5 -417.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -362.5 822.5 -357.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -422.5 932.5 -417.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -362.5 932.5 -357.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -362.5 712.5 -357.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -302.5 712.5 -297.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -362.5 822.5 -357.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -302.5 822.5 -297.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -362.5 932.5 -357.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -302.5 932.5 -297.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -362.5 1252.5 -357.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -302.5 1252.5 -297.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -362.5 1362.5 -357.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -302.5 1362.5 -297.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -362.5 1472.5 -357.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -302.5 1472.5 -297.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -332.5 1792.5 -327.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -272.5 1792.5 -267.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -332.5 1902.5 -327.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -272.5 1902.5 -267.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -332.5 2012.5 -327.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -272.5 2012.5 -267.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1757.5 -1112.5 1762.5 -1107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1757.5 -1052.5 1762.5 -1047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1877.5 -1112.5 1882.5 -1107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1877.5 -1052.5 1882.5 -1047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 797.5 -1182.5 802.5 -1177.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 37.5 822.5 42.5 {name=d dir=inout}
B 5 777.5 67.5 782.5 72.5 {name=g dir=in}
B 5 817.5 97.5 822.5 102.5 {name=s dir=inout}
B 5 817.5 67.5 822.5 72.5 {name=b dir=in}
B 5 817.5 -52.5 822.5 -47.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 7.5 822.5 12.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 907.5 37.5 912.5 42.5 {name=p dir=inout pinnumber=1}
B 5 907.5 97.5 912.5 102.5 {name=m dir=inout pinnumber=2}
B 5 577.5 97.5 582.5 102.5 {name=p dir=inout}
B 5 577.5 157.5 582.5 162.5 {name=m dir=inout}
B 5 658.75 68.75 661.25 71.25 {name=p dir=out}
B 5 687.5 177.5 692.5 182.5 {name=p dir=inout goto=0}
B 5 687.5 -82.5 692.5 -77.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 958.75 38.75 961.25 41.25 {name=p dir=in}
B 5 1467.5 37.5 1472.5 42.5 {name=d dir=inout}
B 5 1427.5 67.5 1432.5 72.5 {name=g dir=in}
B 5 1467.5 97.5 1472.5 102.5 {name=s dir=inout}
B 5 1467.5 67.5 1472.5 72.5 {name=b dir=in}
B 5 1467.5 -52.5 1472.5 -47.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 7.5 1472.5 12.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1227.5 97.5 1232.5 102.5 {name=p dir=inout}
B 5 1227.5 157.5 1232.5 162.5 {name=m dir=inout}
B 5 1308.75 68.75 1311.25 71.25 {name=p dir=out}
B 5 1337.5 177.5 1342.5 182.5 {name=p dir=inout goto=0}
B 5 1337.5 -82.5 1342.5 -77.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1608.75 38.75 1611.25 41.25 {name=p dir=in}
B 5 1297.5 -5162.5 1302.5 -5157.5 {name=d dir=inout}
B 5 1257.5 -5132.5 1262.5 -5127.5 {name=g dir=in}
B 5 1297.5 -5102.5 1302.5 -5097.5 {name=s dir=inout}
B 5 1297.5 -5132.5 1302.5 -5127.5 {name=b dir=in}
B 5 1297.5 -5252.5 1302.5 -5247.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1297.5 -5192.5 1302.5 -5187.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1387.5 -5162.5 1392.5 -5157.5 {name=p dir=inout pinnumber=1}
B 5 1387.5 -5102.5 1392.5 -5097.5 {name=m dir=inout pinnumber=2}
B 5 1057.5 -5102.5 1062.5 -5097.5 {name=p dir=inout}
B 5 1057.5 -5042.5 1062.5 -5037.5 {name=m dir=inout}
B 5 1138.75 -5131.25 1141.25 -5128.75 {name=p dir=out}
B 5 1167.5 -5022.5 1172.5 -5017.5 {name=p dir=inout goto=0}
B 5 1167.5 -5282.5 1172.5 -5277.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1438.75 -5161.25 1441.25 -5158.75 {name=p dir=in}
B 5 1857.5 -5162.5 1862.5 -5157.5 {name=d dir=inout}
B 5 1817.5 -5132.5 1822.5 -5127.5 {name=g dir=in}
B 5 1857.5 -5102.5 1862.5 -5097.5 {name=s dir=inout}
B 5 1857.5 -5132.5 1862.5 -5127.5 {name=b dir=in}
B 5 1857.5 -5252.5 1862.5 -5247.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1857.5 -5192.5 1862.5 -5187.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1947.5 -5162.5 1952.5 -5157.5 {name=p dir=inout pinnumber=1}
B 5 1947.5 -5102.5 1952.5 -5097.5 {name=m dir=inout pinnumber=2}
B 5 1617.5 -5102.5 1622.5 -5097.5 {name=p dir=inout}
B 5 1617.5 -5042.5 1622.5 -5037.5 {name=m dir=inout}
B 5 1698.75 -5131.25 1701.25 -5128.75 {name=p dir=out}
B 5 1727.5 -5022.5 1732.5 -5017.5 {name=p dir=inout goto=0}
B 5 1727.5 -5282.5 1732.5 -5277.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1998.75 -5161.25 2001.25 -5158.75 {name=p dir=in}
B 5 2427.5 -5162.5 2432.5 -5157.5 {name=d dir=inout}
B 5 2387.5 -5132.5 2392.5 -5127.5 {name=g dir=in}
B 5 2427.5 -5102.5 2432.5 -5097.5 {name=s dir=inout}
B 5 2427.5 -5132.5 2432.5 -5127.5 {name=b dir=in}
B 5 2427.5 -5252.5 2432.5 -5247.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -5192.5 2432.5 -5187.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2517.5 -5162.5 2522.5 -5157.5 {name=p dir=inout pinnumber=1}
B 5 2517.5 -5102.5 2522.5 -5097.5 {name=m dir=inout pinnumber=2}
B 5 2187.5 -5102.5 2192.5 -5097.5 {name=p dir=inout}
B 5 2187.5 -5042.5 2192.5 -5037.5 {name=m dir=inout}
B 5 2268.75 -5131.25 2271.25 -5128.75 {name=p dir=out}
B 5 2297.5 -5022.5 2302.5 -5017.5 {name=p dir=inout goto=0}
B 5 2297.5 -5282.5 2302.5 -5277.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2568.75 -5161.25 2571.25 -5158.75 {name=p dir=in}
B 5 2027.5 37.5 2032.5 42.5 {name=d dir=inout}
B 5 1987.5 67.5 1992.5 72.5 {name=g dir=in}
B 5 2027.5 97.5 2032.5 102.5 {name=s dir=inout}
B 5 2027.5 67.5 2032.5 72.5 {name=b dir=in}
B 5 2027.5 -52.5 2032.5 -47.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2027.5 7.5 2032.5 12.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 97.5 1792.5 102.5 {name=p dir=inout}
B 5 1787.5 157.5 1792.5 162.5 {name=m dir=inout}
B 5 1868.75 68.75 1871.25 71.25 {name=p dir=out}
B 5 1897.5 177.5 1902.5 182.5 {name=p dir=inout goto=0}
B 5 1897.5 -82.5 1902.5 -77.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2168.75 38.75 2171.25 41.25 {name=p dir=in}
A 1 1220 -2100 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1340 -2100 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1850 -2100 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1970 -2100 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1280 -1820 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1910 -1820 5.590169943749475 333.434948822922 360 {fill=1}
A 1 740 -1420 5.590169943749475 333.434948822922 360 {fill=1}
A 2 1570 -8630 15 270 360 {}
A 2 2030 -8630 15 270 360 {}
A 4 1030 -8160 15 270 360 {}
A 4 1570 -8160 15 270 360 {}
A 4 500 -8160 15 270 360 {}
A 4 500 -7700 15 270 360 {}
A 4 1040 -7700 15 270 360 {}
A 4 500 -6870 15 270 360 {}
A 4 1040 -6870 15 270 360 {}
A 4 500 -6380 15 270 360 {}
A 4 1040 -6380 15 270 360 {}
A 4 500 -5890 15 270 360 {}
A 4 1690 -5890 15 270 360 {}
A 4 1040 -5890 15 270 360 {}
A 4 1030 -7330 15 270 360 {}
A 4 500 -7330 15 270 360 {}
A 4 1530 -7330 15 270 360 {}
A 4 500 -8630 15 270 360 {}
A 4 520 -5450 15 270 360 {}
A 4 1060 -5450 15 270 360 {}
A 4 1620 -5450 15 270 360 {}
A 4 2190 -5450 15 270 360 {}
A 4 520 -4650 15 270 360 {}
A 4 1060 -4650 15 270 360 {}
A 4 2190 -4650 15 270 360 {}
A 4 520 -5070 15 270 360 {}
A 4 520 -4240 15 270 360 {}
A 4 1620 -4240 15 270 360 {}
A 4 1060 -4240 15 270 360 {}
A 4 1030 -8630 15 270 360 {}
A 4 580 130 15 270 360 {}
A 4 1230 130 15 270 360 {}
A 4 1060 -5070 15 270 360 {}
A 4 1620 -5070 15 270 360 {}
A 4 2190 -5070 15 270 360 {}
A 4 1790 130 15 270 360 {}
A 5 1360 -3180 5.590169943749475 333.434948822922 360 {fill=1}
P 1 14 920 -8080 942.5 -8080 947.5 -8080 947.5 -8075 947.5 -8032.5 940 -8007.5 935 -8007.5 905 -8007.5 900 -8007.5 892.5 -8032.5 892.5 -8075 892.5 -8080 897.5 -8080 920 -8080 {bezier=1}
P 1 14 935 -8077.5 940 -8077.5 945 -8077.5 945 -8072.5 945 -8052.5 945 -8047.5 940 -8047.5 930 -8047.5 925 -8047.5 925 -8052.5 925 -8072.5 925 -8077.5 930 -8077.5 935 -8077.5 {bezier=1}
P 1 5 917.5 -8075 922.5 -8075 922.5 -8050 917.5 -8050 917.5 -8075 {}
P 1 14 1350 -8080 1372.5 -8080 1377.5 -8080 1377.5 -8075 1377.5 -8032.5 1370 -8007.5 1365 -8007.5 1335 -8007.5 1330 -8007.5 1322.5 -8032.5 1322.5 -8075 1322.5 -8080 1327.5 -8080 1350 -8080 {bezier=1}
P 1 14 1365 -8077.5 1370 -8077.5 1375 -8077.5 1375 -8072.5 1375 -8052.5 1375 -8047.5 1370 -8047.5 1360 -8047.5 1355 -8047.5 1355 -8052.5 1355 -8072.5 1355 -8077.5 1360 -8077.5 1365 -8077.5 {bezier=1}
P 1 5 1347.5 -8075 1352.5 -8075 1352.5 -8050 1347.5 -8050 1347.5 -8075 {}
P 1 14 2120 -8080 2142.5 -8080 2147.5 -8080 2147.5 -8075 2147.5 -8032.5 2140 -8007.5 2135 -8007.5 2105 -8007.5 2100 -8007.5 2092.5 -8032.5 2092.5 -8075 2092.5 -8080 2097.5 -8080 2120 -8080 {bezier=1}
P 1 14 2135 -8077.5 2140 -8077.5 2145 -8077.5 2145 -8072.5 2145 -8052.5 2145 -8047.5 2140 -8047.5 2130 -8047.5 2125 -8047.5 2125 -8052.5 2125 -8072.5 2125 -8077.5 2130 -8077.5 2135 -8077.5 {bezier=1}
P 1 5 2117.5 -8075 2122.5 -8075 2122.5 -8050 2117.5 -8050 2117.5 -8075 {}
P 1 14 2105 -8077.5 2110 -8077.5 2115 -8077.5 2115 -8072.5 2115 -8052.5 2115 -8047.5 2110 -8047.5 2100 -8047.5 2095 -8047.5 2095 -8052.5 2095 -8072.5 2095 -8077.5 2100 -8077.5 2105 -8077.5 {}
P 1 14 1420 -7890 1442.5 -7890 1447.5 -7890 1447.5 -7885 1447.5 -7842.5 1440 -7817.5 1435 -7817.5 1405 -7817.5 1400 -7817.5 1392.5 -7842.5 1392.5 -7885 1392.5 -7890 1397.5 -7890 1420 -7890 {bezier=1}
P 1 14 1435 -7887.5 1440 -7887.5 1445 -7887.5 1445 -7882.5 1445 -7862.5 1445 -7857.5 1440 -7857.5 1430 -7857.5 1425 -7857.5 1425 -7862.5 1425 -7882.5 1425 -7887.5 1430 -7887.5 1435 -7887.5 {bezier=1}
P 1 5 1417.5 -7885 1422.5 -7885 1422.5 -7860 1417.5 -7860 1417.5 -7885 {}
P 1 14 1440 -7070 1462.5 -7070 1467.5 -7070 1467.5 -7065 1467.5 -7022.5 1460 -6997.5 1455 -6997.5 1425 -6997.5 1420 -6997.5 1412.5 -7022.5 1412.5 -7065 1412.5 -7070 1417.5 -7070 1440 -7070 {bezier=1}
P 1 14 1455 -7067.5 1460 -7067.5 1465 -7067.5 1465 -7062.5 1465 -7042.5 1465 -7037.5 1460 -7037.5 1450 -7037.5 1445 -7037.5 1445 -7042.5 1445 -7062.5 1445 -7067.5 1450 -7067.5 1455 -7067.5 {bezier=1}
P 1 5 1437.5 -7065 1442.5 -7065 1442.5 -7040 1437.5 -7040 1437.5 -7065 {}
P 1 10 1530 -7055 1555 -7055 1565 -7045 1565 -7015 1555 -7005 1505 -7005 1495 -7015 1495 -7045 1505 -7055 1530 -7055 {bezier=1}
P 1 10 1530 -7060 1560 -7060 1570 -7050 1570 -7010 1560 -7000 1500 -7000 1490 -7010 1490 -7050 1500 -7060 1530 -7060 {bezier=1}
P 1 14 1440 -6580 1462.5 -6580 1467.5 -6580 1467.5 -6575 1467.5 -6532.5 1460 -6507.5 1455 -6507.5 1425 -6507.5 1420 -6507.5 1412.5 -6532.5 1412.5 -6575 1412.5 -6580 1417.5 -6580 1440 -6580 {bezier=1}
P 1 14 1455 -6577.5 1460 -6577.5 1465 -6577.5 1465 -6572.5 1465 -6552.5 1465 -6547.5 1460 -6547.5 1450 -6547.5 1445 -6547.5 1445 -6552.5 1445 -6572.5 1445 -6577.5 1450 -6577.5 1455 -6577.5 {bezier=1}
P 1 5 1437.5 -6575 1442.5 -6575 1442.5 -6550 1437.5 -6550 1437.5 -6575 {}
P 1 10 1530 -6565 1555 -6565 1565 -6555 1565 -6525 1555 -6515 1505 -6515 1495 -6525 1495 -6555 1505 -6565 1530 -6565 {bezier=1}
P 1 10 1530 -6570 1560 -6570 1570 -6560 1570 -6520 1560 -6510 1500 -6510 1490 -6520 1490 -6560 1500 -6570 1530 -6570 {bezier=1}
P 1 14 950 -5850 972.5 -5850 977.5 -5850 977.5 -5845 977.5 -5802.5 970 -5777.5 965 -5777.5 935 -5777.5 930 -5777.5 922.5 -5802.5 922.5 -5845 922.5 -5850 927.5 -5850 950 -5850 {bezier=1}
P 1 14 965 -5847.5 970 -5847.5 975 -5847.5 975 -5842.5 975 -5822.5 975 -5817.5 970 -5817.5 960 -5817.5 955 -5817.5 955 -5822.5 955 -5842.5 955 -5847.5 960 -5847.5 965 -5847.5 {bezier=1}
P 1 5 947.5 -5845 952.5 -5845 952.5 -5820 947.5 -5820 947.5 -5845 {}
P 1 14 1430 -5860 1452.5 -5860 1457.5 -5860 1457.5 -5855 1457.5 -5812.5 1450 -5787.5 1445 -5787.5 1415 -5787.5 1410 -5787.5 1402.5 -5812.5 1402.5 -5855 1402.5 -5860 1407.5 -5860 1430 -5860 {bezier=1}
P 1 14 1445 -5857.5 1450 -5857.5 1455 -5857.5 1455 -5852.5 1455 -5832.5 1455 -5827.5 1450 -5827.5 1440 -5827.5 1435 -5827.5 1435 -5832.5 1435 -5852.5 1435 -5857.5 1440 -5857.5 1445 -5857.5 {bezier=1}
P 1 5 1427.5 -5855 1432.5 -5855 1432.5 -5830 1427.5 -5830 1427.5 -5855 {}
P 1 10 1520 -5845 1545 -5845 1555 -5835 1555 -5805 1545 -5795 1495 -5795 1485 -5805 1485 -5835 1495 -5845 1520 -5845 {bezier=1}
P 1 10 1520 -5850 1550 -5850 1560 -5840 1560 -5800 1550 -5790 1490 -5790 1480 -5800 1480 -5840 1490 -5850 1520 -5850 {bezier=1}
P 1 14 920 -7250 942.5 -7250 947.5 -7250 947.5 -7245 947.5 -7202.5 940 -7177.5 935 -7177.5 905 -7177.5 900 -7177.5 892.5 -7202.5 892.5 -7245 892.5 -7250 897.5 -7250 920 -7250 {bezier=1}
P 1 14 935 -7247.5 940 -7247.5 945 -7247.5 945 -7242.5 945 -7222.5 945 -7217.5 940 -7217.5 930 -7217.5 925 -7217.5 925 -7222.5 925 -7242.5 925 -7247.5 930 -7247.5 935 -7247.5 {bezier=1}
P 1 5 917.5 -7245 922.5 -7245 922.5 -7220 917.5 -7220 917.5 -7245 {}
P 1 14 1350 -7250 1372.5 -7250 1377.5 -7250 1377.5 -7245 1377.5 -7202.5 1370 -7177.5 1365 -7177.5 1335 -7177.5 1330 -7177.5 1322.5 -7202.5 1322.5 -7245 1322.5 -7250 1327.5 -7250 1350 -7250 {bezier=1}
P 1 14 1365 -7247.5 1370 -7247.5 1375 -7247.5 1375 -7242.5 1375 -7222.5 1375 -7217.5 1370 -7217.5 1360 -7217.5 1355 -7217.5 1355 -7222.5 1355 -7242.5 1355 -7247.5 1360 -7247.5 1365 -7247.5 {bezier=1}
P 1 5 1347.5 -7245 1352.5 -7245 1352.5 -7220 1347.5 -7220 1347.5 -7245 {}
P 1 14 2120 -7250 2142.5 -7250 2147.5 -7250 2147.5 -7245 2147.5 -7202.5 2140 -7177.5 2135 -7177.5 2105 -7177.5 2100 -7177.5 2092.5 -7202.5 2092.5 -7245 2092.5 -7250 2097.5 -7250 2120 -7250 {bezier=1}
P 1 14 2135 -7247.5 2140 -7247.5 2145 -7247.5 2145 -7242.5 2145 -7222.5 2145 -7217.5 2140 -7217.5 2130 -7217.5 2125 -7217.5 2125 -7222.5 2125 -7242.5 2125 -7247.5 2130 -7247.5 2135 -7247.5 {bezier=1}
P 1 5 2117.5 -7245 2122.5 -7245 2122.5 -7220 2117.5 -7220 2117.5 -7245 {}
P 1 14 2105 -7247.5 2110 -7247.5 2115 -7247.5 2115 -7242.5 2115 -7222.5 2115 -7217.5 2110 -7217.5 2100 -7217.5 2095 -7217.5 2095 -7222.5 2095 -7242.5 2095 -7247.5 2100 -7247.5 2105 -7247.5 {}
P 1 10 1270 -7245 1295 -7245 1305 -7235 1305 -7205 1295 -7195 1245 -7195 1235 -7205 1235 -7235 1245 -7245 1270 -7245 {bezier=1}
P 1 10 1270 -7250 1300 -7250 1310 -7240 1310 -7200 1300 -7190 1240 -7190 1230 -7200 1230 -7240 1240 -7250 1270 -7250 {bezier=1}
P 1 14 920 -8550 942.5 -8550 947.5 -8550 947.5 -8545 947.5 -8502.5 940 -8477.5 935 -8477.5 905 -8477.5 900 -8477.5 892.5 -8502.5 892.5 -8545 892.5 -8550 897.5 -8550 920 -8550 {bezier=1}
P 1 14 935 -8547.5 940 -8547.5 945 -8547.5 945 -8542.5 945 -8522.5 945 -8517.5 940 -8517.5 930 -8517.5 925 -8517.5 925 -8522.5 925 -8542.5 925 -8547.5 930 -8547.5 935 -8547.5 {bezier=1}
P 1 5 917.5 -8545 922.5 -8545 922.5 -8520 917.5 -8520 917.5 -8545 {}
P 1 14 1630 -8540 1652.5 -8540 1657.5 -8540 1657.5 -8535 1657.5 -8492.5 1650 -8467.5 1645 -8467.5 1615 -8467.5 1610 -8467.5 1602.5 -8492.5 1602.5 -8535 1602.5 -8540 1607.5 -8540 1630 -8540 {bezier=1}
P 1 14 1645 -8537.5 1650 -8537.5 1655 -8537.5 1655 -8532.5 1655 -8512.5 1655 -8507.5 1650 -8507.5 1640 -8507.5 1635 -8507.5 1635 -8512.5 1635 -8532.5 1635 -8537.5 1640 -8537.5 1645 -8537.5 {bezier=1}
P 1 5 1627.5 -8535 1632.5 -8535 1632.5 -8510 1627.5 -8510 1627.5 -8535 {}
P 1 10 1710 -8525 1735 -8525 1745 -8515 1745 -8485 1735 -8475 1685 -8475 1675 -8485 1675 -8515 1685 -8525 1710 -8525 {bezier=1}
P 1 10 1710 -8530 1740 -8530 1750 -8520 1750 -8480 1740 -8470 1680 -8470 1670 -8480 1670 -8520 1680 -8530 1710 -8530 {bezier=1}
P 1 14 2410 -8530 2432.5 -8530 2437.5 -8530 2437.5 -8525 2437.5 -8482.5 2430 -8457.5 2425 -8457.5 2395 -8457.5 2390 -8457.5 2382.5 -8482.5 2382.5 -8525 2382.5 -8530 2387.5 -8530 2410 -8530 {bezier=1}
P 1 14 2425 -8527.5 2430 -8527.5 2435 -8527.5 2435 -8522.5 2435 -8502.5 2435 -8497.5 2430 -8497.5 2420 -8497.5 2415 -8497.5 2415 -8502.5 2415 -8522.5 2415 -8527.5 2420 -8527.5 2425 -8527.5 {bezier=1}
P 1 5 2407.5 -8525 2412.5 -8525 2412.5 -8500 2407.5 -8500 2407.5 -8525 {}
P 1 10 2490 -8515 2515 -8515 2525 -8505 2525 -8475 2515 -8465 2465 -8465 2455 -8475 2455 -8505 2465 -8515 2490 -8515 {bezier=1}
P 1 10 2490 -8520 2520 -8520 2530 -8510 2530 -8470 2520 -8460 2460 -8460 2450 -8470 2450 -8510 2460 -8520 2490 -8520 {bezier=1}
P 1 14 1490 -5660 1512.5 -5660 1517.5 -5660 1517.5 -5655 1517.5 -5612.5 1510 -5587.5 1505 -5587.5 1475 -5587.5 1470 -5587.5 1462.5 -5612.5 1462.5 -5655 1462.5 -5660 1467.5 -5660 1490 -5660 {bezier=1}
P 1 14 1505 -5657.5 1510 -5657.5 1515 -5657.5 1515 -5652.5 1515 -5632.5 1515 -5627.5 1510 -5627.5 1500 -5627.5 1495 -5627.5 1495 -5632.5 1495 -5652.5 1495 -5657.5 1500 -5657.5 1505 -5657.5 {bezier=1}
P 1 5 1487.5 -5655 1492.5 -5655 1492.5 -5630 1487.5 -5630 1487.5 -5655 {}
P 1 14 1940 -5730 1962.5 -5730 1967.5 -5730 1967.5 -5725 1967.5 -5682.5 1960 -5657.5 1955 -5657.5 1925 -5657.5 1920 -5657.5 1912.5 -5682.5 1912.5 -5725 1912.5 -5730 1917.5 -5730 1940 -5730 {bezier=1}
P 1 14 1955 -5727.5 1960 -5727.5 1965 -5727.5 1965 -5722.5 1965 -5702.5 1965 -5697.5 1960 -5697.5 1950 -5697.5 1945 -5697.5 1945 -5702.5 1945 -5722.5 1945 -5727.5 1950 -5727.5 1955 -5727.5 {bezier=1}
P 1 5 1937.5 -5725 1942.5 -5725 1942.5 -5700 1937.5 -5700 1937.5 -5725 {}
P 1 14 2560 -5640 2582.5 -5640 2587.5 -5640 2587.5 -5635 2587.5 -5592.5 2580 -5567.5 2575 -5567.5 2545 -5567.5 2540 -5567.5 2532.5 -5592.5 2532.5 -5635 2532.5 -5640 2537.5 -5640 2560 -5640 {bezier=1}
P 1 14 2575 -5637.5 2580 -5637.5 2585 -5637.5 2585 -5632.5 2585 -5612.5 2585 -5607.5 2580 -5607.5 2570 -5607.5 2565 -5607.5 2565 -5612.5 2565 -5632.5 2565 -5637.5 2570 -5637.5 2575 -5637.5 {bezier=1}
P 1 5 2557.5 -5635 2562.5 -5635 2562.5 -5610 2557.5 -5610 2557.5 -5635 {}
P 1 14 2545 -5637.5 2550 -5637.5 2555 -5637.5 2555 -5632.5 2555 -5612.5 2555 -5607.5 2550 -5607.5 2540 -5607.5 2535 -5607.5 2535 -5612.5 2535 -5632.5 2535 -5637.5 2540 -5637.5 2545 -5637.5 {}
P 1 14 690 -4830 712.5 -4830 717.5 -4830 717.5 -4825 717.5 -4782.5 710 -4757.5 705 -4757.5 675 -4757.5 670 -4757.5 662.5 -4782.5 662.5 -4825 662.5 -4830 667.5 -4830 690 -4830 {bezier=1}
P 1 14 705 -4827.5 710 -4827.5 715 -4827.5 715 -4822.5 715 -4802.5 715 -4797.5 710 -4797.5 700 -4797.5 695 -4797.5 695 -4802.5 695 -4822.5 695 -4827.5 700 -4827.5 705 -4827.5 {bezier=1}
P 1 5 687.5 -4825 692.5 -4825 692.5 -4800 687.5 -4800 687.5 -4825 {}
P 1 14 1350 -4850 1372.5 -4850 1377.5 -4850 1377.5 -4845 1377.5 -4802.5 1370 -4777.5 1365 -4777.5 1335 -4777.5 1330 -4777.5 1322.5 -4802.5 1322.5 -4845 1322.5 -4850 1327.5 -4850 1350 -4850 {bezier=1}
P 1 14 1365 -4847.5 1370 -4847.5 1375 -4847.5 1375 -4842.5 1375 -4822.5 1375 -4817.5 1370 -4817.5 1360 -4817.5 1355 -4817.5 1355 -4822.5 1355 -4842.5 1355 -4847.5 1360 -4847.5 1365 -4847.5 {bezier=1}
P 1 5 1347.5 -4845 1352.5 -4845 1352.5 -4820 1347.5 -4820 1347.5 -4845 {}
P 1 14 2540 -4900 2562.5 -4900 2567.5 -4900 2567.5 -4895 2567.5 -4852.5 2560 -4827.5 2555 -4827.5 2525 -4827.5 2520 -4827.5 2512.5 -4852.5 2512.5 -4895 2512.5 -4900 2517.5 -4900 2540 -4900 {bezier=1}
P 1 14 2555 -4897.5 2560 -4897.5 2565 -4897.5 2565 -4892.5 2565 -4872.5 2565 -4867.5 2560 -4867.5 2550 -4867.5 2545 -4867.5 2545 -4872.5 2545 -4892.5 2545 -4897.5 2550 -4897.5 2555 -4897.5 {bezier=1}
P 1 5 2537.5 -4895 2542.5 -4895 2542.5 -4870 2537.5 -4870 2537.5 -4895 {}
P 1 14 2525 -4897.5 2530 -4897.5 2535 -4897.5 2535 -4892.5 2535 -4872.5 2535 -4867.5 2530 -4867.5 2520 -4867.5 2515 -4867.5 2515 -4872.5 2515 -4892.5 2515 -4897.5 2520 -4897.5 2525 -4897.5 {}
P 1 14 850 -4470 872.5 -4470 877.5 -4470 877.5 -4465 877.5 -4422.5 870 -4397.5 865 -4397.5 835 -4397.5 830 -4397.5 822.5 -4422.5 822.5 -4465 822.5 -4470 827.5 -4470 850 -4470 {bezier=1}
P 1 14 865 -4467.5 870 -4467.5 875 -4467.5 875 -4462.5 875 -4442.5 875 -4437.5 870 -4437.5 860 -4437.5 855 -4437.5 855 -4442.5 855 -4462.5 855 -4467.5 860 -4467.5 865 -4467.5 {bezier=1}
P 1 5 847.5 -4465 852.5 -4465 852.5 -4440 847.5 -4440 847.5 -4465 {}
P 1 14 1250 -4420 1272.5 -4420 1277.5 -4420 1277.5 -4415 1277.5 -4372.5 1270 -4347.5 1265 -4347.5 1235 -4347.5 1230 -4347.5 1222.5 -4372.5 1222.5 -4415 1222.5 -4420 1227.5 -4420 1250 -4420 {bezier=1}
P 1 14 1265 -4417.5 1270 -4417.5 1275 -4417.5 1275 -4412.5 1275 -4392.5 1275 -4387.5 1270 -4387.5 1260 -4387.5 1255 -4387.5 1255 -4392.5 1255 -4412.5 1255 -4417.5 1260 -4417.5 1265 -4417.5 {bezier=1}
P 1 5 1247.5 -4415 1252.5 -4415 1252.5 -4390 1247.5 -4390 1247.5 -4415 {}
P 1 10 1170 -4405 1195 -4405 1205 -4395 1205 -4365 1195 -4355 1145 -4355 1135 -4365 1135 -4395 1145 -4405 1170 -4405 {bezier=1}
P 1 10 1170 -4410 1200 -4410 1210 -4400 1210 -4360 1200 -4350 1140 -4350 1130 -4360 1130 -4400 1140 -4410 1170 -4410 {bezier=1}
P 1 14 1810 -4450 1832.5 -4450 1837.5 -4450 1837.5 -4445 1837.5 -4402.5 1830 -4377.5 1825 -4377.5 1795 -4377.5 1790 -4377.5 1782.5 -4402.5 1782.5 -4445 1782.5 -4450 1787.5 -4450 1810 -4450 {bezier=1}
P 1 14 1825 -4447.5 1830 -4447.5 1835 -4447.5 1835 -4442.5 1835 -4422.5 1835 -4417.5 1830 -4417.5 1820 -4417.5 1815 -4417.5 1815 -4422.5 1815 -4442.5 1815 -4447.5 1820 -4447.5 1825 -4447.5 {bezier=1}
P 1 5 1807.5 -4445 1812.5 -4445 1812.5 -4420 1807.5 -4420 1807.5 -4445 {}
P 1 14 1430 -3900 1452.5 -3900 1457.5 -3900 1457.5 -3895 1457.5 -3852.5 1450 -3827.5 1445 -3827.5 1415 -3827.5 1410 -3827.5 1402.5 -3852.5 1402.5 -3895 1402.5 -3900 1407.5 -3900 1430 -3900 {bezier=1}
P 1 14 1445 -3897.5 1450 -3897.5 1455 -3897.5 1455 -3892.5 1455 -3872.5 1455 -3867.5 1450 -3867.5 1440 -3867.5 1435 -3867.5 1435 -3872.5 1435 -3892.5 1435 -3897.5 1440 -3897.5 1445 -3897.5 {bezier=1}
P 1 5 1427.5 -3895 1432.5 -3895 1432.5 -3870 1427.5 -3870 1427.5 -3895 {}
P 1 10 1430 -4055 1455 -4055 1465 -4045 1465 -4015 1455 -4005 1405 -4005 1395 -4015 1395 -4045 1405 -4055 1430 -4055 {bezier=1}
P 1 10 1430 -4060 1460 -4060 1470 -4050 1470 -4010 1460 -4000 1400 -4000 1390 -4010 1390 -4050 1400 -4060 1430 -4060 {bezier=1}
P 1 10 1430 -3975 1455 -3975 1465 -3965 1465 -3935 1455 -3925 1405 -3925 1395 -3935 1395 -3965 1405 -3975 1430 -3975 {bezier=1}
P 1 10 1430 -3980 1460 -3980 1470 -3970 1470 -3930 1460 -3920 1400 -3920 1390 -3930 1390 -3970 1400 -3980 1430 -3980 {bezier=1}
P 1 14 1700 -3900 1722.5 -3900 1727.5 -3900 1727.5 -3895 1727.5 -3852.5 1720 -3827.5 1715 -3827.5 1685 -3827.5 1680 -3827.5 1672.5 -3852.5 1672.5 -3895 1672.5 -3900 1677.5 -3900 1700 -3900 {bezier=1}
P 1 14 1715 -3897.5 1720 -3897.5 1725 -3897.5 1725 -3892.5 1725 -3872.5 1725 -3867.5 1720 -3867.5 1710 -3867.5 1705 -3867.5 1705 -3872.5 1705 -3892.5 1705 -3897.5 1710 -3897.5 1715 -3897.5 {bezier=1}
P 1 5 1697.5 -3895 1702.5 -3895 1702.5 -3870 1697.5 -3870 1697.5 -3895 {}
P 1 10 1700 -4055 1725 -4055 1735 -4045 1735 -4015 1725 -4005 1675 -4005 1665 -4015 1665 -4045 1675 -4055 1700 -4055 {bezier=1}
P 1 10 1700 -4060 1730 -4060 1740 -4050 1740 -4010 1730 -4000 1670 -4000 1660 -4010 1660 -4050 1670 -4060 1700 -4060 {bezier=1}
P 1 10 1700 -3975 1725 -3975 1735 -3965 1735 -3935 1725 -3925 1675 -3925 1665 -3935 1665 -3965 1675 -3975 1700 -3975 {bezier=1}
P 1 10 1700 -3980 1730 -3980 1740 -3970 1740 -3930 1730 -3920 1670 -3920 1660 -3930 1660 -3970 1670 -3980 1700 -3980 {bezier=1}
P 1 14 2300 -3900 2322.5 -3900 2327.5 -3900 2327.5 -3895 2327.5 -3852.5 2320 -3827.5 2315 -3827.5 2285 -3827.5 2280 -3827.5 2272.5 -3852.5 2272.5 -3895 2272.5 -3900 2277.5 -3900 2300 -3900 {bezier=1}
P 1 14 2315 -3897.5 2320 -3897.5 2325 -3897.5 2325 -3892.5 2325 -3872.5 2325 -3867.5 2320 -3867.5 2310 -3867.5 2305 -3867.5 2305 -3872.5 2305 -3892.5 2305 -3897.5 2310 -3897.5 2315 -3897.5 {bezier=1}
P 1 5 2297.5 -3895 2302.5 -3895 2302.5 -3870 2297.5 -3870 2297.5 -3895 {}
P 1 14 2285 -3897.5 2290 -3897.5 2295 -3897.5 2295 -3892.5 2295 -3872.5 2295 -3867.5 2290 -3867.5 2280 -3867.5 2275 -3867.5 2275 -3872.5 2275 -3892.5 2275 -3897.5 2280 -3897.5 2285 -3897.5 {}
P 1 14 1430 -3520 1452.5 -3520 1457.5 -3520 1457.5 -3515 1457.5 -3472.5 1450 -3447.5 1445 -3447.5 1415 -3447.5 1410 -3447.5 1402.5 -3472.5 1402.5 -3515 1402.5 -3520 1407.5 -3520 1430 -3520 {bezier=1}
P 1 14 1445 -3517.5 1450 -3517.5 1455 -3517.5 1455 -3512.5 1455 -3492.5 1455 -3487.5 1450 -3487.5 1440 -3487.5 1435 -3487.5 1435 -3492.5 1435 -3512.5 1435 -3517.5 1440 -3517.5 1445 -3517.5 {bezier=1}
P 1 5 1427.5 -3515 1432.5 -3515 1432.5 -3490 1427.5 -3490 1427.5 -3515 {}
P 1 10 1430 -3675 1455 -3675 1465 -3665 1465 -3635 1455 -3625 1405 -3625 1395 -3635 1395 -3665 1405 -3675 1430 -3675 {bezier=1}
P 1 10 1430 -3680 1460 -3680 1470 -3670 1470 -3630 1460 -3620 1400 -3620 1390 -3630 1390 -3670 1400 -3680 1430 -3680 {bezier=1}
P 1 10 1430 -3595 1455 -3595 1465 -3585 1465 -3555 1455 -3545 1405 -3545 1395 -3555 1395 -3585 1405 -3595 1430 -3595 {bezier=1}
P 1 10 1430 -3600 1460 -3600 1470 -3590 1470 -3550 1460 -3540 1400 -3540 1390 -3550 1390 -3590 1400 -3600 1430 -3600 {bezier=1}
P 1 14 2080 -790 2102.5 -790 2107.5 -790 2107.5 -785 2107.5 -742.5 2100 -717.5 2095 -717.5 2065 -717.5 2060 -717.5 2052.5 -742.5 2052.5 -785 2052.5 -790 2057.5 -790 2080 -790 {bezier=1}
P 1 14 2095 -787.5 2100 -787.5 2105 -787.5 2105 -782.5 2105 -762.5 2105 -757.5 2100 -757.5 2090 -757.5 2085 -757.5 2085 -762.5 2085 -782.5 2085 -787.5 2090 -787.5 2095 -787.5 {bezier=1}
P 1 5 2077.5 -785 2082.5 -785 2082.5 -760 2077.5 -760 2077.5 -785 {}
P 1 10 2080 -855 2105 -855 2115 -845 2115 -815 2105 -805 2055 -805 2045 -815 2045 -845 2055 -855 2080 -855 {bezier=1}
P 1 10 2080 -860 2110 -860 2120 -850 2120 -810 2110 -800 2050 -800 2040 -810 2040 -850 2050 -860 2080 -860 {bezier=1}
P 1 14 1570 -760 1592.5 -760 1597.5 -760 1597.5 -755 1597.5 -712.5 1590 -687.5 1585 -687.5 1555 -687.5 1550 -687.5 1542.5 -712.5 1542.5 -755 1542.5 -760 1547.5 -760 1570 -760 {bezier=1}
P 1 14 1585 -757.5 1590 -757.5 1595 -757.5 1595 -752.5 1595 -732.5 1595 -727.5 1590 -727.5 1580 -727.5 1575 -727.5 1575 -732.5 1575 -752.5 1575 -757.5 1580 -757.5 1585 -757.5 {bezier=1}
P 1 5 1567.5 -755 1572.5 -755 1572.5 -730 1567.5 -730 1567.5 -755 {}
P 1 14 1430 -3160 1452.5 -3160 1457.5 -3160 1457.5 -3155 1457.5 -3112.5 1450 -3087.5 1445 -3087.5 1415 -3087.5 1410 -3087.5 1402.5 -3112.5 1402.5 -3155 1402.5 -3160 1407.5 -3160 1430 -3160 {bezier=1}
P 1 14 1415 -3157.5 1410 -3157.5 1405 -3157.5 1405 -3152.5 1405 -3132.5 1405 -3127.5 1410 -3127.5 1420 -3127.5 1425 -3127.5 1425 -3132.5 1425 -3152.5 1425 -3157.5 1420 -3157.5 1415 -3157.5 {bezier=1}
P 1 5 1427.5 -3155 1432.5 -3155 1432.5 -3130 1427.5 -3130 1427.5 -3155 {}
P 1 10 1430 -3225 1455 -3225 1465 -3215 1465 -3185 1455 -3175 1405 -3175 1395 -3185 1395 -3215 1405 -3225 1430 -3225 {bezier=1}
P 1 10 1430 -3230 1460 -3230 1470 -3220 1470 -3180 1460 -3170 1400 -3170 1390 -3180 1390 -3220 1400 -3230 1430 -3230 {bezier=1}
P 1 14 1960 -3270 1982.5 -3270 1987.5 -3270 1987.5 -3265 1987.5 -3222.5 1980 -3197.5 1975 -3197.5 1945 -3197.5 1940 -3197.5 1932.5 -3222.5 1932.5 -3265 1932.5 -3270 1937.5 -3270 1960 -3270 {bezier=1}
P 1 14 1975 -3267.5 1980 -3267.5 1985 -3267.5 1985 -3262.5 1985 -3242.5 1985 -3237.5 1980 -3237.5 1970 -3237.5 1965 -3237.5 1965 -3242.5 1965 -3262.5 1965 -3267.5 1970 -3267.5 1975 -3267.5 {bezier=1}
P 1 5 1957.5 -3265 1962.5 -3265 1962.5 -3240 1957.5 -3240 1957.5 -3265 {}
P 1 14 1580 -2750 1602.5 -2750 1607.5 -2750 1607.5 -2745 1607.5 -2702.5 1600 -2677.5 1595 -2677.5 1565 -2677.5 1560 -2677.5 1552.5 -2702.5 1552.5 -2745 1552.5 -2750 1557.5 -2750 1580 -2750 {bezier=1}
P 1 14 1595 -2747.5 1600 -2747.5 1605 -2747.5 1605 -2742.5 1605 -2722.5 1605 -2717.5 1600 -2717.5 1590 -2717.5 1585 -2717.5 1585 -2722.5 1585 -2742.5 1585 -2747.5 1590 -2747.5 1595 -2747.5 {bezier=1}
P 1 5 1577.5 -2745 1582.5 -2745 1582.5 -2720 1577.5 -2720 1577.5 -2745 {}
P 1 10 1580 -2815 1605 -2815 1615 -2805 1615 -2775 1605 -2765 1555 -2765 1545 -2775 1545 -2805 1555 -2815 1580 -2815 {bezier=1}
P 1 10 1580 -2820 1610 -2820 1620 -2810 1620 -2770 1610 -2760 1550 -2760 1540 -2770 1540 -2810 1550 -2820 1580 -2820 {bezier=1}
P 1 14 2070 -2810 2092.5 -2810 2097.5 -2810 2097.5 -2805 2097.5 -2762.5 2090 -2737.5 2085 -2737.5 2055 -2737.5 2050 -2737.5 2042.5 -2762.5 2042.5 -2805 2042.5 -2810 2047.5 -2810 2070 -2810 {bezier=1}
P 1 14 2085 -2807.5 2090 -2807.5 2095 -2807.5 2095 -2802.5 2095 -2782.5 2095 -2777.5 2090 -2777.5 2080 -2777.5 2075 -2777.5 2075 -2782.5 2075 -2802.5 2075 -2807.5 2080 -2807.5 2085 -2807.5 {bezier=1}
P 1 5 2067.5 -2805 2072.5 -2805 2072.5 -2780 2067.5 -2780 2067.5 -2805 {}
P 1 14 2600 -2940 2622.5 -2940 2627.5 -2940 2627.5 -2935 2627.5 -2892.5 2620 -2867.5 2615 -2867.5 2585 -2867.5 2580 -2867.5 2572.5 -2892.5 2572.5 -2935 2572.5 -2940 2577.5 -2940 2600 -2940 {bezier=1}
P 1 14 2615 -2937.5 2620 -2937.5 2625 -2937.5 2625 -2932.5 2625 -2912.5 2625 -2907.5 2620 -2907.5 2610 -2907.5 2605 -2907.5 2605 -2912.5 2605 -2932.5 2605 -2937.5 2610 -2937.5 2615 -2937.5 {bezier=1}
P 1 5 2597.5 -2935 2602.5 -2935 2602.5 -2910 2597.5 -2910 2597.5 -2935 {}
P 1 14 2585 -2937.5 2590 -2937.5 2595 -2937.5 2595 -2932.5 2595 -2912.5 2595 -2907.5 2590 -2907.5 2580 -2907.5 2575 -2907.5 2575 -2912.5 2575 -2932.5 2575 -2937.5 2580 -2937.5 2585 -2937.5 {}
P 1 10 1960 -2515 1985 -2515 1995 -2505 1995 -2475 1985 -2465 1935 -2465 1925 -2475 1925 -2505 1935 -2515 1960 -2515 {bezier=1}
P 1 10 1960 -2520 1990 -2520 2000 -2510 2000 -2470 1990 -2460 1930 -2460 1920 -2470 1920 -2510 1930 -2520 1960 -2520 {bezier=1}
P 1 10 1960 -2435 1985 -2435 1995 -2425 1995 -2395 1985 -2385 1935 -2385 1925 -2395 1925 -2425 1935 -2435 1960 -2435 {bezier=1}
P 1 10 1960 -2440 1990 -2440 2000 -2430 2000 -2390 1990 -2380 1930 -2380 1920 -2390 1920 -2430 1930 -2440 1960 -2440 {bezier=1}
P 1 14 990 -8820 1012.5 -8820 1017.5 -8820 1017.5 -8815 1017.5 -8772.5 1010 -8747.5 1005 -8747.5 975 -8747.5 970 -8747.5 962.5 -8772.5 962.5 -8815 962.5 -8820 967.5 -8820 990 -8820 {bezier=1}
P 1 14 1005 -8817.5 1010 -8817.5 1015 -8817.5 1015 -8812.5 1015 -8792.5 1015 -8787.5 1010 -8787.5 1000 -8787.5 995 -8787.5 995 -8792.5 995 -8812.5 995 -8817.5 1000 -8817.5 1005 -8817.5 {bezier=1}
P 1 5 987.5 -8815 992.5 -8815 992.5 -8790 987.5 -8790 987.5 -8815 {}
P 1 10 1080 -8805 1105 -8805 1115 -8795 1115 -8765 1105 -8755 1055 -8755 1045 -8765 1045 -8795 1055 -8805 1080 -8805 {bezier=1}
P 1 10 1080 -8810 1110 -8810 1120 -8800 1120 -8760 1110 -8750 1050 -8750 1040 -8760 1040 -8800 1050 -8810 1080 -8810 {bezier=1}
P 1 14 1570 -380 1592.5 -380 1597.5 -380 1597.5 -375 1597.5 -332.5 1590 -307.5 1585 -307.5 1555 -307.5 1550 -307.5 1542.5 -332.5 1542.5 -375 1542.5 -380 1547.5 -380 1570 -380 {bezier=1}
P 1 14 1585 -377.5 1590 -377.5 1595 -377.5 1595 -372.5 1595 -352.5 1595 -347.5 1590 -347.5 1580 -347.5 1575 -347.5 1575 -352.5 1575 -372.5 1575 -377.5 1580 -377.5 1585 -377.5 {bezier=1}
P 1 5 1567.5 -375 1572.5 -375 1572.5 -350 1567.5 -350 1567.5 -375 {}
P 1 14 2080 -330 2102.5 -330 2107.5 -330 2107.5 -325 2107.5 -282.5 2100 -257.5 2095 -257.5 2065 -257.5 2060 -257.5 2052.5 -282.5 2052.5 -325 2052.5 -330 2057.5 -330 2080 -330 {bezier=1}
P 1 14 2095 -327.5 2100 -327.5 2105 -327.5 2105 -322.5 2105 -302.5 2105 -297.5 2100 -297.5 2090 -297.5 2085 -297.5 2085 -302.5 2085 -322.5 2085 -327.5 2090 -327.5 2095 -327.5 {bezier=1}
P 1 5 2077.5 -325 2082.5 -325 2082.5 -300 2077.5 -300 2077.5 -325 {}
P 1 10 2080 -475 2105 -475 2115 -465 2115 -435 2105 -425 2055 -425 2045 -435 2045 -465 2055 -475 2080 -475 {bezier=1}
P 1 10 2080 -480 2110 -480 2120 -470 2120 -430 2110 -420 2050 -420 2040 -430 2040 -470 2050 -480 2080 -480 {bezier=1}
P 1 10 2080 -405 2105 -405 2115 -395 2115 -365 2105 -355 2055 -355 2045 -365 2045 -395 2055 -405 2080 -405 {bezier=1}
P 1 10 2080 -410 2110 -410 2120 -400 2120 -360 2110 -350 2050 -350 2040 -360 2040 -400 2050 -410 2080 -410 {bezier=1}
P 1 10 1920 -2215 1945 -2215 1955 -2205 1955 -2175 1945 -2165 1895 -2165 1885 -2175 1885 -2205 1895 -2215 1920 -2215 {bezier=1}
P 1 10 1920 -2220 1950 -2220 1960 -2210 1960 -2170 1950 -2160 1890 -2160 1880 -2170 1880 -2210 1890 -2220 1920 -2220 {bezier=1}
P 1 10 1830 -1785 1855 -1785 1865 -1775 1865 -1745 1855 -1735 1805 -1735 1795 -1745 1795 -1775 1805 -1785 1830 -1785 {bezier=1}
P 1 10 1830 -1790 1860 -1790 1870 -1780 1870 -1740 1860 -1730 1800 -1730 1790 -1740 1790 -1780 1800 -1790 1830 -1790 {bezier=1}
P 1 14 2500 -3190 2522.5 -3190 2527.5 -3190 2527.5 -3185 2527.5 -3142.5 2520 -3117.5 2515 -3117.5 2485 -3117.5 2480 -3117.5 2472.5 -3142.5 2472.5 -3185 2472.5 -3190 2477.5 -3190 2500 -3190 {bezier=1}
P 1 14 2515 -3187.5 2520 -3187.5 2525 -3187.5 2525 -3182.5 2525 -3162.5 2525 -3157.5 2520 -3157.5 2510 -3157.5 2505 -3157.5 2505 -3162.5 2505 -3182.5 2505 -3187.5 2510 -3187.5 2515 -3187.5 {bezier=1}
P 1 5 2497.5 -3185 2502.5 -3185 2502.5 -3160 2497.5 -3160 2497.5 -3185 {}
P 1 10 1290 -1135 1315 -1135 1325 -1125 1325 -1095 1315 -1085 1265 -1085 1255 -1095 1255 -1125 1265 -1135 1290 -1135 {bezier=1}
P 1 10 1290 -1140 1320 -1140 1330 -1130 1330 -1090 1320 -1080 1260 -1080 1250 -1090 1250 -1130 1260 -1140 1290 -1140 {bezier=1}
P 1 14 1820 -1230 1842.5 -1230 1847.5 -1230 1847.5 -1225 1847.5 -1182.5 1840 -1157.5 1835 -1157.5 1805 -1157.5 1800 -1157.5 1792.5 -1182.5 1792.5 -1225 1792.5 -1230 1797.5 -1230 1820 -1230 {bezier=1}
P 1 14 1835 -1227.5 1840 -1227.5 1845 -1227.5 1845 -1222.5 1845 -1202.5 1845 -1197.5 1840 -1197.5 1830 -1197.5 1825 -1197.5 1825 -1202.5 1825 -1222.5 1825 -1227.5 1830 -1227.5 1835 -1227.5 {bezier=1}
P 1 5 1817.5 -1225 1822.5 -1225 1822.5 -1200 1817.5 -1200 1817.5 -1225 {}
P 1 14 670 -1160 692.5 -1160 697.5 -1160 697.5 -1155 697.5 -1112.5 690 -1087.5 685 -1087.5 655 -1087.5 650 -1087.5 642.5 -1112.5 642.5 -1155 642.5 -1160 647.5 -1160 670 -1160 {bezier=1}
P 1 14 685 -1157.5 690 -1157.5 695 -1157.5 695 -1152.5 695 -1132.5 695 -1127.5 690 -1127.5 680 -1127.5 675 -1127.5 675 -1132.5 675 -1152.5 675 -1157.5 680 -1157.5 685 -1157.5 {bezier=1}
P 1 5 667.5 -1155 672.5 -1155 672.5 -1130 667.5 -1130 667.5 -1155 {}
P 1 14 790 -1160 812.5 -1160 817.5 -1160 817.5 -1155 817.5 -1112.5 810 -1087.5 805 -1087.5 775 -1087.5 770 -1087.5 762.5 -1112.5 762.5 -1155 762.5 -1160 767.5 -1160 790 -1160 {bezier=1}
P 1 14 805 -1157.5 810 -1157.5 815 -1157.5 815 -1152.5 815 -1132.5 815 -1127.5 810 -1127.5 800 -1127.5 795 -1127.5 795 -1132.5 795 -1152.5 795 -1157.5 800 -1157.5 805 -1157.5 {bezier=1}
P 1 5 787.5 -1155 792.5 -1155 792.5 -1130 787.5 -1130 787.5 -1155 {}
P 1 10 790 -1065 815 -1065 825 -1055 825 -1025 815 -1015 765 -1015 755 -1025 755 -1055 765 -1065 790 -1065 {bezier=1}
P 1 10 790 -1070 820 -1070 830 -1060 830 -1020 820 -1010 760 -1010 750 -1020 750 -1060 760 -1070 790 -1070 {bezier=1}
P 1 14 1650 170 1672.5 170 1677.5 170 1677.5 175 1677.5 217.5 1670 242.5 1665 242.5 1635 242.5 1630 242.5 1622.5 217.5 1622.5 175 1622.5 170 1627.5 170 1650 170 {bezier=1}
P 1 14 1635 172.5 1630 172.5 1625 172.5 1625 177.5 1625 197.5 1625 202.5 1630 202.5 1640 202.5 1645 202.5 1645 197.5 1645 177.5 1645 172.5 1640 172.5 1635 172.5 {bezier=1}
P 1 5 1647.5 175 1652.5 175 1652.5 200 1647.5 200 1647.5 175 {}
P 1 10 1650 95 1675 95 1685 105 1685 135 1675 145 1625 145 1615 135 1615 105 1625 95 1650 95 {bezier=1}
P 1 10 1650 90 1680 90 1690 100 1690 140 1680 150 1620 150 1610 140 1610 100 1620 90 1650 90 {bezier=1}
P 1 10 1920 -1645 1945 -1645 1955 -1635 1955 -1605 1945 -1595 1895 -1595 1885 -1605 1885 -1635 1895 -1645 1920 -1645 {bezier=1}
P 1 10 1920 -1650 1950 -1650 1960 -1640 1960 -1600 1950 -1590 1890 -1590 1880 -1600 1880 -1640 1890 -1650 1920 -1650 {bezier=1}
P 1 14 460 -5100 482.5 -5100 487.5 -5100 487.5 -5095 487.5 -5052.5 480 -5027.5 475 -5027.5 445 -5027.5 440 -5027.5 432.5 -5052.5 432.5 -5095 432.5 -5100 437.5 -5100 460 -5100 {bezier=1}
P 1 14 475 -5097.5 480 -5097.5 485 -5097.5 485 -5092.5 485 -5072.5 485 -5067.5 480 -5067.5 470 -5067.5 465 -5067.5 465 -5072.5 465 -5092.5 465 -5097.5 470 -5097.5 475 -5097.5 {bezier=1}
P 1 5 457.5 -5095 462.5 -5095 462.5 -5070 457.5 -5070 457.5 -5095 {}
P 1 14 1000 -5280 1022.5 -5280 1027.5 -5280 1027.5 -5275 1027.5 -5232.5 1020 -5207.5 1015 -5207.5 985 -5207.5 980 -5207.5 972.5 -5232.5 972.5 -5275 972.5 -5280 977.5 -5280 1000 -5280 {bezier=1}
P 1 14 1015 -5277.5 1020 -5277.5 1025 -5277.5 1025 -5272.5 1025 -5252.5 1025 -5247.5 1020 -5247.5 1010 -5247.5 1005 -5247.5 1005 -5252.5 1005 -5272.5 1005 -5277.5 1010 -5277.5 1015 -5277.5 {bezier=1}
P 1 5 997.5 -5275 1002.5 -5275 1002.5 -5250 997.5 -5250 997.5 -5275 {}
P 1 14 2010 -5070 2032.5 -5070 2037.5 -5070 2037.5 -5065 2037.5 -5022.5 2030 -4997.5 2025 -4997.5 1995 -4997.5 1990 -4997.5 1982.5 -5022.5 1982.5 -5065 1982.5 -5070 1987.5 -5070 2010 -5070 {bezier=1}
P 1 14 2025 -5067.5 2030 -5067.5 2035 -5067.5 2035 -5062.5 2035 -5042.5 2035 -5037.5 2030 -5037.5 2020 -5037.5 2015 -5037.5 2015 -5042.5 2015 -5062.5 2015 -5067.5 2020 -5067.5 2025 -5067.5 {bezier=1}
P 1 5 2007.5 -5065 2012.5 -5065 2012.5 -5040 2007.5 -5040 2007.5 -5065 {}
P 1 14 2580 -5070 2602.5 -5070 2607.5 -5070 2607.5 -5065 2607.5 -5022.5 2600 -4997.5 2595 -4997.5 2565 -4997.5 2560 -4997.5 2552.5 -5022.5 2552.5 -5065 2552.5 -5070 2557.5 -5070 2580 -5070 {bezier=1}
P 1 14 2595 -5067.5 2600 -5067.5 2605 -5067.5 2605 -5062.5 2605 -5042.5 2605 -5037.5 2600 -5037.5 2590 -5037.5 2585 -5037.5 2585 -5042.5 2585 -5062.5 2585 -5067.5 2590 -5067.5 2595 -5067.5 {bezier=1}
P 1 5 2577.5 -5065 2582.5 -5065 2582.5 -5040 2577.5 -5040 2577.5 -5065 {}
P 1 14 2280 -5860 2302.5 -5860 2307.5 -5860 2307.5 -5855 2307.5 -5812.5 2300 -5787.5 2295 -5787.5 2265 -5787.5 2260 -5787.5 2252.5 -5812.5 2252.5 -5855 2252.5 -5860 2257.5 -5860 2280 -5860 {bezier=1}
P 1 14 2295 -5857.5 2300 -5857.5 2305 -5857.5 2305 -5852.5 2305 -5832.5 2305 -5827.5 2300 -5827.5 2290 -5827.5 2285 -5827.5 2285 -5832.5 2285 -5852.5 2285 -5857.5 2290 -5857.5 2295 -5857.5 {bezier=1}
P 1 5 2277.5 -5855 2282.5 -5855 2282.5 -5830 2277.5 -5830 2277.5 -5855 {}
P 1 10 2370 -5845 2395 -5845 2405 -5835 2405 -5805 2395 -5795 2345 -5795 2335 -5805 2335 -5835 2345 -5845 2370 -5845 {bezier=1}
P 1 10 2370 -5850 2400 -5850 2410 -5840 2410 -5800 2400 -5790 2340 -5790 2330 -5800 2330 -5840 2340 -5850 2370 -5850 {bezier=1}
P 1 14 1980 -3520 2002.5 -3520 2007.5 -3520 2007.5 -3515 2007.5 -3472.5 2000 -3447.5 1995 -3447.5 1965 -3447.5 1960 -3447.5 1952.5 -3472.5 1952.5 -3515 1952.5 -3520 1957.5 -3520 1980 -3520 {bezier=1}
P 1 14 1995 -3517.5 2000 -3517.5 2005 -3517.5 2005 -3512.5 2005 -3492.5 2005 -3487.5 2000 -3487.5 1990 -3487.5 1985 -3487.5 1985 -3492.5 1985 -3512.5 1985 -3517.5 1990 -3517.5 1995 -3517.5 {bezier=1}
P 1 5 1977.5 -3515 1982.5 -3515 1982.5 -3490 1977.5 -3490 1977.5 -3515 {}
P 1 10 1980 -3675 2005 -3675 2015 -3665 2015 -3635 2005 -3625 1955 -3625 1945 -3635 1945 -3665 1955 -3675 1980 -3675 {bezier=1}
P 1 10 1980 -3680 2010 -3680 2020 -3670 2020 -3630 2010 -3620 1950 -3620 1940 -3630 1940 -3670 1950 -3680 1980 -3680 {bezier=1}
P 1 10 1980 -3595 2005 -3595 2015 -3585 2015 -3555 2005 -3545 1955 -3545 1945 -3555 1945 -3585 1955 -3595 1980 -3595 {bezier=1}
P 1 10 1980 -3600 2010 -3600 2020 -3590 2020 -3550 2010 -3540 1950 -3540 1940 -3550 1940 -3590 1950 -3600 1980 -3600 {bezier=1}
P 1 14 2340 -1820 2362.5 -1820 2367.5 -1820 2367.5 -1815 2367.5 -1772.5 2360 -1747.5 2355 -1747.5 2325 -1747.5 2320 -1747.5 2312.5 -1772.5 2312.5 -1815 2312.5 -1820 2317.5 -1820 2340 -1820 {bezier=1}
P 1 14 2355 -1817.5 2360 -1817.5 2365 -1817.5 2365 -1812.5 2365 -1792.5 2365 -1787.5 2360 -1787.5 2350 -1787.5 2345 -1787.5 2345 -1792.5 2345 -1812.5 2345 -1817.5 2350 -1817.5 2355 -1817.5 {bezier=1}
P 1 5 2337.5 -1815 2342.5 -1815 2342.5 -1790 2337.5 -1790 2337.5 -1815 {}
P 1 14 810 -1940 832.5 -1940 837.5 -1940 837.5 -1935 837.5 -1892.5 830 -1867.5 825 -1867.5 795 -1867.5 790 -1867.5 782.5 -1892.5 782.5 -1935 782.5 -1940 787.5 -1940 810 -1940 {bezier=1}
P 1 14 825 -1937.5 830 -1937.5 835 -1937.5 835 -1932.5 835 -1912.5 835 -1907.5 830 -1907.5 820 -1907.5 815 -1907.5 815 -1912.5 815 -1932.5 815 -1937.5 820 -1937.5 825 -1937.5 {bezier=1}
P 1 5 807.5 -1935 812.5 -1935 812.5 -1910 807.5 -1910 807.5 -1935 {}
P 1 14 1350 -1920 1372.5 -1920 1377.5 -1920 1377.5 -1915 1377.5 -1872.5 1370 -1847.5 1365 -1847.5 1335 -1847.5 1330 -1847.5 1322.5 -1872.5 1322.5 -1915 1322.5 -1920 1327.5 -1920 1350 -1920 {bezier=1}
P 1 14 1365 -1917.5 1370 -1917.5 1375 -1917.5 1375 -1912.5 1375 -1892.5 1375 -1887.5 1370 -1887.5 1360 -1887.5 1355 -1887.5 1355 -1892.5 1355 -1912.5 1355 -1917.5 1360 -1917.5 1365 -1917.5 {bezier=1}
P 1 5 1347.5 -1915 1352.5 -1915 1352.5 -1890 1347.5 -1890 1347.5 -1915 {}
P 1 14 1260 -1540 1282.5 -1540 1287.5 -1540 1287.5 -1535 1287.5 -1492.5 1280 -1467.5 1275 -1467.5 1245 -1467.5 1240 -1467.5 1232.5 -1492.5 1232.5 -1535 1232.5 -1540 1237.5 -1540 1260 -1540 {bezier=1}
P 1 14 1275 -1537.5 1280 -1537.5 1285 -1537.5 1285 -1532.5 1285 -1512.5 1285 -1507.5 1280 -1507.5 1270 -1507.5 1265 -1507.5 1265 -1512.5 1265 -1532.5 1265 -1537.5 1270 -1537.5 1275 -1537.5 {bezier=1}
P 1 5 1257.5 -1535 1262.5 -1535 1262.5 -1510 1257.5 -1510 1257.5 -1535 {}
P 1 14 2520 -1490 2542.5 -1490 2547.5 -1490 2547.5 -1485 2547.5 -1442.5 2540 -1417.5 2535 -1417.5 2505 -1417.5 2500 -1417.5 2492.5 -1442.5 2492.5 -1485 2492.5 -1490 2497.5 -1490 2520 -1490 {bezier=1}
P 1 14 2535 -1487.5 2540 -1487.5 2545 -1487.5 2545 -1482.5 2545 -1462.5 2545 -1457.5 2540 -1457.5 2530 -1457.5 2525 -1457.5 2525 -1462.5 2525 -1482.5 2525 -1487.5 2530 -1487.5 2535 -1487.5 {bezier=1}
P 1 5 2517.5 -1485 2522.5 -1485 2522.5 -1460 2517.5 -1460 2517.5 -1485 {}
P 1 14 2480 -80 2502.5 -80 2507.5 -80 2507.5 -75 2507.5 -32.5 2500 -7.5 2495 -7.5 2465 -7.5 2460 -7.5 2452.5 -32.5 2452.5 -75 2452.5 -80 2457.5 -80 2480 -80 {bezier=1}
P 1 14 2465 -77.5 2460 -77.5 2455 -77.5 2455 -72.5 2455 -52.5 2455 -47.5 2460 -47.5 2470 -47.5 2475 -47.5 2475 -52.5 2475 -72.5 2475 -77.5 2470 -77.5 2465 -77.5 {bezier=1}
P 1 5 2477.5 -75 2482.5 -75 2482.5 -50 2477.5 -50 2477.5 -75 {}
P 2 7 897.5 -5980 893.75 -5985 885 -5985 888.75 -5980 885 -5975 893.75 -5975 897.5 -5980 {fill=true}
P 2 7 1437.5 -5980 1433.75 -5985 1425 -5985 1428.75 -5980 1425 -5975 1433.75 -5975 1437.5 -5980 {fill=true}
P 2 7 2277.5 -5980 2273.75 -5985 2265 -5985 2268.75 -5980 2265 -5975 2273.75 -5975 2277.5 -5980 {fill=true}
P 2 7 2030 -810 2020 -820 2030 -820 2030 -820 2010 -830 2020 -810 2020 -820 {}
P 2 7 1520 -710 1510 -720 1520 -720 1520 -720 1500 -730 1510 -710 1510 -720 {}
P 2 7 2030 -430 2020 -440 2030 -440 2030 -440 2010 -450 2020 -430 2020 -440 {}
P 2 7 1520 -330 1510 -340 1520 -340 1520 -340 1500 -350 1510 -330 1510 -340 {}
P 3 6 1280 -1390 1280 -1400 1270 -1400 1280 -1420 1290 -1400 1280 -1400 {}
P 3 6 740 -1390 740 -1400 730 -1400 740 -1420 750 -1400 740 -1400 {}
P 5 7 1105 -8220 1101.25 -8225 1092.5 -8225 1096.25 -8220 1092.5 -8215 1101.25 -8215 1105 -8220 {fill=true}
P 5 7 1427.5 -8250 1423.75 -8255 1415 -8255 1418.75 -8250 1415 -8245 1423.75 -8245 1427.5 -8250 {fill=true}
P 5 7 1645 -8220 1641.25 -8225 1632.5 -8225 1636.25 -8220 1632.5 -8215 1641.25 -8215 1645 -8220 {fill=true}
P 5 7 1967.5 -8250 1963.75 -8255 1955 -8255 1958.75 -8250 1955 -8245 1963.75 -8245 1967.5 -8250 {fill=true}
P 5 7 575 -8220 571.25 -8225 562.5 -8225 566.25 -8220 562.5 -8215 571.25 -8215 575 -8220 {fill=true}
P 5 7 897.5 -8250 893.75 -8255 885 -8255 888.75 -8250 885 -8245 893.75 -8245 897.5 -8250 {fill=true}
P 5 7 575 -7760 571.25 -7765 562.5 -7765 566.25 -7760 562.5 -7755 571.25 -7755 575 -7760 {fill=true}
P 5 7 897.5 -7790 893.75 -7795 885 -7795 888.75 -7790 885 -7785 893.75 -7785 897.5 -7790 {fill=true}
P 5 7 1115 -7760 1111.25 -7765 1102.5 -7765 1106.25 -7760 1102.5 -7755 1111.25 -7755 1115 -7760 {fill=true}
P 5 7 1437.5 -7790 1433.75 -7795 1425 -7795 1428.75 -7790 1425 -7785 1433.75 -7785 1437.5 -7790 {fill=true}
P 5 7 575 -6930 571.25 -6935 562.5 -6935 566.25 -6930 562.5 -6925 571.25 -6925 575 -6930 {fill=true}
P 5 7 897.5 -6960 893.75 -6965 885 -6965 888.75 -6960 885 -6955 893.75 -6955 897.5 -6960 {fill=true}
P 5 7 1115 -6930 1111.25 -6935 1102.5 -6935 1106.25 -6930 1102.5 -6925 1111.25 -6925 1115 -6930 {fill=true}
P 5 7 1437.5 -6960 1433.75 -6965 1425 -6965 1428.75 -6960 1425 -6955 1433.75 -6955 1437.5 -6960 {fill=true}
P 5 7 575 -6440 571.25 -6445 562.5 -6445 566.25 -6440 562.5 -6435 571.25 -6435 575 -6440 {fill=true}
P 5 7 897.5 -6470 893.75 -6475 885 -6475 888.75 -6470 885 -6465 893.75 -6465 897.5 -6470 {fill=true}
P 5 7 1115 -6440 1111.25 -6445 1102.5 -6445 1106.25 -6440 1102.5 -6435 1111.25 -6435 1115 -6440 {fill=true}
P 5 7 1437.5 -6470 1433.75 -6475 1425 -6475 1428.75 -6470 1425 -6465 1433.75 -6465 1437.5 -6470 {fill=true}
P 5 7 575 -5950 571.25 -5955 562.5 -5955 566.25 -5950 562.5 -5945 571.25 -5945 575 -5950 {fill=true}
P 5 7 1765 -5950 1761.25 -5955 1752.5 -5955 1756.25 -5950 1752.5 -5945 1761.25 -5945 1765 -5950 {fill=true}
P 5 7 1115 -5950 1111.25 -5955 1102.5 -5955 1106.25 -5950 1102.5 -5945 1111.25 -5945 1115 -5950 {fill=true}
P 5 7 1105 -7390 1101.25 -7395 1092.5 -7395 1096.25 -7390 1092.5 -7385 1101.25 -7385 1105 -7390 {fill=true}
P 5 7 1427.5 -7420 1423.75 -7425 1415 -7425 1418.75 -7420 1415 -7415 1423.75 -7415 1427.5 -7420 {fill=true}
P 5 7 575 -7390 571.25 -7395 562.5 -7395 566.25 -7390 562.5 -7385 571.25 -7385 575 -7390 {fill=true}
P 5 7 897.5 -7420 893.75 -7425 885 -7425 888.75 -7420 885 -7415 893.75 -7415 897.5 -7420 {fill=true}
P 5 7 1605 -7390 1601.25 -7395 1592.5 -7395 1596.25 -7390 1592.5 -7385 1601.25 -7385 1605 -7390 {fill=true}
P 5 7 1927.5 -7420 1923.75 -7425 1915 -7425 1918.75 -7420 1915 -7415 1923.75 -7415 1927.5 -7420 {fill=true}
P 5 7 1645 -8690 1641.25 -8695 1632.5 -8695 1636.25 -8690 1632.5 -8685 1641.25 -8685 1645 -8690 {fill=true}
P 5 7 1967.5 -8720 1963.75 -8725 1955 -8725 1958.75 -8720 1955 -8715 1963.75 -8715 1967.5 -8720 {fill=true}
P 5 7 575 -8690 571.25 -8695 562.5 -8695 566.25 -8690 562.5 -8685 571.25 -8685 575 -8690 {fill=true}
P 5 7 897.5 -8720 893.75 -8725 885 -8725 888.75 -8720 885 -8715 893.75 -8715 897.5 -8720 {fill=true}
P 5 7 2105 -8690 2101.25 -8695 2092.5 -8695 2096.25 -8690 2092.5 -8685 2101.25 -8685 2105 -8690 {fill=true}
P 5 7 2427.5 -8720 2423.75 -8725 2415 -8725 2418.75 -8720 2415 -8715 2423.75 -8715 2427.5 -8720 {fill=true}
P 5 7 595 -5510 591.25 -5515 582.5 -5515 586.25 -5510 582.5 -5505 591.25 -5505 595 -5510 {fill=true}
P 5 7 917.5 -5540 913.75 -5545 905 -5545 908.75 -5540 905 -5535 913.75 -5535 917.5 -5540 {fill=true}
P 5 7 1135 -5510 1131.25 -5515 1122.5 -5515 1126.25 -5510 1122.5 -5505 1131.25 -5505 1135 -5510 {fill=true}
P 5 7 1457.5 -5540 1453.75 -5545 1445 -5545 1448.75 -5540 1445 -5535 1453.75 -5535 1457.5 -5540 {fill=true}
P 5 7 1695 -5510 1691.25 -5515 1682.5 -5515 1686.25 -5510 1682.5 -5505 1691.25 -5505 1695 -5510 {fill=true}
P 5 7 2017.5 -5540 2013.75 -5545 2005 -5545 2008.75 -5540 2005 -5535 2013.75 -5535 2017.5 -5540 {fill=true}
P 5 7 2265 -5510 2261.25 -5515 2252.5 -5515 2256.25 -5510 2252.5 -5505 2261.25 -5505 2265 -5510 {fill=true}
P 5 7 2587.5 -5540 2583.75 -5545 2575 -5545 2578.75 -5540 2575 -5535 2583.75 -5535 2587.5 -5540 {fill=true}
P 5 7 595 -4710 591.25 -4715 582.5 -4715 586.25 -4710 582.5 -4705 591.25 -4705 595 -4710 {fill=true}
P 5 7 917.5 -4740 913.75 -4745 905 -4745 908.75 -4740 905 -4735 913.75 -4735 917.5 -4740 {fill=true}
P 5 7 1135 -4710 1131.25 -4715 1122.5 -4715 1126.25 -4710 1122.5 -4705 1131.25 -4705 1135 -4710 {fill=true}
P 5 7 1457.5 -4740 1453.75 -4745 1445 -4745 1448.75 -4740 1445 -4735 1453.75 -4735 1457.5 -4740 {fill=true}
P 5 7 2265 -4710 2261.25 -4715 2252.5 -4715 2256.25 -4710 2252.5 -4705 2261.25 -4705 2265 -4710 {fill=true}
P 5 7 2587.5 -4740 2583.75 -4745 2575 -4745 2578.75 -4740 2575 -4735 2583.75 -4735 2587.5 -4740 {fill=true}
P 5 7 595 -5130 591.25 -5135 582.5 -5135 586.25 -5130 582.5 -5125 591.25 -5125 595 -5130 {fill=true}
P 5 7 917.5 -5160 913.75 -5165 905 -5165 908.75 -5160 905 -5155 913.75 -5155 917.5 -5160 {fill=true}
P 5 7 595 -4300 591.25 -4305 582.5 -4305 586.25 -4300 582.5 -4295 591.25 -4295 595 -4300 {fill=true}
P 5 7 917.5 -4330 913.75 -4335 905 -4335 908.75 -4330 905 -4325 913.75 -4325 917.5 -4330 {fill=true}
P 5 7 1695 -4300 1691.25 -4305 1682.5 -4305 1686.25 -4300 1682.5 -4295 1691.25 -4295 1695 -4300 {fill=true}
P 5 7 2017.5 -4330 2013.75 -4335 2005 -4335 2008.75 -4330 2005 -4325 2013.75 -4325 2017.5 -4330 {fill=true}
P 5 7 1135 -4300 1131.25 -4305 1122.5 -4305 1126.25 -4300 1122.5 -4295 1131.25 -4295 1135 -4300 {fill=true}
P 5 7 1457.5 -4330 1453.75 -4335 1445 -4335 1448.75 -4330 1445 -4325 1453.75 -4325 1457.5 -4330 {fill=true}
P 5 7 1105 -8690 1101.25 -8695 1092.5 -8695 1096.25 -8690 1092.5 -8685 1101.25 -8685 1105 -8690 {fill=true}
P 5 7 1427.5 -8720 1423.75 -8725 1415 -8725 1418.75 -8720 1415 -8715 1423.75 -8715 1427.5 -8720 {fill=true}
P 5 7 655 70 651.25 65 642.5 65 646.25 70 642.5 75 651.25 75 655 70 {fill=true}
P 5 7 977.5 40 973.75 35 965 35 968.75 40 965 45 973.75 45 977.5 40 {fill=true}
P 5 7 1305 70 1301.25 65 1292.5 65 1296.25 70 1292.5 75 1301.25 75 1305 70 {fill=true}
P 5 7 1627.5 40 1623.75 35 1615 35 1618.75 40 1615 45 1623.75 45 1627.5 40 {fill=true}
P 5 7 1135 -5130 1131.25 -5135 1122.5 -5135 1126.25 -5130 1122.5 -5125 1131.25 -5125 1135 -5130 {fill=true}
P 5 7 1457.5 -5160 1453.75 -5165 1445 -5165 1448.75 -5160 1445 -5155 1453.75 -5155 1457.5 -5160 {fill=true}
P 5 7 1695 -5130 1691.25 -5135 1682.5 -5135 1686.25 -5130 1682.5 -5125 1691.25 -5125 1695 -5130 {fill=true}
P 5 7 2017.5 -5160 2013.75 -5165 2005 -5165 2008.75 -5160 2005 -5155 2013.75 -5155 2017.5 -5160 {fill=true}
P 5 7 2265 -5130 2261.25 -5135 2252.5 -5135 2256.25 -5130 2252.5 -5125 2261.25 -5125 2265 -5130 {fill=true}
P 5 7 2587.5 -5160 2583.75 -5165 2575 -5165 2578.75 -5160 2575 -5155 2583.75 -5155 2587.5 -5160 {fill=true}
P 5 7 1865 70 1861.25 65 1852.5 65 1856.25 70 1852.5 75 1861.25 75 1865 70 {fill=true}
P 5 7 2187.5 40 2183.75 35 2175 35 2178.75 40 2175 45 2183.75 45 2187.5 40 {fill=true}
P 7 14 905 -8077.5 910 -8077.5 915 -8077.5 915 -8072.5 915 -8052.5 915 -8047.5 910 -8047.5 900 -8047.5 895 -8047.5 895 -8052.5 895 -8072.5 895 -8077.5 900 -8077.5 905 -8077.5 {fill=1
bezier=1}
P 7 14 1335 -8077.5 1340 -8077.5 1345 -8077.5 1345 -8072.5 1345 -8052.5 1345 -8047.5 1340 -8047.5 1330 -8047.5 1325 -8047.5 1325 -8052.5 1325 -8072.5 1325 -8077.5 1330 -8077.5 1335 -8077.5 {fill=1
bezier=1}
P 7 14 1405 -7887.5 1410 -7887.5 1415 -7887.5 1415 -7882.5 1415 -7862.5 1415 -7857.5 1410 -7857.5 1400 -7857.5 1395 -7857.5 1395 -7862.5 1395 -7882.5 1395 -7887.5 1400 -7887.5 1405 -7887.5 {fill=1
bezier=1}
P 7 14 1425 -7067.5 1430 -7067.5 1435 -7067.5 1435 -7062.5 1435 -7042.5 1435 -7037.5 1430 -7037.5 1420 -7037.5 1415 -7037.5 1415 -7042.5 1415 -7062.5 1415 -7067.5 1420 -7067.5 1425 -7067.5 {fill=1
bezier=1}
P 7 14 1425 -6577.5 1430 -6577.5 1435 -6577.5 1435 -6572.5 1435 -6552.5 1435 -6547.5 1430 -6547.5 1420 -6547.5 1415 -6547.5 1415 -6552.5 1415 -6572.5 1415 -6577.5 1420 -6577.5 1425 -6577.5 {fill=1
bezier=1}
P 7 14 935 -5847.5 940 -5847.5 945 -5847.5 945 -5842.5 945 -5822.5 945 -5817.5 940 -5817.5 930 -5817.5 925 -5817.5 925 -5822.5 925 -5842.5 925 -5847.5 930 -5847.5 935 -5847.5 {fill=1
bezier=1}
P 7 14 1415 -5857.5 1420 -5857.5 1425 -5857.5 1425 -5852.5 1425 -5832.5 1425 -5827.5 1420 -5827.5 1410 -5827.5 1405 -5827.5 1405 -5832.5 1405 -5852.5 1405 -5857.5 1410 -5857.5 1415 -5857.5 {fill=1
bezier=1}
P 7 14 905 -7247.5 910 -7247.5 915 -7247.5 915 -7242.5 915 -7222.5 915 -7217.5 910 -7217.5 900 -7217.5 895 -7217.5 895 -7222.5 895 -7242.5 895 -7247.5 900 -7247.5 905 -7247.5 {fill=1
bezier=1}
P 7 14 1335 -7247.5 1340 -7247.5 1345 -7247.5 1345 -7242.5 1345 -7222.5 1345 -7217.5 1340 -7217.5 1330 -7217.5 1325 -7217.5 1325 -7222.5 1325 -7242.5 1325 -7247.5 1330 -7247.5 1335 -7247.5 {fill=1}
P 7 14 905 -8547.5 910 -8547.5 915 -8547.5 915 -8542.5 915 -8522.5 915 -8517.5 910 -8517.5 900 -8517.5 895 -8517.5 895 -8522.5 895 -8542.5 895 -8547.5 900 -8547.5 905 -8547.5 {fill=1
bezier=1}
P 7 14 1615 -8537.5 1620 -8537.5 1625 -8537.5 1625 -8532.5 1625 -8512.5 1625 -8507.5 1620 -8507.5 1610 -8507.5 1605 -8507.5 1605 -8512.5 1605 -8532.5 1605 -8537.5 1610 -8537.5 1615 -8537.5 {fill=1
bezier=1}
P 7 14 2395 -8527.5 2400 -8527.5 2405 -8527.5 2405 -8522.5 2405 -8502.5 2405 -8497.5 2400 -8497.5 2390 -8497.5 2385 -8497.5 2385 -8502.5 2385 -8522.5 2385 -8527.5 2390 -8527.5 2395 -8527.5 {fill=1
bezier=1}
P 7 14 1475 -5657.5 1480 -5657.5 1485 -5657.5 1485 -5652.5 1485 -5632.5 1485 -5627.5 1480 -5627.5 1470 -5627.5 1465 -5627.5 1465 -5632.5 1465 -5652.5 1465 -5657.5 1470 -5657.5 1475 -5657.5 {fill=1
bezier=1}
P 7 14 1925 -5727.5 1930 -5727.5 1935 -5727.5 1935 -5722.5 1935 -5702.5 1935 -5697.5 1930 -5697.5 1920 -5697.5 1915 -5697.5 1915 -5702.5 1915 -5722.5 1915 -5727.5 1920 -5727.5 1925 -5727.5 {fill=1
bezier=1}
P 7 14 675 -4827.5 680 -4827.5 685 -4827.5 685 -4822.5 685 -4802.5 685 -4797.5 680 -4797.5 670 -4797.5 665 -4797.5 665 -4802.5 665 -4822.5 665 -4827.5 670 -4827.5 675 -4827.5 {fill=1
bezier=1}
P 7 14 1335 -4847.5 1340 -4847.5 1345 -4847.5 1345 -4842.5 1345 -4822.5 1345 -4817.5 1340 -4817.5 1330 -4817.5 1325 -4817.5 1325 -4822.5 1325 -4842.5 1325 -4847.5 1330 -4847.5 1335 -4847.5 {fill=1
bezier=1}
P 7 14 835 -4467.5 840 -4467.5 845 -4467.5 845 -4462.5 845 -4442.5 845 -4437.5 840 -4437.5 830 -4437.5 825 -4437.5 825 -4442.5 825 -4462.5 825 -4467.5 830 -4467.5 835 -4467.5 {fill=1}
P 7 14 1235 -4417.5 1240 -4417.5 1245 -4417.5 1245 -4412.5 1245 -4392.5 1245 -4387.5 1240 -4387.5 1230 -4387.5 1225 -4387.5 1225 -4392.5 1225 -4412.5 1225 -4417.5 1230 -4417.5 1235 -4417.5 {fill=1
bezier=1}
P 7 14 1415 -3897.5 1420 -3897.5 1425 -3897.5 1425 -3892.5 1425 -3872.5 1425 -3867.5 1420 -3867.5 1410 -3867.5 1405 -3867.5 1405 -3872.5 1405 -3892.5 1405 -3897.5 1410 -3897.5 1415 -3897.5 {fill=1
bezier=1}
P 7 14 1685 -3897.5 1690 -3897.5 1695 -3897.5 1695 -3892.5 1695 -3872.5 1695 -3867.5 1690 -3867.5 1680 -3867.5 1675 -3867.5 1675 -3872.5 1675 -3892.5 1675 -3897.5 1680 -3897.5 1685 -3897.5 {fill=1
bezier=1}
P 7 14 1415 -3517.5 1420 -3517.5 1425 -3517.5 1425 -3512.5 1425 -3492.5 1425 -3487.5 1420 -3487.5 1410 -3487.5 1405 -3487.5 1405 -3492.5 1405 -3512.5 1405 -3517.5 1410 -3517.5 1415 -3517.5 {fill=1
bezier=1}
P 7 14 2065 -787.5 2070 -787.5 2075 -787.5 2075 -782.5 2075 -762.5 2075 -757.5 2070 -757.5 2060 -757.5 2055 -757.5 2055 -762.5 2055 -782.5 2055 -787.5 2060 -787.5 2065 -787.5 {fill=1
bezier=1}
P 7 14 1555 -757.5 1560 -757.5 1565 -757.5 1565 -752.5 1565 -732.5 1565 -727.5 1560 -727.5 1550 -727.5 1545 -727.5 1545 -732.5 1545 -752.5 1545 -757.5 1550 -757.5 1555 -757.5 {fill=1
bezier=1}
P 7 14 1445 -3157.5 1440 -3157.5 1435 -3157.5 1435 -3152.5 1435 -3132.5 1435 -3127.5 1440 -3127.5 1450 -3127.5 1455 -3127.5 1455 -3132.5 1455 -3152.5 1455 -3157.5 1450 -3157.5 1445 -3157.5 {fill=1
bezier=1}
P 7 14 1945 -3267.5 1950 -3267.5 1955 -3267.5 1955 -3262.5 1955 -3242.5 1955 -3237.5 1950 -3237.5 1940 -3237.5 1935 -3237.5 1935 -3242.5 1935 -3262.5 1935 -3267.5 1940 -3267.5 1945 -3267.5 {fill=1
bezier=1}
P 7 14 1565 -2747.5 1570 -2747.5 1575 -2747.5 1575 -2742.5 1575 -2722.5 1575 -2717.5 1570 -2717.5 1560 -2717.5 1555 -2717.5 1555 -2722.5 1555 -2742.5 1555 -2747.5 1560 -2747.5 1565 -2747.5 {fill=1
bezier=1}
P 7 14 2055 -2807.5 2060 -2807.5 2065 -2807.5 2065 -2802.5 2065 -2782.5 2065 -2777.5 2060 -2777.5 2050 -2777.5 2045 -2777.5 2045 -2782.5 2045 -2802.5 2045 -2807.5 2050 -2807.5 2055 -2807.5 {fill=1
bezier=1}
P 7 14 1795 -4447.5 1800 -4447.5 1805 -4447.5 1805 -4442.5 1805 -4422.5 1805 -4417.5 1800 -4417.5 1790 -4417.5 1785 -4417.5 1785 -4422.5 1785 -4442.5 1785 -4447.5 1790 -4447.5 1795 -4447.5 {}
P 7 14 975 -8817.5 980 -8817.5 985 -8817.5 985 -8812.5 985 -8792.5 985 -8787.5 980 -8787.5 970 -8787.5 965 -8787.5 965 -8792.5 965 -8812.5 965 -8817.5 970 -8817.5 975 -8817.5 {fill=1
bezier=1}
P 7 14 1555 -377.5 1560 -377.5 1565 -377.5 1565 -372.5 1565 -352.5 1565 -347.5 1560 -347.5 1550 -347.5 1545 -347.5 1545 -352.5 1545 -372.5 1545 -377.5 1550 -377.5 1555 -377.5 {fill=1
bezier=1}
P 7 14 2065 -327.5 2070 -327.5 2075 -327.5 2075 -322.5 2075 -302.5 2075 -297.5 2070 -297.5 2060 -297.5 2055 -297.5 2055 -302.5 2055 -322.5 2055 -327.5 2060 -327.5 2065 -327.5 {fill=1
bezier=1}
P 7 14 2485 -3187.5 2490 -3187.5 2495 -3187.5 2495 -3182.5 2495 -3162.5 2495 -3157.5 2490 -3157.5 2480 -3157.5 2475 -3157.5 2475 -3162.5 2475 -3182.5 2475 -3187.5 2480 -3187.5 2485 -3187.5 {fill=1
bezier=1}
P 7 14 1805 -1227.5 1810 -1227.5 1815 -1227.5 1815 -1222.5 1815 -1202.5 1815 -1197.5 1810 -1197.5 1800 -1197.5 1795 -1197.5 1795 -1202.5 1795 -1222.5 1795 -1227.5 1800 -1227.5 1805 -1227.5 {fill=1
bezier=1}
P 7 14 655 -1157.5 660 -1157.5 665 -1157.5 665 -1152.5 665 -1132.5 665 -1127.5 660 -1127.5 650 -1127.5 645 -1127.5 645 -1132.5 645 -1152.5 645 -1157.5 650 -1157.5 655 -1157.5 {fill=1
bezier=1}
P 7 14 775 -1157.5 780 -1157.5 785 -1157.5 785 -1152.5 785 -1132.5 785 -1127.5 780 -1127.5 770 -1127.5 765 -1127.5 765 -1132.5 765 -1152.5 765 -1157.5 770 -1157.5 775 -1157.5 {fill=1
bezier=1}
P 7 14 1665 172.5 1660 172.5 1655 172.5 1655 177.5 1655 197.5 1655 202.5 1660 202.5 1670 202.5 1675 202.5 1675 197.5 1675 177.5 1675 172.5 1670 172.5 1665 172.5 {fill=1
bezier=1}
P 7 14 445 -5097.5 450 -5097.5 455 -5097.5 455 -5092.5 455 -5072.5 455 -5067.5 450 -5067.5 440 -5067.5 435 -5067.5 435 -5072.5 435 -5092.5 435 -5097.5 440 -5097.5 445 -5097.5 {fill=1
bezier=1}
P 7 14 985 -5277.5 990 -5277.5 995 -5277.5 995 -5272.5 995 -5252.5 995 -5247.5 990 -5247.5 980 -5247.5 975 -5247.5 975 -5252.5 975 -5272.5 975 -5277.5 980 -5277.5 985 -5277.5 {fill=1
bezier=1}
P 7 14 1995 -5067.5 2000 -5067.5 2005 -5067.5 2005 -5062.5 2005 -5042.5 2005 -5037.5 2000 -5037.5 1990 -5037.5 1985 -5037.5 1985 -5042.5 1985 -5062.5 1985 -5067.5 1990 -5067.5 1995 -5067.5 {fill=1
bezier=1}
P 7 14 2565 -5067.5 2570 -5067.5 2575 -5067.5 2575 -5062.5 2575 -5042.5 2575 -5037.5 2570 -5037.5 2560 -5037.5 2555 -5037.5 2555 -5042.5 2555 -5062.5 2555 -5067.5 2560 -5067.5 2565 -5067.5 {fill=1
bezier=1}
P 7 14 2265 -5857.5 2270 -5857.5 2275 -5857.5 2275 -5852.5 2275 -5832.5 2275 -5827.5 2270 -5827.5 2260 -5827.5 2255 -5827.5 2255 -5832.5 2255 -5852.5 2255 -5857.5 2260 -5857.5 2265 -5857.5 {fill=1
bezier=1}
P 7 14 1965 -3517.5 1970 -3517.5 1975 -3517.5 1975 -3512.5 1975 -3492.5 1975 -3487.5 1970 -3487.5 1960 -3487.5 1955 -3487.5 1955 -3492.5 1955 -3512.5 1955 -3517.5 1960 -3517.5 1965 -3517.5 {fill=1
bezier=1}
P 7 14 2325 -1817.5 2330 -1817.5 2335 -1817.5 2335 -1812.5 2335 -1792.5 2335 -1787.5 2330 -1787.5 2320 -1787.5 2315 -1787.5 2315 -1792.5 2315 -1812.5 2315 -1817.5 2320 -1817.5 2325 -1817.5 {fill=1
bezier=1}
P 7 14 795 -1937.5 800 -1937.5 805 -1937.5 805 -1932.5 805 -1912.5 805 -1907.5 800 -1907.5 790 -1907.5 785 -1907.5 785 -1912.5 785 -1932.5 785 -1937.5 790 -1937.5 795 -1937.5 {fill=1
bezier=1}
P 7 14 1335 -1917.5 1340 -1917.5 1345 -1917.5 1345 -1912.5 1345 -1892.5 1345 -1887.5 1340 -1887.5 1330 -1887.5 1325 -1887.5 1325 -1892.5 1325 -1912.5 1325 -1917.5 1330 -1917.5 1335 -1917.5 {fill=1
bezier=1}
P 7 14 1245 -1537.5 1250 -1537.5 1255 -1537.5 1255 -1532.5 1255 -1512.5 1255 -1507.5 1250 -1507.5 1240 -1507.5 1235 -1507.5 1235 -1512.5 1235 -1532.5 1235 -1537.5 1240 -1537.5 1245 -1537.5 {fill=1
bezier=1}
P 7 14 2505 -1487.5 2510 -1487.5 2515 -1487.5 2515 -1482.5 2515 -1462.5 2515 -1457.5 2510 -1457.5 2500 -1457.5 2495 -1457.5 2495 -1462.5 2495 -1482.5 2495 -1487.5 2500 -1487.5 2505 -1487.5 {fill=1
bezier=1}
P 7 14 2495 -77.5 2490 -77.5 2485 -77.5 2485 -72.5 2485 -52.5 2485 -47.5 2490 -47.5 2500 -47.5 2505 -47.5 2505 -52.5 2505 -72.5 2505 -77.5 2500 -77.5 2495 -77.5 {fill=1
bezier=1}
P 9 8 1770 -4790 1912.5 -4762.5 1890 -4730 1980 -4670 1960 -4640 1870 -4700 1845 -4665 1770 -4790 {fill=0}
P 10 7 880 -8050 872.5 -8057.5 877.5 -8062.5 862.5 -8067.5 867.5 -8052.5 872.5 -8057.5 880 -8050 {fill=1}
P 10 7 2110 -8100 2102.5 -8107.5 2107.5 -8112.5 2092.5 -8117.5 2097.5 -8102.5 2102.5 -8107.5 2110 -8100 {fill=1}
P 10 7 1330 -8090 1322.5 -8097.5 1327.5 -8102.5 1312.5 -8107.5 1317.5 -8092.5 1322.5 -8097.5 1330 -8090 {fill=1}
P 10 7 760 -7830 752.5 -7837.5 757.5 -7842.5 742.5 -7847.5 747.5 -7832.5 752.5 -7837.5 760 -7830 {fill=1}
P 10 7 1380 -7830 1372.5 -7837.5 1377.5 -7842.5 1362.5 -7847.5 1367.5 -7832.5 1372.5 -7837.5 1380 -7830 {fill=1}
P 10 7 760 -7000 752.5 -7007.5 757.5 -7012.5 742.5 -7017.5 747.5 -7002.5 752.5 -7007.5 760 -7000 {fill=1}
P 10 7 1380 -7000 1372.5 -7007.5 1377.5 -7012.5 1362.5 -7017.5 1367.5 -7002.5 1372.5 -7007.5 1380 -7000 {fill=1}
P 10 7 760 -6510 752.5 -6517.5 757.5 -6522.5 742.5 -6527.5 747.5 -6512.5 752.5 -6517.5 760 -6510 {fill=1}
P 10 7 1380 -6510 1372.5 -6517.5 1377.5 -6522.5 1362.5 -6527.5 1367.5 -6512.5 1372.5 -6517.5 1380 -6510 {fill=1}
P 10 7 920 -5790 912.5 -5797.5 917.5 -5802.5 902.5 -5807.5 907.5 -5792.5 912.5 -5797.5 920 -5790 {fill=1}
P 10 7 1390 -5850 1382.5 -5857.5 1387.5 -5862.5 1372.5 -5867.5 1377.5 -5852.5 1382.5 -5857.5 1390 -5850 {fill=1}
P 10 7 2240 -5850 2232.5 -5857.5 2237.5 -5862.5 2222.5 -5867.5 2227.5 -5852.5 2232.5 -5857.5 2240 -5850 {fill=1}
P 10 7 880 -7220 872.5 -7227.5 877.5 -7232.5 862.5 -7237.5 867.5 -7222.5 872.5 -7227.5 880 -7220 {fill=1}
P 10 7 2110 -7270 2102.5 -7277.5 2107.5 -7282.5 2092.5 -7287.5 2097.5 -7272.5 2102.5 -7277.5 2110 -7270 {fill=1}
P 10 7 1330 -7260 1322.5 -7267.5 1327.5 -7272.5 1312.5 -7277.5 1317.5 -7262.5 1322.5 -7267.5 1330 -7260 {fill=1}
P 10 7 880 -8520 872.5 -8527.5 877.5 -8532.5 862.5 -8537.5 867.5 -8522.5 872.5 -8527.5 880 -8520 {fill=1}
P 10 7 1630 -8550 1622.5 -8557.5 1627.5 -8562.5 1612.5 -8567.5 1617.5 -8552.5 1622.5 -8557.5 1630 -8550 {fill=1}
P 10 7 2410 -8540 2402.5 -8547.5 2407.5 -8552.5 2392.5 -8557.5 2397.5 -8542.5 2402.5 -8547.5 2410 -8540 {fill=1}
P 10 7 780 -5610 772.5 -5617.5 777.5 -5622.5 762.5 -5627.5 767.5 -5612.5 772.5 -5617.5 780 -5610 {fill=1}
P 10 7 1450 -5610 1442.5 -5617.5 1447.5 -5622.5 1432.5 -5627.5 1437.5 -5612.5 1442.5 -5617.5 1450 -5610 {fill=1}
P 10 7 1950 -5610 1942.5 -5617.5 1947.5 -5622.5 1932.5 -5627.5 1937.5 -5612.5 1942.5 -5617.5 1950 -5610 {fill=1}
P 10 7 2520 -5640 2512.5 -5647.5 2517.5 -5652.5 2502.5 -5657.5 2507.5 -5642.5 2512.5 -5647.5 2520 -5640 {fill=1}
P 10 7 730 -4840 722.5 -4847.5 727.5 -4852.5 712.5 -4857.5 717.5 -4842.5 722.5 -4847.5 730 -4840 {fill=1}
P 10 7 1310 -4840 1302.5 -4847.5 1307.5 -4852.5 1292.5 -4857.5 1297.5 -4842.5 1302.5 -4847.5 1310 -4840 {fill=1}
P 10 7 2520 -4910 2512.5 -4917.5 2517.5 -4922.5 2502.5 -4927.5 2507.5 -4912.5 2512.5 -4917.5 2520 -4910 {fill=1}
P 10 7 820 -4470 812.5 -4477.5 817.5 -4482.5 802.5 -4487.5 807.5 -4472.5 812.5 -4477.5 820 -4470 {fill=1}
P 10 7 1820 -4460 1812.5 -4467.5 1817.5 -4472.5 1802.5 -4477.5 1807.5 -4462.5 1812.5 -4467.5 1820 -4460 {fill=1}
P 10 7 1260 -4430 1252.5 -4437.5 1257.5 -4442.5 1242.5 -4447.5 1247.5 -4432.5 1252.5 -4437.5 1260 -4430 {fill=1}
P 10 7 1380 -3510 1372.5 -3517.5 1377.5 -3522.5 1362.5 -3527.5 1367.5 -3512.5 1372.5 -3517.5 1380 -3510 {fill=1}
P 10 7 1920 -3550 1912.5 -3557.5 1917.5 -3562.5 1902.5 -3567.5 1907.5 -3552.5 1912.5 -3557.5 1920 -3550 {fill=1}
P 10 7 1380 -3890 1372.5 -3897.5 1377.5 -3902.5 1362.5 -3907.5 1367.5 -3892.5 1372.5 -3897.5 1380 -3890 {fill=1}
P 10 7 1800 -3890 1792.5 -3897.5 1797.5 -3902.5 1782.5 -3907.5 1787.5 -3892.5 1792.5 -3897.5 1800 -3890 {fill=1}
P 10 7 2400 -3890 2392.5 -3897.5 2397.5 -3902.5 2382.5 -3907.5 2387.5 -3892.5 2392.5 -3897.5 2400 -3890 {fill=1}
P 10 7 660 -2410 652.5 -2417.5 657.5 -2422.5 642.5 -2427.5 647.5 -2412.5 652.5 -2417.5 660 -2410 {fill=1}
P 10 7 1240 -2410 1232.5 -2417.5 1237.5 -2422.5 1222.5 -2427.5 1227.5 -2412.5 1232.5 -2417.5 1240 -2410 {fill=1}
P 10 7 1010 -8830 1002.5 -8837.5 1007.5 -8842.5 992.5 -8847.5 997.5 -8832.5 1002.5 -8837.5 1010 -8830 {fill=1}
P 10 7 680 -2170 672.5 -2177.5 677.5 -2182.5 662.5 -2187.5 667.5 -2172.5 672.5 -2177.5 680 -2170 {fill=1}
P 10 7 1300 -2080 1292.5 -2087.5 1297.5 -2092.5 1282.5 -2097.5 1287.5 -2082.5 1292.5 -2087.5 1300 -2080 {fill=1}
P 10 7 760 -1900 752.5 -1907.5 757.5 -1912.5 742.5 -1917.5 747.5 -1902.5 752.5 -1907.5 760 -1900 {fill=1}
P 10 7 1300 -1870 1292.5 -1877.5 1297.5 -1882.5 1282.5 -1887.5 1287.5 -1872.5 1292.5 -1877.5 1300 -1870 {fill=1}
P 10 7 2350 -1840 2342.5 -1847.5 2347.5 -1852.5 2332.5 -1857.5 2337.5 -1842.5 2342.5 -1847.5 2350 -1840 {fill=1}
P 10 7 1830 -1120 1822.5 -1127.5 1827.5 -1132.5 1812.5 -1137.5 1817.5 -1122.5 1822.5 -1127.5 1830 -1120 {fill=1}
P 10 7 700 -1190 692.5 -1197.5 697.5 -1202.5 682.5 -1207.5 687.5 -1192.5 692.5 -1197.5 700 -1190 {fill=1}
P 10 7 820 -1190 812.5 -1197.5 817.5 -1202.5 802.5 -1207.5 807.5 -1192.5 812.5 -1197.5 820 -1190 {fill=1}
P 10 7 930 90 922.5 82.5 927.5 77.5 912.5 72.5 917.5 87.5 922.5 82.5 930 90 {fill=1}
P 10 7 1580 90 1572.5 82.5 1577.5 77.5 1562.5 72.5 1567.5 87.5 1572.5 82.5 1580 90 {fill=1}
P 10 7 760 -1470 752.5 -1477.5 757.5 -1482.5 742.5 -1487.5 747.5 -1472.5 752.5 -1477.5 760 -1470 {fill=1}
P 10 7 1220 -1520 1212.5 -1527.5 1217.5 -1532.5 1202.5 -1537.5 1207.5 -1522.5 1212.5 -1527.5 1220 -1520 {fill=1}
P 10 7 540 -5080 532.5 -5087.5 537.5 -5092.5 522.5 -5097.5 527.5 -5082.5 532.5 -5087.5 540 -5080 {fill=1}
P 10 7 1080 -5260 1072.5 -5267.5 1077.5 -5272.5 1062.5 -5277.5 1067.5 -5262.5 1072.5 -5267.5 1080 -5260 {fill=1}
P 10 7 1970 -5000 1962.5 -5007.5 1967.5 -5012.5 1952.5 -5017.5 1957.5 -5002.5 1962.5 -5007.5 1970 -5000 {fill=1}
P 10 7 2540 -5050 2532.5 -5057.5 2537.5 -5062.5 2522.5 -5067.5 2527.5 -5052.5 2532.5 -5057.5 2540 -5050 {fill=1}
P 10 7 840 -3160 832.5 -3167.5 837.5 -3172.5 822.5 -3177.5 827.5 -3162.5 832.5 -3167.5 840 -3160 {fill=1}
P 10 7 1380 -3160 1372.5 -3167.5 1377.5 -3172.5 1362.5 -3177.5 1367.5 -3162.5 1372.5 -3167.5 1380 -3160 {fill=1}
P 10 7 1920 -3240 1912.5 -3247.5 1917.5 -3252.5 1902.5 -3257.5 1907.5 -3242.5 1912.5 -3247.5 1920 -3240 {fill=1}
P 10 7 2460 -3160 2452.5 -3167.5 2457.5 -3172.5 2442.5 -3177.5 2447.5 -3162.5 2452.5 -3167.5 2460 -3160 {fill=1}
P 10 7 2560 -2910 2552.5 -2917.5 2557.5 -2922.5 2542.5 -2927.5 2547.5 -2912.5 2552.5 -2917.5 2560 -2910 {fill=1}
P 10 7 2030 -2810 2022.5 -2817.5 2027.5 -2822.5 2012.5 -2827.5 2017.5 -2812.5 2022.5 -2817.5 2030 -2810 {fill=1}
P 10 7 1520 -2800 1512.5 -2807.5 1517.5 -2812.5 1502.5 -2817.5 1507.5 -2802.5 1512.5 -2807.5 1520 -2800 {fill=1}
P 10 8 1770 -4790 1912.5 -4762.5 1890 -4730 1980 -4670 1960 -4640 1870 -4700 1845 -4665 1770 -4790 {fill=1}
P 10 7 2470 -1480 2462.5 -1487.5 2467.5 -1492.5 2452.5 -1497.5 2457.5 -1482.5 2462.5 -1487.5 2470 -1480 {fill=1}
P 10 7 2450 -90 2442.5 -97.5 2447.5 -102.5 2432.5 -107.5 2437.5 -92.5 2442.5 -97.5 2450 -90 {fill=1}
T {INTUITIVE_INTERFACE CHEAT SHEET} 1100 -9310 0 0 2 2 {hcenter=1}
T {D} 1275 -8247.5 0 0 0.15 0.15 { layer=2}
T {D} 2055 -8257.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -8247.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -7787.5 0 0 0.15 0.15 {}
T {D} 1285 -7787.5 0 0 0.15 0.15 {}
T {D} 745 -6957.5 0 0 0.15 0.15 {}
T {D} 1285 -6957.5 0 0 0.15 0.15 {}
T {D} 745 -6467.5 0 0 0.15 0.15 {}
T {D} 1285 -6467.5 0 0 0.15 0.15 {}
T {D} 745 -5977.5 0 0 0.15 0.15 { layer=2}
T {D} 2125 -5977.5 0 0 0.15 0.15 { layer=2}
T {D} 1285 -5977.5 0 0 0.15 0.15 { layer=2}
T {(Enable Options-> Intuitive Click & Drag interface
or add: `set intuitive_interface 1` in xschemrc file).} 1080 -9170 0 0 1 1 {hcenter=1 layer=1}
T {Move objects} 0 -8320 0 0 1 1 {}
T {Move objects} 0 -7910 0 0 1 1 {}
T {Move objects,
create wires} 0 -7080 0 0 1 1 {}
T {Move objects,
keep attached
wires
} 0 -6590 0 0 1 1 {}
T {Move objects,
keep attached
wires
} 0 -6100 0 0 1 1 {}
T {Shift} 1530 -7045 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1530 -6555 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1520 -5835 0 0 0.5 0.5 {hcenter=1}
T {Duplicate objects} 0 -7470 0 0 1 1 {}
T {D} 1275 -7417.5 0 0 0.15 0.15 { layer=2}
T {D} 2055 -7427.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -7417.5 0 0 0.15 0.15 { layer=2}
T {D} 1775 -7417.5 0 0 0.15 0.15 {}
T {Shift} 1270 -7235 0 0 0.5 0.5 {hcenter=1}
T {D} 1815 -8717.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -8717.5 0 0 0.15 0.15 { layer=2}
T {Select
and unselect
objects} 0 -8770 0 0 1 1 {}
T {Shift} 1710 -8515 0 0 0.5 0.5 {hcenter=1}
T {D} 2275 -8717.5 0 0 0.15 0.15 { layer=2}
T {Alt} 2490 -8505 0 0 0.5 0.5 {hcenter=1}
T {Select} 750 -8520 0 0 0.5 0.5 {}
T {Add
Selection} 1770 -8530 0 0 0.5 0.5 {}
T {Remove
Selection} 2220 -8530 0 0 0.5 0.5 {}
T {D} 765 -5537.5 0 0 0.15 0.15 {}
T {D} 1305 -5537.5 0 0 0.15 0.15 {}
T {D} 1865 -5537.5 0 0 0.15 0.15 {}
T {D} 2435 -5537.5 0 0 0.15 0.15 {}
T {D} 765 -4737.5 0 0 0.15 0.15 {}
T {D} 1305 -4737.5 0 0 0.15 0.15 {}
T {D} 2435 -4737.5 0 0 0.15 0.15 {}
T {D} 765 -5157.5 0 0 0.15 0.15 {}
T {D} 765 -4327.5 0 0 0.15 0.15 {}
T {D} 1865 -4327.5 0 0 0.15 0.15 {}
T {D} 1305 -4327.5 0 0 0.15 0.15 {}
T {Create and move
wires} 0 -5660 0 0 1 1 {}
T {Resize wires} 0 -4860 0 0 1 1 {}
T {Create wires} 0 -5280 0 0 1 1 {}
T {Stretch circuit} 0 -4450 0 0 1 1 {}
T {Move components, 
create wires,
resize wires} 0 -3660 0 0 1 1 {}
T {Move components,
create new wires} 0 -4040 0 0 1 1 {}
T {Cut wires} 0 -3310 0 0 1 1 {}
T {Stretch multiple
shapes} 0 -2890 0 0 1 1 {}
T {Ctrl} 1170 -4395 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1430 -4045 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1430 -3965 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1700 -4045 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1700 -3965 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1430 -3665 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1430 -3585 0 0 0.5 0.5 {hcenter=1}
T {Accurately position closer
to the wire end to be moved
so it will not be unselected} 1610 -4970 0 0 0.5 0.5 {}
T {Move multiple
objects keeping
connections} 0 -870 0 0 1 1 {}
T {Ctrl} 2080 -845 0 0 0.5 0.5 {hcenter=1}
T {Alt} 1430 -3215 0 0 0.5 0.5 {hcenter=1}
T {Click to select wire, release button
click wire endpoint and drag it away} 660 -4950 0 0 0.5 0.5 {}
T {Ctrl} 1580 -2805 0 0 0.5 0.5 {hcenter=1}
T {D} 655 -2467.5 0 0 0.15 0.15 { layer=2}
T {D} 1235 -2467.5 0 0 0.15 0.15 { layer=2}
T {D} 1885 -2467.5 0 0 0.15 0.15 {}
T {Ctrl} 1960 -2505 0 0 0.5 0.5 {hcenter=1}
T {!} 1960 -2425 0 0 0.5 0.5 {hcenter=1}
T {Break wires
under component
} 0 -2540 0 0 1 1 {}
T {If Shift key is needed for ! 
use also Shift} 2020 -2480 0 0 0.5 0.5 {}
T {D} 1275 -8717.5 0 0 0.15 0.15 { layer=2}
T {Add
Selection} 1090 -8540 0 0 0.5 0.5 {}
T {Shift} 1080 -8795 0 0 0.5 0.5 {hcenter=1}
T {Move multiple
objects keeping
connections,
adding wires} 0 -490 0 0 1 1 {}
T {Ctrl} 2080 -465 0 0 0.5 0.5 {hcenter=1}
T {Shift} 2080 -395 0 0 0.5 0.5 {hcenter=1}
T {Join / Trim wires} 0 -2200 0 0 1 1 {}
T {&} 1920 -2205 0 0 0.5 0.5 {hcenter=1}
T {This wire will not be broken} 1120 -1790 0 0 0.5 0.5 {}
T {&} 1830 -1775 0 0 0.5 0.5 {hcenter=1}
T {This wire is now 
broken} 1890 -1790 0 0 0.5 0.5 {}
T {break wires
at instance
pins} 0 -1270 0 0 1 1 {}
T {!} 1290 -1125 0 0 0.5 0.5 {hcenter=1}
T {Shift} 790 -1055 0 0 0.5 0.5 {hcenter=1}
T {+} 720 -1130 0 0 0.5 0.5 {}
T {The single wire line will be
broken at selected instance pins} 1640 -1300 0 0 0.5 0.5 {}
T {Single wire line} 640 -1290 0 0 0.5 0.5 {}
T {D} 825 42.5 0 0 0.15 0.15 {}
T {D} 1475 42.5 0 0 0.15 0.15 {}
T {Shift} 1650 105 0 0 0.5 0.5 {hcenter=1}
T {Select instance
and all connected
wires} 0 -90 0 0 1 1 {}
T {Join / Trim wires} 0 -1920 0 0 1 1 {}
T {Options->Auto join / trim wires to perform this function automatically} 840 -2020 0 0 0.5 0.5 {}
T {Join / Trim wires} 0 -1530 0 0 1 1 {}
T {This wire is broken} 630 -1390 0 0 0.5 0.5 {}
T {This wire is still broken} 1170 -1390 0 0 0.5 0.5 {}
T {This wire is now joined} 1800 -1390 0 0 0.5 0.5 {}
T {&} 1920 -1635 0 0 0.5 0.5 {hcenter=1}
T {Options->Auto join / trim wires to perform this function automatically} 840 -1650 0 0 0.5 0.5 {}
T {Options->Auto join / trim wires to perform this function automatically} 840 -2260 0 0 0.5 0.5 {}
T {multiple overlayed wires create
unneeded connecting dots} 1110 -2180 0 0 0.5 0.5 {}
T {overlayed wires are removed} 2270 -2160 0 0 0.5 0.5 {}
T {D} 1305 -5157.5 0 0 0.15 0.15 {}
T {D} 1865 -5157.5 0 0 0.15 0.15 {}
T {D} 2435 -5157.5 0 0 0.15 0.15 {}
T {Ctrl} 2370 -5835 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1980 -3665 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1980 -3585 0 0 0.5 0.5 {hcenter=1}
T {you can now 
select one of
the cut segments...} 1930 -3180 0 0 0.4 0.4 {}
T {... and move it.} 2420 -3100 0 0 0.4 0.4 {}
T {D} 2035 42.5 0 0 0.15 0.15 {}
