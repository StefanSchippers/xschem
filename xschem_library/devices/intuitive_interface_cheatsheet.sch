v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 1 917.5 -10882.5 922.5 -10882.5 {}
L 1 917.5 -10880 922.5 -10880 {}
L 1 917.5 -10877.5 922.5 -10877.5 {}
L 1 917.5 -10875 922.5 -10875 {}
L 1 917.5 -10872.5 922.5 -10872.5 {}
L 1 917.5 -10870 922.5 -10870 {}
L 1 917.5 -10867.5 922.5 -10867.5 {}
L 1 917.5 -10865 922.5 -10865 {}
L 1 917.5 -10862.5 922.5 -10862.5 {}
L 1 1347.5 -10882.5 1352.5 -10882.5 {}
L 1 1347.5 -10880 1352.5 -10880 {}
L 1 1347.5 -10877.5 1352.5 -10877.5 {}
L 1 1347.5 -10875 1352.5 -10875 {}
L 1 1347.5 -10872.5 1352.5 -10872.5 {}
L 1 1347.5 -10870 1352.5 -10870 {}
L 1 1347.5 -10867.5 1352.5 -10867.5 {}
L 1 1347.5 -10865 1352.5 -10865 {}
L 1 1347.5 -10862.5 1352.5 -10862.5 {}
L 1 2117.5 -10882.5 2122.5 -10882.5 {}
L 1 2117.5 -10880 2122.5 -10880 {}
L 1 2117.5 -10877.5 2122.5 -10877.5 {}
L 1 2117.5 -10875 2122.5 -10875 {}
L 1 2117.5 -10872.5 2122.5 -10872.5 {}
L 1 2117.5 -10870 2122.5 -10870 {}
L 1 2117.5 -10867.5 2122.5 -10867.5 {}
L 1 2117.5 -10865 2122.5 -10865 {}
L 1 2117.5 -10862.5 2122.5 -10862.5 {}
L 1 1417.5 -10692.5 1422.5 -10692.5 {}
L 1 1417.5 -10690 1422.5 -10690 {}
L 1 1417.5 -10687.5 1422.5 -10687.5 {}
L 1 1417.5 -10685 1422.5 -10685 {}
L 1 1417.5 -10682.5 1422.5 -10682.5 {}
L 1 1417.5 -10680 1422.5 -10680 {}
L 1 1417.5 -10677.5 1422.5 -10677.5 {}
L 1 1417.5 -10675 1422.5 -10675 {}
L 1 1417.5 -10672.5 1422.5 -10672.5 {}
L 1 1437.5 -7112.5 1442.5 -7112.5 {}
L 1 1437.5 -7110 1442.5 -7110 {}
L 1 1437.5 -7107.5 1442.5 -7107.5 {}
L 1 1437.5 -7105 1442.5 -7105 {}
L 1 1437.5 -7102.5 1442.5 -7102.5 {}
L 1 1437.5 -7100 1442.5 -7100 {}
L 1 1437.5 -7097.5 1442.5 -7097.5 {}
L 1 1437.5 -7095 1442.5 -7095 {}
L 1 1437.5 -7092.5 1442.5 -7092.5 {}
L 1 1437.5 -6712.5 1442.5 -6712.5 {}
L 1 1437.5 -6710 1442.5 -6710 {}
L 1 1437.5 -6707.5 1442.5 -6707.5 {}
L 1 1437.5 -6705 1442.5 -6705 {}
L 1 1437.5 -6702.5 1442.5 -6702.5 {}
L 1 1437.5 -6700 1442.5 -6700 {}
L 1 1437.5 -6697.5 1442.5 -6697.5 {}
L 1 1437.5 -6695 1442.5 -6695 {}
L 1 1437.5 -6692.5 1442.5 -6692.5 {}
L 1 947.5 -6032.5 952.5 -6032.5 {}
L 1 947.5 -6030 952.5 -6030 {}
L 1 947.5 -6027.5 952.5 -6027.5 {}
L 1 947.5 -6025 952.5 -6025 {}
L 1 947.5 -6022.5 952.5 -6022.5 {}
L 1 947.5 -6020 952.5 -6020 {}
L 1 947.5 -6017.5 952.5 -6017.5 {}
L 1 947.5 -6015 952.5 -6015 {}
L 1 947.5 -6012.5 952.5 -6012.5 {}
L 1 1060 -6290 1300 -6290 {}
L 1 1060 -6030 1300 -6030 {}
L 1 1447.5 -6042.5 1452.5 -6042.5 {}
L 1 1447.5 -6040 1452.5 -6040 {}
L 1 1447.5 -6037.5 1452.5 -6037.5 {}
L 1 1447.5 -6035 1452.5 -6035 {}
L 1 1447.5 -6032.5 1452.5 -6032.5 {}
L 1 1447.5 -6030 1452.5 -6030 {}
L 1 1447.5 -6027.5 1452.5 -6027.5 {}
L 1 1447.5 -6025 1452.5 -6025 {}
L 1 1447.5 -6022.5 1452.5 -6022.5 {}
L 1 917.5 -10052.5 922.5 -10052.5 {}
L 1 917.5 -10050 922.5 -10050 {}
L 1 917.5 -10047.5 922.5 -10047.5 {}
L 1 917.5 -10045 922.5 -10045 {}
L 1 917.5 -10042.5 922.5 -10042.5 {}
L 1 917.5 -10040 922.5 -10040 {}
L 1 917.5 -10037.5 922.5 -10037.5 {}
L 1 917.5 -10035 922.5 -10035 {}
L 1 917.5 -10032.5 922.5 -10032.5 {}
L 1 1347.5 -10052.5 1352.5 -10052.5 {}
L 1 1347.5 -10050 1352.5 -10050 {}
L 1 1347.5 -10047.5 1352.5 -10047.5 {}
L 1 1347.5 -10045 1352.5 -10045 {}
L 1 1347.5 -10042.5 1352.5 -10042.5 {}
L 1 1347.5 -10040 1352.5 -10040 {}
L 1 1347.5 -10037.5 1352.5 -10037.5 {}
L 1 1347.5 -10035 1352.5 -10035 {}
L 1 1347.5 -10032.5 1352.5 -10032.5 {}
L 1 2117.5 -10052.5 2122.5 -10052.5 {}
L 1 2117.5 -10050 2122.5 -10050 {}
L 1 2117.5 -10047.5 2122.5 -10047.5 {}
L 1 2117.5 -10045 2122.5 -10045 {}
L 1 2117.5 -10042.5 2122.5 -10042.5 {}
L 1 2117.5 -10040 2122.5 -10040 {}
L 1 2117.5 -10037.5 2122.5 -10037.5 {}
L 1 2117.5 -10035 2122.5 -10035 {}
L 1 2117.5 -10032.5 2122.5 -10032.5 {}
L 1 862.5 -11352.5 867.5 -11352.5 {}
L 1 862.5 -11350 867.5 -11350 {}
L 1 862.5 -11347.5 867.5 -11347.5 {}
L 1 862.5 -11345 867.5 -11345 {}
L 1 862.5 -11342.5 867.5 -11342.5 {}
L 1 862.5 -11340 867.5 -11340 {}
L 1 862.5 -11337.5 867.5 -11337.5 {}
L 1 862.5 -11335 867.5 -11335 {}
L 1 862.5 -11332.5 867.5 -11332.5 {}
L 1 1627.5 -11342.5 1632.5 -11342.5 {}
L 1 1627.5 -11340 1632.5 -11340 {}
L 1 1627.5 -11337.5 1632.5 -11337.5 {}
L 1 1627.5 -11335 1632.5 -11335 {}
L 1 1627.5 -11332.5 1632.5 -11332.5 {}
L 1 1627.5 -11330 1632.5 -11330 {}
L 1 1627.5 -11327.5 1632.5 -11327.5 {}
L 1 1627.5 -11325 1632.5 -11325 {}
L 1 1627.5 -11322.5 1632.5 -11322.5 {}
L 1 2407.5 -11332.5 2412.5 -11332.5 {}
L 1 2407.5 -11330 2412.5 -11330 {}
L 1 2407.5 -11327.5 2412.5 -11327.5 {}
L 1 2407.5 -11325 2412.5 -11325 {}
L 1 2407.5 -11322.5 2412.5 -11322.5 {}
L 1 2407.5 -11320 2412.5 -11320 {}
L 1 2407.5 -11317.5 2412.5 -11317.5 {}
L 1 2407.5 -11315 2412.5 -11315 {}
L 1 2407.5 -11312.5 2412.5 -11312.5 {}
L 1 820 -5090 820 -4760 {}
L 1 1360 -5090 1360 -4760 {}
L 1 1900 -4920 1900 -4760 {}
L 1 820 -4570 820 -4470 {}
L 1 710 -4570 710 -4470 {}
L 1 930 -4570 930 -4470 {}
L 1 820 -5450 820 -5300 {}
L 1 1360 -5450 1360 -5300 {}
L 1 1900 -5450 1900 -5340 {}
L 1 687.5 -9472.5 692.5 -9472.5 {}
L 1 687.5 -9470 692.5 -9470 {}
L 1 687.5 -9467.5 692.5 -9467.5 {}
L 1 687.5 -9465 692.5 -9465 {}
L 1 687.5 -9462.5 692.5 -9462.5 {}
L 1 687.5 -9460 692.5 -9460 {}
L 1 687.5 -9457.5 692.5 -9457.5 {}
L 1 687.5 -9455 692.5 -9455 {}
L 1 687.5 -9452.5 692.5 -9452.5 {}
L 1 1347.5 -9492.5 1352.5 -9492.5 {}
L 1 1347.5 -9490 1352.5 -9490 {}
L 1 1347.5 -9487.5 1352.5 -9487.5 {}
L 1 1347.5 -9485 1352.5 -9485 {}
L 1 1347.5 -9482.5 1352.5 -9482.5 {}
L 1 1347.5 -9480 1352.5 -9480 {}
L 1 1347.5 -9477.5 1352.5 -9477.5 {}
L 1 1347.5 -9475 1352.5 -9475 {}
L 1 1347.5 -9472.5 1352.5 -9472.5 {}
L 1 2537.5 -9542.5 2542.5 -9542.5 {}
L 1 2537.5 -9540 2542.5 -9540 {}
L 1 2537.5 -9537.5 2542.5 -9537.5 {}
L 1 2537.5 -9535 2542.5 -9535 {}
L 1 2537.5 -9532.5 2542.5 -9532.5 {}
L 1 2537.5 -9530 2542.5 -9530 {}
L 1 2537.5 -9527.5 2542.5 -9527.5 {}
L 1 2537.5 -9525 2542.5 -9525 {}
L 1 2537.5 -9522.5 2542.5 -9522.5 {}
L 1 1427.5 -5252.5 1432.5 -5252.5 {}
L 1 1427.5 -5250 1432.5 -5250 {}
L 1 1427.5 -5247.5 1432.5 -5247.5 {}
L 1 1427.5 -5245 1432.5 -5245 {}
L 1 1427.5 -5242.5 1432.5 -5242.5 {}
L 1 1427.5 -5240 1432.5 -5240 {}
L 1 1427.5 -5237.5 1432.5 -5237.5 {}
L 1 1427.5 -5235 1432.5 -5235 {}
L 1 1427.5 -5232.5 1432.5 -5232.5 {}
L 1 820 -2640 820 -2540 {}
L 1 710 -2640 710 -2540 {}
L 1 930 -2640 930 -2540 {}
L 1 820 -2480 820 -2450 {}
L 1 710 -2480 710 -2450 {}
L 1 930 -2480 930 -2450 {}
L 1 2077.5 -2522.5 2082.5 -2522.5 {}
L 1 2077.5 -2520 2082.5 -2520 {}
L 1 2077.5 -2517.5 2082.5 -2517.5 {}
L 1 2077.5 -2515 2082.5 -2515 {}
L 1 2077.5 -2512.5 2082.5 -2512.5 {}
L 1 2077.5 -2510 2082.5 -2510 {}
L 1 2077.5 -2507.5 2082.5 -2507.5 {}
L 1 2077.5 -2505 2082.5 -2505 {}
L 1 2077.5 -2502.5 2082.5 -2502.5 {}
L 1 1567.5 -2492.5 1572.5 -2492.5 {}
L 1 1567.5 -2490 1572.5 -2490 {}
L 1 1567.5 -2487.5 1572.5 -2487.5 {}
L 1 1567.5 -2485 1572.5 -2485 {}
L 1 1567.5 -2482.5 1572.5 -2482.5 {}
L 1 1567.5 -2480 1572.5 -2480 {}
L 1 1567.5 -2477.5 1572.5 -2477.5 {}
L 1 1567.5 -2475 1572.5 -2475 {}
L 1 1567.5 -2472.5 1572.5 -2472.5 {}
L 1 1427.5 -4892.5 1432.5 -4892.5 {}
L 1 1427.5 -4890 1432.5 -4890 {}
L 1 1427.5 -4887.5 1432.5 -4887.5 {}
L 1 1427.5 -4885 1432.5 -4885 {}
L 1 1427.5 -4882.5 1432.5 -4882.5 {}
L 1 1427.5 -4880 1432.5 -4880 {}
L 1 1427.5 -4877.5 1432.5 -4877.5 {}
L 1 1427.5 -4875 1432.5 -4875 {}
L 1 1427.5 -4872.5 1432.5 -4872.5 {}
L 1 1957.5 -5002.5 1962.5 -5002.5 {}
L 1 1957.5 -5000 1962.5 -5000 {}
L 1 1957.5 -4997.5 1962.5 -4997.5 {}
L 1 1957.5 -4995 1962.5 -4995 {}
L 1 1957.5 -4992.5 1962.5 -4992.5 {}
L 1 1957.5 -4990 1962.5 -4990 {}
L 1 1957.5 -4987.5 1962.5 -4987.5 {}
L 1 1957.5 -4985 1962.5 -4985 {}
L 1 1957.5 -4982.5 1962.5 -4982.5 {}
L 1 1577.5 -4482.5 1582.5 -4482.5 {}
L 1 1577.5 -4480 1582.5 -4480 {}
L 1 1577.5 -4477.5 1582.5 -4477.5 {}
L 1 1577.5 -4475 1582.5 -4475 {}
L 1 1577.5 -4472.5 1582.5 -4472.5 {}
L 1 1577.5 -4470 1582.5 -4470 {}
L 1 1577.5 -4467.5 1582.5 -4467.5 {}
L 1 1577.5 -4465 1582.5 -4465 {}
L 1 1577.5 -4462.5 1582.5 -4462.5 {}
L 1 2067.5 -4542.5 2072.5 -4542.5 {}
L 1 2067.5 -4540 2072.5 -4540 {}
L 1 2067.5 -4537.5 2072.5 -4537.5 {}
L 1 2067.5 -4535 2072.5 -4535 {}
L 1 2067.5 -4532.5 2072.5 -4532.5 {}
L 1 2067.5 -4530 2072.5 -4530 {}
L 1 2067.5 -4527.5 2072.5 -4527.5 {}
L 1 2067.5 -4525 2072.5 -4525 {}
L 1 2067.5 -4522.5 2072.5 -4522.5 {}
L 1 2597.5 -4672.5 2602.5 -4672.5 {}
L 1 2597.5 -4670 2602.5 -4670 {}
L 1 2597.5 -4667.5 2602.5 -4667.5 {}
L 1 2597.5 -4665 2602.5 -4665 {}
L 1 2597.5 -4662.5 2602.5 -4662.5 {}
L 1 2597.5 -4660 2602.5 -4660 {}
L 1 2597.5 -4657.5 2602.5 -4657.5 {}
L 1 2597.5 -4655 2602.5 -4655 {}
L 1 2597.5 -4652.5 2602.5 -4652.5 {}
L 1 987.5 -11622.5 992.5 -11622.5 {}
L 1 987.5 -11620 992.5 -11620 {}
L 1 987.5 -11617.5 992.5 -11617.5 {}
L 1 987.5 -11615 992.5 -11615 {}
L 1 987.5 -11612.5 992.5 -11612.5 {}
L 1 987.5 -11610 992.5 -11610 {}
L 1 987.5 -11607.5 992.5 -11607.5 {}
L 1 987.5 -11605 992.5 -11605 {}
L 1 987.5 -11602.5 992.5 -11602.5 {}
L 1 820 -2260 820 -2160 {}
L 1 710 -2260 710 -2160 {}
L 1 930 -2260 930 -2160 {}
L 1 1567.5 -2112.5 1572.5 -2112.5 {}
L 1 1567.5 -2110 1572.5 -2110 {}
L 1 1567.5 -2107.5 1572.5 -2107.5 {}
L 1 1567.5 -2105 1572.5 -2105 {}
L 1 1567.5 -2102.5 1572.5 -2102.5 {}
L 1 1567.5 -2100 1572.5 -2100 {}
L 1 1567.5 -2097.5 1572.5 -2097.5 {}
L 1 1567.5 -2095 1572.5 -2095 {}
L 1 1567.5 -2092.5 1572.5 -2092.5 {}
L 1 2077.5 -2062.5 2082.5 -2062.5 {}
L 1 2077.5 -2060 2082.5 -2060 {}
L 1 2077.5 -2057.5 2082.5 -2057.5 {}
L 1 2077.5 -2055 2082.5 -2055 {}
L 1 2077.5 -2052.5 2082.5 -2052.5 {}
L 1 2077.5 -2050 2082.5 -2050 {}
L 1 2077.5 -2047.5 2082.5 -2047.5 {}
L 1 2077.5 -2045 2082.5 -2045 {}
L 1 2077.5 -2042.5 2082.5 -2042.5 {}
L 1 620 -3840 870 -3840 {}
L 1 1340 -3840 1410 -3840 {}
L 1 1160 -3840 1220 -3840 {}
L 1 1790 -3840 2040 -3840 {}
L 1 2340 -3840 2590 -3840 {}
L 1 620 -3560 870 -3560 {}
L 1 1160 -3560 1410 -3560 {}
L 1 1790 -3560 2040 -3560 {}
L 1 1910 -3680 1910 -3560 {}
L 1 2460 -3560 2590 -3560 {}
L 1 2460 -3680 2460 -3560 {}
L 1 2360 -4920 2360 -4760 {}
L 1 2497.5 -4922.5 2502.5 -4922.5 {}
L 1 2497.5 -4920 2502.5 -4920 {}
L 1 2497.5 -4917.5 2502.5 -4917.5 {}
L 1 2497.5 -4915 2502.5 -4915 {}
L 1 2497.5 -4912.5 2502.5 -4912.5 {}
L 1 2497.5 -4910 2502.5 -4910 {}
L 1 2497.5 -4907.5 2502.5 -4907.5 {}
L 1 2497.5 -4905 2502.5 -4905 {}
L 1 2497.5 -4902.5 2502.5 -4902.5 {}
L 1 1160 -2980 1410 -2980 {}
L 1 1880 -2850 1950 -2850 {}
L 1 1700 -2850 1760 -2850 {}
L 1 1817.5 -2962.5 1822.5 -2962.5 {}
L 1 1817.5 -2960 1822.5 -2960 {}
L 1 1817.5 -2957.5 1822.5 -2957.5 {}
L 1 1817.5 -2955 1822.5 -2955 {}
L 1 1817.5 -2952.5 1822.5 -2952.5 {}
L 1 1817.5 -2950 1822.5 -2950 {}
L 1 1817.5 -2947.5 1822.5 -2947.5 {}
L 1 1817.5 -2945 1822.5 -2945 {}
L 1 1817.5 -2942.5 1822.5 -2942.5 {}
L 1 620 -2980 870 -2980 {}
L 1 667.5 -2892.5 672.5 -2892.5 {}
L 1 667.5 -2890 672.5 -2890 {}
L 1 667.5 -2887.5 672.5 -2887.5 {}
L 1 667.5 -2885 672.5 -2885 {}
L 1 667.5 -2882.5 672.5 -2882.5 {}
L 1 667.5 -2880 672.5 -2880 {}
L 1 667.5 -2877.5 672.5 -2877.5 {}
L 1 667.5 -2875 672.5 -2875 {}
L 1 667.5 -2872.5 672.5 -2872.5 {}
L 1 787.5 -2892.5 792.5 -2892.5 {}
L 1 787.5 -2890 792.5 -2890 {}
L 1 787.5 -2887.5 792.5 -2887.5 {}
L 1 787.5 -2885 792.5 -2885 {}
L 1 787.5 -2882.5 792.5 -2882.5 {}
L 1 787.5 -2880 792.5 -2880 {}
L 1 787.5 -2877.5 792.5 -2877.5 {}
L 1 787.5 -2875 792.5 -2875 {}
L 1 787.5 -2872.5 792.5 -2872.5 {}
L 1 1597.5 -1562.5 1602.5 -1562.5 {}
L 1 1597.5 -1560 1602.5 -1560 {}
L 1 1597.5 -1557.5 1602.5 -1557.5 {}
L 1 1597.5 -1555 1602.5 -1555 {}
L 1 1597.5 -1552.5 1602.5 -1552.5 {}
L 1 1597.5 -1550 1602.5 -1550 {}
L 1 1597.5 -1547.5 1602.5 -1547.5 {}
L 1 1597.5 -1545 1602.5 -1545 {}
L 1 1597.5 -1542.5 1602.5 -1542.5 {}
L 1 620 -3160 870 -3160 {}
L 1 1160 -3160 1410 -3160 {}
L 1 1790 -3160 2040 -3160 {}
L 1 1830 -3330 1830 -3210 {}
L 1 2277.5 -6042.5 2282.5 -6042.5 {}
L 1 2277.5 -6040 2282.5 -6040 {}
L 1 2277.5 -6037.5 2282.5 -6037.5 {}
L 1 2277.5 -6035 2282.5 -6035 {}
L 1 2277.5 -6032.5 2282.5 -6032.5 {}
L 1 2277.5 -6030 2282.5 -6030 {}
L 1 2277.5 -6027.5 2282.5 -6027.5 {}
L 1 2277.5 -6025 2282.5 -6025 {}
L 1 2277.5 -6022.5 2282.5 -6022.5 {}
L 1 1977.5 -5252.5 1982.5 -5252.5 {}
L 1 1977.5 -5250 1982.5 -5250 {}
L 1 1977.5 -5247.5 1982.5 -5247.5 {}
L 1 1977.5 -5245 1982.5 -5245 {}
L 1 1977.5 -5242.5 1982.5 -5242.5 {}
L 1 1977.5 -5240 1982.5 -5240 {}
L 1 1977.5 -5237.5 1982.5 -5237.5 {}
L 1 1977.5 -5235 1982.5 -5235 {}
L 1 1977.5 -5232.5 1982.5 -5232.5 {}
L 1 2337.5 -3552.5 2342.5 -3552.5 {}
L 1 2337.5 -3550 2342.5 -3550 {}
L 1 2337.5 -3547.5 2342.5 -3547.5 {}
L 1 2337.5 -3545 2342.5 -3545 {}
L 1 2337.5 -3542.5 2342.5 -3542.5 {}
L 1 2337.5 -3540 2342.5 -3540 {}
L 1 2337.5 -3537.5 2342.5 -3537.5 {}
L 1 2337.5 -3535 2342.5 -3535 {}
L 1 2337.5 -3532.5 2342.5 -3532.5 {}
L 1 807.5 -3672.5 812.5 -3672.5 {}
L 1 807.5 -3670 812.5 -3670 {}
L 1 807.5 -3667.5 812.5 -3667.5 {}
L 1 807.5 -3665 812.5 -3665 {}
L 1 807.5 -3662.5 812.5 -3662.5 {}
L 1 807.5 -3660 812.5 -3660 {}
L 1 807.5 -3657.5 812.5 -3657.5 {}
L 1 807.5 -3655 812.5 -3655 {}
L 1 807.5 -3652.5 812.5 -3652.5 {}
L 1 1347.5 -3652.5 1352.5 -3652.5 {}
L 1 1347.5 -3650 1352.5 -3650 {}
L 1 1347.5 -3647.5 1352.5 -3647.5 {}
L 1 1347.5 -3645 1352.5 -3645 {}
L 1 1347.5 -3642.5 1352.5 -3642.5 {}
L 1 1347.5 -3640 1352.5 -3640 {}
L 1 1347.5 -3637.5 1352.5 -3637.5 {}
L 1 1347.5 -3635 1352.5 -3635 {}
L 1 1347.5 -3632.5 1352.5 -3632.5 {}
L 1 2320 -3330 2320 -3210 {}
L 1 1257.5 -3272.5 1262.5 -3272.5 {}
L 1 1257.5 -3270 1262.5 -3270 {}
L 1 1257.5 -3267.5 1262.5 -3267.5 {}
L 1 1257.5 -3265 1262.5 -3265 {}
L 1 1257.5 -3262.5 1262.5 -3262.5 {}
L 1 1257.5 -3260 1262.5 -3260 {}
L 1 1257.5 -3257.5 1262.5 -3257.5 {}
L 1 1257.5 -3255 1262.5 -3255 {}
L 1 1257.5 -3252.5 1262.5 -3252.5 {}
L 1 2517.5 -3222.5 2522.5 -3222.5 {}
L 1 2517.5 -3220 2522.5 -3220 {}
L 1 2517.5 -3217.5 2522.5 -3217.5 {}
L 1 2517.5 -3215 2522.5 -3215 {}
L 1 2517.5 -3212.5 2522.5 -3212.5 {}
L 1 2517.5 -3210 2522.5 -3210 {}
L 1 2517.5 -3207.5 2522.5 -3207.5 {}
L 1 2517.5 -3205 2522.5 -3205 {}
L 1 2517.5 -3202.5 2522.5 -3202.5 {}
L 1 2477.5 -1812.5 2482.5 -1812.5 {}
L 1 2477.5 -1810 2482.5 -1810 {}
L 1 2477.5 -1807.5 2482.5 -1807.5 {}
L 1 2477.5 -1805 2482.5 -1805 {}
L 1 2477.5 -1802.5 2482.5 -1802.5 {}
L 1 2477.5 -1800 2482.5 -1800 {}
L 1 2477.5 -1797.5 2482.5 -1797.5 {}
L 1 2477.5 -1795 2482.5 -1795 {}
L 1 2477.5 -1792.5 2482.5 -1792.5 {}
L 1 367.5 -8902.5 372.5 -8902.5 {}
L 1 367.5 -8900 372.5 -8900 {}
L 1 367.5 -8897.5 372.5 -8897.5 {}
L 1 367.5 -8895 372.5 -8895 {}
L 1 367.5 -8892.5 372.5 -8892.5 {}
L 1 367.5 -8890 372.5 -8890 {}
L 1 367.5 -8887.5 372.5 -8887.5 {}
L 1 367.5 -8885 372.5 -8885 {}
L 1 367.5 -8882.5 372.5 -8882.5 {}
L 1 897.5 -9072.5 902.5 -9072.5 {}
L 1 897.5 -9070 902.5 -9070 {}
L 1 897.5 -9067.5 902.5 -9067.5 {}
L 1 897.5 -9065 902.5 -9065 {}
L 1 897.5 -9062.5 902.5 -9062.5 {}
L 1 897.5 -9060 902.5 -9060 {}
L 1 897.5 -9057.5 902.5 -9057.5 {}
L 1 897.5 -9055 902.5 -9055 {}
L 1 897.5 -9052.5 902.5 -9052.5 {}
L 1 800 -9110 800 -9000 {}
L 1 1147.5 -9112.5 1152.5 -9112.5 {}
L 1 1147.5 -9110 1152.5 -9110 {}
L 1 1147.5 -9107.5 1152.5 -9107.5 {}
L 1 1147.5 -9105 1152.5 -9105 {}
L 1 1147.5 -9102.5 1152.5 -9102.5 {}
L 1 1147.5 -9100 1152.5 -9100 {}
L 1 1147.5 -9097.5 1152.5 -9097.5 {}
L 1 1147.5 -9095 1152.5 -9095 {}
L 1 1147.5 -9092.5 1152.5 -9092.5 {}
L 1 1090 -9110 1090 -9000 {}
L 1 1437.5 -9112.5 1442.5 -9112.5 {}
L 1 1437.5 -9110 1442.5 -9110 {}
L 1 1437.5 -9107.5 1442.5 -9107.5 {}
L 1 1437.5 -9105 1442.5 -9105 {}
L 1 1437.5 -9102.5 1442.5 -9102.5 {}
L 1 1437.5 -9100 1442.5 -9100 {}
L 1 1437.5 -9097.5 1442.5 -9097.5 {}
L 1 1437.5 -9095 1442.5 -9095 {}
L 1 1437.5 -9092.5 1442.5 -9092.5 {}
L 1 1320 -9110 1320 -9000 {}
L 1 1610 -9110 1610 -9000 {}
L 1 1897.5 -9072.5 1902.5 -9072.5 {}
L 1 1897.5 -9070 1902.5 -9070 {}
L 1 1897.5 -9067.5 1902.5 -9067.5 {}
L 1 1897.5 -9065 1902.5 -9065 {}
L 1 1897.5 -9062.5 1902.5 -9062.5 {}
L 1 1897.5 -9060 1902.5 -9060 {}
L 1 1897.5 -9057.5 1902.5 -9057.5 {}
L 1 1897.5 -9055 1902.5 -9055 {}
L 1 1897.5 -9052.5 1902.5 -9052.5 {}
L 1 1850 -9110 1850 -9000 {}
L 1 2150 -9110 2150 -9000 {}
L 1 927.5 -5622.5 932.5 -5622.5 {}
L 1 927.5 -5620 932.5 -5620 {}
L 1 927.5 -5617.5 932.5 -5617.5 {}
L 1 927.5 -5615 932.5 -5615 {}
L 1 927.5 -5612.5 932.5 -5612.5 {}
L 1 927.5 -5610 932.5 -5610 {}
L 1 927.5 -5607.5 932.5 -5607.5 {}
L 1 927.5 -5605 932.5 -5605 {}
L 1 927.5 -5602.5 932.5 -5602.5 {}
L 1 1767.5 -5672.5 1772.5 -5672.5 {}
L 1 1767.5 -5670 1772.5 -5670 {}
L 1 1767.5 -5667.5 1772.5 -5667.5 {}
L 1 1767.5 -5665 1772.5 -5665 {}
L 1 1767.5 -5662.5 1772.5 -5662.5 {}
L 1 1767.5 -5660 1772.5 -5660 {}
L 1 1767.5 -5657.5 1772.5 -5657.5 {}
L 1 1767.5 -5655 1772.5 -5655 {}
L 1 1767.5 -5652.5 1772.5 -5652.5 {}
L 1 2527.5 -5672.5 2532.5 -5672.5 {}
L 1 2527.5 -5670 2532.5 -5670 {}
L 1 2527.5 -5667.5 2532.5 -5667.5 {}
L 1 2527.5 -5665 2532.5 -5665 {}
L 1 2527.5 -5662.5 2532.5 -5662.5 {}
L 1 2527.5 -5660 2532.5 -5660 {}
L 1 2527.5 -5657.5 2532.5 -5657.5 {}
L 1 2527.5 -5655 2532.5 -5655 {}
L 1 2527.5 -5652.5 2532.5 -5652.5 {}
L 1 902.5 -9892.5 907.5 -9892.5 {}
L 1 902.5 -9890 907.5 -9890 {}
L 1 902.5 -9887.5 907.5 -9887.5 {}
L 1 902.5 -9885 907.5 -9885 {}
L 1 902.5 -9882.5 907.5 -9882.5 {}
L 1 902.5 -9880 907.5 -9880 {}
L 1 902.5 -9877.5 907.5 -9877.5 {}
L 1 902.5 -9875 907.5 -9875 {}
L 1 902.5 -9872.5 907.5 -9872.5 {}
L 1 1437.5 -9772.5 1442.5 -9772.5 {}
L 1 1437.5 -9770 1442.5 -9770 {}
L 1 1437.5 -9767.5 1442.5 -9767.5 {}
L 1 1437.5 -9765 1442.5 -9765 {}
L 1 1437.5 -9762.5 1442.5 -9762.5 {}
L 1 1437.5 -9760 1442.5 -9760 {}
L 1 1437.5 -9757.5 1442.5 -9757.5 {}
L 1 1437.5 -9755 1442.5 -9755 {}
L 1 1437.5 -9752.5 1442.5 -9752.5 {}
L 1 465 -9930 705 -9930 {}
L 1 1030 -9930 1270 -9930 {}
L 1 1807.5 -9772.5 1812.5 -9772.5 {}
L 1 1807.5 -9770 1812.5 -9770 {}
L 1 1807.5 -9767.5 1812.5 -9767.5 {}
L 1 1807.5 -9765 1812.5 -9765 {}
L 1 1807.5 -9762.5 1812.5 -9762.5 {}
L 1 1807.5 -9760 1812.5 -9760 {}
L 1 1807.5 -9757.5 1812.5 -9757.5 {}
L 1 1807.5 -9755 1812.5 -9755 {}
L 1 1807.5 -9752.5 1812.5 -9752.5 {}
L 1 1530 -9930 1770 -9930 {}
L 1 2297.5 -9772.5 2302.5 -9772.5 {}
L 1 2297.5 -9770 2302.5 -9770 {}
L 1 2297.5 -9767.5 2302.5 -9767.5 {}
L 1 2297.5 -9765 2302.5 -9765 {}
L 1 2297.5 -9762.5 2302.5 -9762.5 {}
L 1 2297.5 -9760 2302.5 -9760 {}
L 1 2297.5 -9757.5 2302.5 -9757.5 {}
L 1 2297.5 -9755 2302.5 -9755 {}
L 1 2297.5 -9752.5 2302.5 -9752.5 {}
L 1 2020 -9930 2260 -9930 {}
L 1 1610 -9110 1670 -9110 {}
L 1 2247.5 -8922.5 2252.5 -8922.5 {}
L 1 2247.5 -8920 2252.5 -8920 {}
L 1 2247.5 -8917.5 2252.5 -8917.5 {}
L 1 2247.5 -8915 2252.5 -8915 {}
L 1 2247.5 -8912.5 2252.5 -8912.5 {}
L 1 2247.5 -8910 2252.5 -8910 {}
L 1 2247.5 -8907.5 2252.5 -8907.5 {}
L 1 2247.5 -8905 2252.5 -8905 {}
L 1 2247.5 -8902.5 2252.5 -8902.5 {}
L 1 2150 -9110 2210 -9110 {}
L 1 2047.5 -8372.5 2052.5 -8372.5 {}
L 1 2047.5 -8370 2052.5 -8370 {}
L 1 2047.5 -8367.5 2052.5 -8367.5 {}
L 1 2047.5 -8365 2052.5 -8365 {}
L 1 2047.5 -8362.5 2052.5 -8362.5 {}
L 1 2047.5 -8360 2052.5 -8360 {}
L 1 2047.5 -8357.5 2052.5 -8357.5 {}
L 1 2047.5 -8355 2052.5 -8355 {}
L 1 2047.5 -8352.5 2052.5 -8352.5 {}
L 1 2047.5 -7942.5 2052.5 -7942.5 {}
L 1 2047.5 -7940 2052.5 -7940 {}
L 1 2047.5 -7937.5 2052.5 -7937.5 {}
L 1 2047.5 -7935 2052.5 -7935 {}
L 1 2047.5 -7932.5 2052.5 -7932.5 {}
L 1 2047.5 -7930 2052.5 -7930 {}
L 1 2047.5 -7927.5 2052.5 -7927.5 {}
L 1 2047.5 -7925 2052.5 -7925 {}
L 1 2047.5 -7922.5 2052.5 -7922.5 {}
L 1 1157.5 -7462.5 1162.5 -7462.5 {}
L 1 1157.5 -7460 1162.5 -7460 {}
L 1 1157.5 -7457.5 1162.5 -7457.5 {}
L 1 1157.5 -7455 1162.5 -7455 {}
L 1 1157.5 -7452.5 1162.5 -7452.5 {}
L 1 1157.5 -7450 1162.5 -7450 {}
L 1 1157.5 -7447.5 1162.5 -7447.5 {}
L 1 1157.5 -7445 1162.5 -7445 {}
L 1 1157.5 -7442.5 1162.5 -7442.5 {}
L 1 2360 -9110 2360 -9000 {}
L 1 2477.5 -8982.5 2482.5 -8982.5 {}
L 1 2477.5 -8980 2482.5 -8980 {}
L 1 2477.5 -8977.5 2482.5 -8977.5 {}
L 1 2477.5 -8975 2482.5 -8975 {}
L 1 2477.5 -8972.5 2482.5 -8972.5 {}
L 1 2477.5 -8970 2482.5 -8970 {}
L 1 2477.5 -8967.5 2482.5 -8967.5 {}
L 1 2477.5 -8965 2482.5 -8965 {}
L 1 2477.5 -8962.5 2482.5 -8962.5 {}
L 1 2360 -9110 2420 -9110 {}
L 1 617.5 -9112.5 622.5 -9112.5 {}
L 1 617.5 -9110 622.5 -9110 {}
L 1 617.5 -9107.5 622.5 -9107.5 {}
L 1 617.5 -9105 622.5 -9105 {}
L 1 617.5 -9102.5 622.5 -9102.5 {}
L 1 617.5 -9100 622.5 -9100 {}
L 1 617.5 -9097.5 622.5 -9097.5 {}
L 1 617.5 -9095 622.5 -9095 {}
L 1 617.5 -9092.5 622.5 -9092.5 {}
L 1 1970 -1030 2040 -1030 {}
L 1 1970 -1010 2040 -1010 {}
L 1 1970 -990 2040 -990 {}
L 1 1970 -970 2040 -970 {}
L 1 647.5 -932.5 652.5 -932.5 {}
L 1 647.5 -930 652.5 -930 {}
L 1 647.5 -927.5 652.5 -927.5 {}
L 1 647.5 -925 652.5 -925 {}
L 1 647.5 -922.5 652.5 -922.5 {}
L 1 647.5 -920 652.5 -920 {}
L 1 647.5 -917.5 652.5 -917.5 {}
L 1 647.5 -915 652.5 -915 {}
L 1 647.5 -912.5 652.5 -912.5 {}
L 1 1097.5 -932.5 1102.5 -932.5 {}
L 1 1097.5 -930 1102.5 -930 {}
L 1 1097.5 -927.5 1102.5 -927.5 {}
L 1 1097.5 -925 1102.5 -925 {}
L 1 1097.5 -922.5 1102.5 -922.5 {}
L 1 1097.5 -920 1102.5 -920 {}
L 1 1097.5 -917.5 1102.5 -917.5 {}
L 1 1097.5 -915 1102.5 -915 {}
L 1 1097.5 -912.5 1102.5 -912.5 {}
L 1 1517.5 -902.5 1522.5 -902.5 {}
L 1 1517.5 -900 1522.5 -900 {}
L 1 1517.5 -897.5 1522.5 -897.5 {}
L 1 1517.5 -895 1522.5 -895 {}
L 1 1517.5 -892.5 1522.5 -892.5 {}
L 1 1517.5 -890 1522.5 -890 {}
L 1 1517.5 -887.5 1522.5 -887.5 {}
L 1 1517.5 -885 1522.5 -885 {}
L 1 1517.5 -882.5 1522.5 -882.5 {}
L 1 2447.5 -962.5 2452.5 -962.5 {}
L 1 2447.5 -960 2452.5 -960 {}
L 1 2447.5 -957.5 2452.5 -957.5 {}
L 1 2447.5 -955 2452.5 -955 {}
L 1 2447.5 -952.5 2452.5 -952.5 {}
L 1 2447.5 -950 2452.5 -950 {}
L 1 2447.5 -947.5 2452.5 -947.5 {}
L 1 2447.5 -945 2452.5 -945 {}
L 1 2447.5 -942.5 2452.5 -942.5 {}
L 1 2207.5 -12012.5 2212.5 -12012.5 {}
L 1 2207.5 -12010 2212.5 -12010 {}
L 1 2207.5 -12007.5 2212.5 -12007.5 {}
L 1 2207.5 -12005 2212.5 -12005 {}
L 1 2207.5 -12002.5 2212.5 -12002.5 {}
L 1 2207.5 -12000 2212.5 -12000 {}
L 1 2207.5 -11997.5 2212.5 -11997.5 {}
L 1 2207.5 -11995 2212.5 -11995 {}
L 1 2207.5 -11992.5 2212.5 -11992.5 {}
L 1 1110 -11030 1230 -11030 {}
L 1 1030 -11180 1270 -11180 {}
L 1 1270 -11060 1410 -11060 {}
L 1 1030 -10940 1030 -10920 {}
L 1 1030 -11180 1030 -11000 {}
L 1 1030 -10920 1270 -10920 {}
L 1 1650 -11030 1770 -11030 {}
L 1 1570 -11180 1810 -11180 {}
L 1 1810 -11060 1950 -11060 {}
L 1 1570 -10940 1570 -10920 {}
L 1 1570 -11180 1570 -11000 {}
L 1 1570 -10920 1810 -10920 {}
L 1 580 -11030 700 -11030 {}
L 1 500 -11180 740 -11180 {}
L 1 740 -11060 880 -11060 {}
L 1 500 -10940 500 -10920 {}
L 1 500 -11180 500 -11000 {}
L 1 500 -10920 740 -10920 {}
L 1 580 -10570 700 -10570 {}
L 1 740 -10630 740 -10600 {}
L 1 740 -10720 740 -10690 {}
L 1 500 -10720 740 -10720 {}
L 1 740 -10600 880 -10600 {}
L 1 830 -10540 830 -10460 {}
L 1 500 -10480 500 -10460 {}
L 1 500 -10720 500 -10540 {}
L 1 740 -10570 740 -10460 {}
L 1 740 -10460 830 -10460 {}
L 1 500 -10460 740 -10460 {}
L 1 1120 -10570 1240 -10570 {}
L 1 1280 -10630 1280 -10600 {}
L 1 1280 -10720 1280 -10690 {}
L 1 1040 -10720 1280 -10720 {}
L 1 1280 -10600 1420 -10600 {}
L 1 1370 -10540 1370 -10460 {}
L 1 1040 -10480 1040 -10460 {}
L 1 1040 -10720 1040 -10540 {}
L 1 1280 -10570 1280 -10460 {}
L 1 1280 -10460 1370 -10460 {}
L 1 1040 -10460 1280 -10460 {}
L 1 580 -6980 700 -6980 {}
L 1 740 -7040 740 -7010 {}
L 1 740 -7130 740 -7100 {}
L 1 500 -7130 740 -7130 {}
L 1 740 -7010 880 -7010 {}
L 1 830 -6950 830 -6870 {}
L 1 500 -6890 500 -6870 {}
L 1 500 -7130 500 -6950 {}
L 1 740 -6980 740 -6870 {}
L 1 740 -6870 830 -6870 {}
L 1 500 -6870 740 -6870 {}
L 1 1120 -6980 1240 -6980 {}
L 1 1280 -7040 1280 -7010 {}
L 1 1280 -7130 1280 -7100 {}
L 1 1040 -7130 1280 -7130 {}
L 1 1280 -7010 1420 -7010 {}
L 1 1370 -6950 1370 -6870 {}
L 1 1040 -6890 1040 -6870 {}
L 1 1040 -7130 1040 -6950 {}
L 1 1280 -6980 1280 -6870 {}
L 1 1280 -6870 1370 -6870 {}
L 1 1040 -6870 1280 -6870 {}
L 1 580 -6580 700 -6580 {}
L 1 740 -6640 740 -6610 {}
L 1 740 -6730 740 -6700 {}
L 1 500 -6730 740 -6730 {}
L 1 740 -6610 880 -6610 {}
L 1 830 -6550 830 -6470 {}
L 1 500 -6490 500 -6470 {}
L 1 500 -6730 500 -6550 {}
L 1 740 -6580 740 -6470 {}
L 1 740 -6470 830 -6470 {}
L 1 500 -6470 740 -6470 {}
L 1 1120 -6580 1240 -6580 {}
L 1 1040 -6730 1280 -6730 {}
L 1 1280 -6610 1420 -6610 {}
L 1 1370 -6550 1370 -6470 {}
L 1 1040 -6490 1040 -6470 {}
L 1 1040 -6730 1040 -6550 {}
L 1 1280 -6580 1280 -6470 {}
L 1 1280 -6470 1370 -6470 {}
L 1 1040 -6470 1280 -6470 {}
L 1 580 -6140 700 -6140 {}
L 1 500 -6290 740 -6290 {}
L 1 500 -6050 500 -6030 {}
L 1 500 -6290 500 -6110 {}
L 1 500 -6030 740 -6030 {}
L 1 1690 -6050 1690 -6030 {}
L 1 1690 -6290 1690 -6110 {}
L 1 1140 -6140 1260 -6140 {}
L 1 1060 -6050 1060 -6030 {}
L 1 1060 -6290 1060 -6110 {}
L 1 1110 -10200 1230 -10200 {}
L 1 1030 -10350 1270 -10350 {}
L 1 1270 -10230 1410 -10230 {}
L 1 1030 -10110 1030 -10090 {}
L 1 1030 -10350 1030 -10170 {}
L 1 1030 -10090 1270 -10090 {}
L 1 580 -10200 700 -10200 {}
L 1 500 -10350 740 -10350 {}
L 1 740 -10230 880 -10230 {}
L 1 500 -10110 500 -10090 {}
L 1 500 -10350 500 -10170 {}
L 1 500 -10090 740 -10090 {}
L 1 1610 -10200 1730 -10200 {}
L 1 1770 -10260 1770 -10230 {}
L 1 1770 -10350 1770 -10320 {}
L 1 1530 -10350 1770 -10350 {}
L 1 1770 -10230 1910 -10230 {}
L 1 1860 -10170 1860 -10090 {}
L 1 1530 -10110 1530 -10090 {}
L 1 1530 -10350 1530 -10170 {}
L 1 1770 -10200 1770 -10090 {}
L 1 1770 -10090 1860 -10090 {}
L 1 1530 -10090 1770 -10090 {}
L 1 1650 -11500 1770 -11500 {}
L 1 1570 -11650 1810 -11650 {}
L 1 1810 -11530 1950 -11530 {}
L 1 1570 -11390 1810 -11390 {}
L 1 525 -11500 645 -11500 {}
L 1 445 -11650 685 -11650 {}
L 1 685 -11530 825 -11530 {}
L 1 445 -11410 445 -11390 {}
L 1 445 -11650 445 -11470 {}
L 1 445 -11390 685 -11390 {}
L 1 2110 -11500 2230 -11500 {}
L 1 2030 -11650 2270 -11650 {}
L 1 2270 -11530 2410 -11530 {}
L 1 2030 -11390 2270 -11390 {}
L 1 2360 -11470 2360 -11390 {}
L 1 600 -9360 720 -9360 {}
L 1 760 -9420 760 -9390 {}
L 1 760 -9510 760 -9480 {}
L 1 760 -9390 900 -9390 {}
L 1 850 -9330 850 -9250 {}
L 1 520 -9270 520 -9250 {}
L 1 520 -9510 520 -9330 {}
L 1 760 -9360 760 -9250 {}
L 1 760 -9250 850 -9250 {}
L 1 520 -9250 760 -9250 {}
L 1 1140 -9360 1260 -9360 {}
L 1 1300 -9420 1300 -9390 {}
L 1 1300 -9510 1300 -9480 {}
L 1 1300 -9390 1440 -9390 {}
L 1 1390 -9330 1390 -9250 {}
L 1 1060 -9270 1060 -9250 {}
L 1 1060 -9510 1060 -9330 {}
L 1 1300 -9360 1300 -9250 {}
L 1 1300 -9250 1390 -9250 {}
L 1 1060 -9250 1300 -9250 {}
L 1 2270 -9360 2390 -9360 {}
L 1 2430 -9420 2430 -9390 {}
L 1 2430 -9510 2430 -9480 {}
L 1 2430 -9390 2570 -9390 {}
L 1 2520 -9330 2520 -9250 {}
L 1 2190 -9270 2190 -9250 {}
L 1 2190 -9510 2190 -9330 {}
L 1 2430 -9360 2430 -9250 {}
L 1 2430 -9250 2520 -9250 {}
L 1 2190 -9250 2430 -9250 {}
L 1 690 -4270 690 -4090 {}
L 1 1230 -4270 1230 -4090 {}
L 1 1880 -4270 1880 -4210 {}
L 1 1880 -4150 1880 -4090 {}
L 1 1110 -11500 1230 -11500 {}
L 1 1030 -11650 1270 -11650 {}
L 1 1270 -11530 1410 -11530 {}
L 1 1030 -11390 1270 -11390 {}
L 1 1030 -11410 1030 -11390 {}
L 1 1030 -11650 1030 -11470 {}
L 1 660 -1670 780 -1670 {}
L 1 820 -1730 820 -1700 {}
L 1 820 -1820 820 -1790 {}
L 1 580 -1820 820 -1820 {}
L 1 820 -1700 960 -1700 {}
L 1 910 -1640 910 -1560 {}
L 1 580 -1580 580 -1560 {}
L 1 580 -1820 580 -1640 {}
L 1 820 -1670 820 -1560 {}
L 1 820 -1560 910 -1560 {}
L 1 580 -1560 820 -1560 {}
L 1 1260 -1670 1380 -1670 {}
L 1 1420 -1730 1420 -1700 {}
L 1 1420 -1820 1420 -1790 {}
L 1 1180 -1820 1420 -1820 {}
L 1 1180 -1820 1180 -1640 {}
L 1 1870 -1670 1990 -1670 {}
L 1 2030 -1730 2030 -1700 {}
L 1 2030 -1820 2030 -1790 {}
L 1 1790 -1820 2030 -1820 {}
L 1 1790 -1820 1790 -1640 {}
L 1 600 -5730 720 -5730 {}
L 1 760 -5790 760 -5760 {}
L 1 760 -5880 760 -5850 {}
L 1 520 -5880 760 -5880 {}
L 1 760 -5760 900 -5760 {}
L 1 520 -5640 520 -5620 {}
L 1 520 -5880 520 -5700 {}
L 1 760 -5730 760 -5620 {}
L 1 760 -5620 850 -5620 {}
L 1 520 -5620 760 -5620 {}
L 1 1160 -5730 1280 -5730 {}
L 1 1320 -5790 1320 -5760 {}
L 1 1320 -5880 1320 -5850 {}
L 1 1080 -5880 1320 -5880 {}
L 1 1320 -5760 1460 -5760 {}
L 1 1080 -5640 1080 -5620 {}
L 1 1080 -5880 1080 -5700 {}
L 1 1320 -5730 1320 -5620 {}
L 1 1320 -5620 1410 -5620 {}
L 1 1080 -5620 1320 -5620 {}
L 1 545 -9780 665 -9780 {}
L 1 705 -9840 705 -9810 {}
L 1 705 -9930 705 -9900 {}
L 1 795 -9750 795 -9670 {}
L 1 465 -9690 465 -9670 {}
L 1 465 -9930 465 -9750 {}
L 1 705 -9780 705 -9670 {}
L 1 705 -9670 795 -9670 {}
L 1 465 -9670 705 -9670 {}
L 1 1110 -9780 1230 -9780 {}
L 1 1270 -9840 1270 -9810 {}
L 1 1270 -9930 1270 -9900 {}
L 1 1360 -9750 1360 -9670 {}
L 1 1030 -9690 1030 -9670 {}
L 1 1030 -9930 1030 -9750 {}
L 1 1270 -9780 1270 -9670 {}
L 1 1270 -9670 1360 -9670 {}
L 1 1030 -9670 1270 -9670 {}
L 1 1610 -9780 1730 -9780 {}
L 1 1770 -9840 1770 -9810 {}
L 1 1770 -9930 1770 -9900 {}
L 1 1860 -9750 1860 -9670 {}
L 1 1530 -9690 1530 -9670 {}
L 1 1530 -9930 1530 -9750 {}
L 1 1770 -9780 1770 -9670 {}
L 1 1770 -9670 1860 -9670 {}
L 1 1530 -9670 1770 -9670 {}
L 1 2100 -9780 2220 -9780 {}
L 1 2260 -9840 2260 -9810 {}
L 1 2260 -9930 2260 -9900 {}
L 1 2350 -9750 2350 -9670 {}
L 1 2020 -9690 2020 -9670 {}
L 1 2020 -9930 2020 -9750 {}
L 1 2260 -9780 2260 -9670 {}
L 1 2260 -9670 2350 -9670 {}
L 1 2020 -9670 2260 -9670 {}
L 1 580 -660 670 -660 {}
L 1 970 -660 1060 -660 {}
L 1 957.5 -602.5 962.5 -602.5 {}
L 1 957.5 -600 962.5 -600 {}
L 1 957.5 -597.5 962.5 -597.5 {}
L 1 957.5 -595 962.5 -595 {}
L 1 957.5 -592.5 962.5 -592.5 {}
L 1 957.5 -590 962.5 -590 {}
L 1 957.5 -587.5 962.5 -587.5 {}
L 1 957.5 -585 962.5 -585 {}
L 1 957.5 -582.5 962.5 -582.5 {}
L 1 1280 -660 1370 -660 {}
L 1 1387.5 -562.5 1392.5 -562.5 {}
L 1 1387.5 -560 1392.5 -560 {}
L 1 1387.5 -557.5 1392.5 -557.5 {}
L 1 1387.5 -555 1392.5 -555 {}
L 1 1387.5 -552.5 1392.5 -552.5 {}
L 1 1387.5 -550 1392.5 -550 {}
L 1 1387.5 -547.5 1392.5 -547.5 {}
L 1 1387.5 -545 1392.5 -545 {}
L 1 1387.5 -542.5 1392.5 -542.5 {}
L 1 1610 -660 1700 -660 {}
L 1 1717.5 -562.5 1722.5 -562.5 {}
L 1 1717.5 -560 1722.5 -560 {}
L 1 1717.5 -557.5 1722.5 -557.5 {}
L 1 1717.5 -555 1722.5 -555 {}
L 1 1717.5 -552.5 1722.5 -552.5 {}
L 1 1717.5 -550 1722.5 -550 {}
L 1 1717.5 -547.5 1722.5 -547.5 {}
L 1 1717.5 -545 1722.5 -545 {}
L 1 1717.5 -542.5 1722.5 -542.5 {}
L 1 1930 -660 2020 -660 {}
L 1 2037.5 -562.5 2042.5 -562.5 {}
L 1 2037.5 -560 2042.5 -560 {}
L 1 2037.5 -557.5 2042.5 -557.5 {}
L 1 2037.5 -555 2042.5 -555 {}
L 1 2037.5 -552.5 2042.5 -552.5 {}
L 1 2037.5 -550 2042.5 -550 {}
L 1 2037.5 -547.5 2042.5 -547.5 {}
L 1 2037.5 -545 2042.5 -545 {}
L 1 2037.5 -542.5 2042.5 -542.5 {}
L 1 710 -330 710 -300 {}
L 1 580 -300 710 -300 {}
L 1 580 -330 580 -190 {}
L 1 580 -130 580 -110 {}
L 1 580 -50 580 -30 {}
L 1 580 -410 580 -360 {}
L 1 580 -410 710 -410 {}
L 1 710 -410 710 -360 {}
L 1 580 -80 580 -50 {}
L 1 580 -160 630 -160 {}
L 1 630 -160 630 -50 {}
L 1 580 -50 630 -50 {}
L 1 540 -360 540 -160 {}
L 1 670 -360 670 -280 {}
L 1 520 -280 670 -280 {}
L 1 520 -280 520 -80 {}
L 1 520 -80 540 -80 {}
L 1 480 -180 520 -180 {}
L 1 480 -210 540 -210 {}
L 1 1080 -330 1080 -300 {}
L 1 950 -300 1080 -300 {}
L 1 950 -330 950 -190 {}
L 1 950 -130 950 -110 {}
L 1 950 -50 950 -30 {}
L 1 950 -410 950 -360 {}
L 1 950 -410 1080 -410 {}
L 1 1080 -410 1080 -360 {}
L 1 950 -160 1000 -160 {}
L 1 1000 -160 1000 -50 {}
L 1 950 -50 1000 -50 {}
L 1 910 -360 910 -160 {}
L 1 1040 -360 1040 -280 {}
L 1 890 -280 1040 -280 {}
L 1 890 -280 890 -80 {}
L 1 890 -80 910 -80 {}
L 1 850 -180 890 -180 {}
L 1 850 -210 910 -210 {}
L 1 1127.5 -322.5 1132.5 -322.5 {}
L 1 1127.5 -320 1132.5 -320 {}
L 1 1127.5 -317.5 1132.5 -317.5 {}
L 1 1127.5 -315 1132.5 -315 {}
L 1 1127.5 -312.5 1132.5 -312.5 {}
L 1 1127.5 -310 1132.5 -310 {}
L 1 1127.5 -307.5 1132.5 -307.5 {}
L 1 1127.5 -305 1132.5 -305 {}
L 1 1127.5 -302.5 1132.5 -302.5 {}
L 1 2370 -330 2370 -300 {}
L 1 2240 -300 2370 -300 {}
L 1 2240 -330 2240 -190 {}
L 1 2240 -130 2240 -110 {}
L 1 2240 -50 2240 -30 {}
L 1 2240 -410 2240 -360 {}
L 1 2240 -410 2370 -410 {}
L 1 2370 -410 2370 -360 {}
L 1 2240 -80 2240 -50 {}
L 1 2240 -160 2290 -160 {}
L 1 2290 -160 2290 -50 {}
L 1 2240 -50 2290 -50 {}
L 1 2200 -360 2200 -160 {}
L 1 2330 -360 2330 -280 {}
L 1 2180 -280 2330 -280 {}
L 1 2180 -280 2180 -80 {}
L 1 2180 -80 2200 -80 {}
L 1 2140 -180 2180 -180 {}
L 1 2140 -210 2200 -210 {}
L 2 1255 -11060 1255 -11000 {}
L 2 1255 -11050 1270 -11050 {}
L 2 1270 -11060 1270 -11050 {}
L 2 1255 -11010 1270 -11010 {}
L 2 1270 -11010 1270 -11000 {}
L 2 1245 -11045 1245 -11015 {}
L 2 1245 -11030 1245 -11025 {}
L 2 1230 -11030 1237.5 -11030 {}
L 2 1230 -11030 1245 -11030 {}
L 2 1260 -11030 1270 -11030 {}
L 2 1255 -11035 1260 -11030 {}
L 2 1255 -11025 1260 -11030 {}
L 2 1270 -11100 1270 -11090 {}
L 2 1270 -11100 1277.5 -11102.5 {}
L 2 1262.5 -11107.5 1277.5 -11102.5 {}
L 2 1262.5 -11107.5 1277.5 -11112.5 {}
L 2 1262.5 -11117.5 1277.5 -11112.5 {}
L 2 1262.5 -11117.5 1277.5 -11122.5 {}
L 2 1262.5 -11127.5 1277.5 -11122.5 {}
L 2 1262.5 -11127.5 1277.5 -11132.5 {}
L 2 1262.5 -11137.5 1277.5 -11132.5 {}
L 2 1262.5 -11137.5 1270 -11140 {}
L 2 1270 -11150 1270 -11140 {}
L 2 1272.5 -11142.5 1277.5 -11142.5 {}
L 2 1275 -11145 1275 -11140 {}
L 2 1360 -11025 1360 -11000 {}
L 2 1360 -11060 1360 -11035 {}
L 2 1350 -11035 1370 -11035 {}
L 2 1350 -11025 1370 -11025 {}
L 2 1362.5 -11052.5 1367.5 -11052.5 {}
L 2 1365 -11055 1365 -11050 {}
L 2 1270 -11090 1270 -11060 {}
L 2 1270 -11180 1270 -11150 {}
L 2 1360 -11000 1360 -10920 {}
L 2 1270 -11030 1270 -10920 {}
L 2 1270 -10920 1360 -10920 {}
L 2 2035 -11070 2035 -11010 {}
L 2 2035 -11060 2050 -11060 {}
L 2 2050 -11070 2050 -11060 {}
L 2 2035 -11020 2050 -11020 {}
L 2 2050 -11020 2050 -11010 {}
L 2 2025 -11055 2025 -11025 {}
L 2 2025 -11040 2025 -11035 {}
L 2 2010 -11040 2017.5 -11040 {}
L 2 2010 -11040 2025 -11040 {}
L 2 2040 -11040 2050 -11040 {}
L 2 2035 -11045 2040 -11040 {}
L 2 2035 -11035 2040 -11040 {}
L 2 2050 -11110 2050 -11100 {}
L 2 2050 -11110 2057.5 -11112.5 {}
L 2 2042.5 -11117.5 2057.5 -11112.5 {}
L 2 2042.5 -11117.5 2057.5 -11122.5 {}
L 2 2042.5 -11127.5 2057.5 -11122.5 {}
L 2 2042.5 -11127.5 2057.5 -11132.5 {}
L 2 2042.5 -11137.5 2057.5 -11132.5 {}
L 2 2042.5 -11137.5 2057.5 -11142.5 {}
L 2 2042.5 -11147.5 2057.5 -11142.5 {}
L 2 2042.5 -11147.5 2050 -11150 {}
L 2 2050 -11160 2050 -11150 {}
L 2 2052.5 -11152.5 2057.5 -11152.5 {}
L 2 2055 -11155 2055 -11150 {}
L 2 2140 -11035 2140 -11010 {}
L 2 2140 -11070 2140 -11045 {}
L 2 2130 -11045 2150 -11045 {}
L 2 2130 -11035 2150 -11035 {}
L 2 2142.5 -11062.5 2147.5 -11062.5 {}
L 2 2145 -11065 2145 -11060 {}
L 2 2050 -11100 2050 -11070 {}
L 2 2050 -11190 2050 -11160 {}
L 2 2140 -11010 2140 -10930 {}
L 2 2050 -11040 2050 -10930 {}
L 2 2050 -10930 2140 -10930 {}
L 2 1360 -10640 1360 -10630 {}
L 2 1360 -10640 1367.5 -10642.5 {}
L 2 1352.5 -10647.5 1367.5 -10642.5 {}
L 2 1352.5 -10647.5 1367.5 -10652.5 {}
L 2 1352.5 -10657.5 1367.5 -10652.5 {}
L 2 1352.5 -10657.5 1367.5 -10662.5 {}
L 2 1352.5 -10667.5 1367.5 -10662.5 {}
L 2 1352.5 -10667.5 1367.5 -10672.5 {}
L 2 1352.5 -10677.5 1367.5 -10672.5 {}
L 2 1352.5 -10677.5 1360 -10680 {}
L 2 1360 -10690 1360 -10680 {}
L 2 1362.5 -10682.5 1367.5 -10682.5 {}
L 2 1365 -10685 1365 -10680 {}
L 2 1360 -7050 1360 -7040 {}
L 2 1360 -7050 1367.5 -7052.5 {}
L 2 1352.5 -7057.5 1367.5 -7052.5 {}
L 2 1352.5 -7057.5 1367.5 -7062.5 {}
L 2 1352.5 -7067.5 1367.5 -7062.5 {}
L 2 1352.5 -7067.5 1367.5 -7072.5 {}
L 2 1352.5 -7077.5 1367.5 -7072.5 {}
L 2 1352.5 -7077.5 1367.5 -7082.5 {}
L 2 1352.5 -7087.5 1367.5 -7082.5 {}
L 2 1352.5 -7087.5 1360 -7090 {}
L 2 1360 -7100 1360 -7090 {}
L 2 1362.5 -7092.5 1367.5 -7092.5 {}
L 2 1365 -7095 1365 -7090 {}
L 2 1280 -7100 1360 -7100 {}
L 2 1280 -7040 1360 -7040 {}
L 2 1360 -6650 1360 -6640 {}
L 2 1360 -6650 1367.5 -6652.5 {}
L 2 1352.5 -6657.5 1367.5 -6652.5 {}
L 2 1352.5 -6657.5 1367.5 -6662.5 {}
L 2 1352.5 -6667.5 1367.5 -6662.5 {}
L 2 1352.5 -6667.5 1367.5 -6672.5 {}
L 2 1352.5 -6677.5 1367.5 -6672.5 {}
L 2 1352.5 -6677.5 1367.5 -6682.5 {}
L 2 1352.5 -6687.5 1367.5 -6682.5 {}
L 2 1352.5 -6687.5 1360 -6690 {}
L 2 1360 -6700 1360 -6690 {}
L 2 1362.5 -6692.5 1367.5 -6692.5 {}
L 2 1365 -6695 1365 -6690 {}
L 2 1280 -6610 1360 -6640 {}
L 2 1280 -6730 1360 -6700 {}
L 2 725 -11060 725 -11000 {}
L 2 725 -11050 740 -11050 {}
L 2 740 -11060 740 -11050 {}
L 2 725 -11010 740 -11010 {}
L 2 740 -11010 740 -11000 {}
L 2 715 -11045 715 -11015 {}
L 2 715 -11030 715 -11025 {}
L 2 700 -11030 707.5 -11030 {}
L 2 700 -11030 715 -11030 {}
L 2 730 -11030 740 -11030 {}
L 2 725 -11035 730 -11030 {}
L 2 725 -11025 730 -11030 {}
L 2 740 -11100 740 -11090 {}
L 2 740 -11100 747.5 -11102.5 {}
L 2 732.5 -11107.5 747.5 -11102.5 {}
L 2 732.5 -11107.5 747.5 -11112.5 {}
L 2 732.5 -11117.5 747.5 -11112.5 {}
L 2 732.5 -11117.5 747.5 -11122.5 {}
L 2 732.5 -11127.5 747.5 -11122.5 {}
L 2 732.5 -11127.5 747.5 -11132.5 {}
L 2 732.5 -11137.5 747.5 -11132.5 {}
L 2 732.5 -11137.5 740 -11140 {}
L 2 740 -11150 740 -11140 {}
L 2 742.5 -11142.5 747.5 -11142.5 {}
L 2 745 -11145 745 -11140 {}
L 2 830 -11025 830 -11000 {}
L 2 830 -11060 830 -11035 {}
L 2 820 -11035 840 -11035 {}
L 2 820 -11025 840 -11025 {}
L 2 832.5 -11052.5 837.5 -11052.5 {}
L 2 835 -11055 835 -11050 {}
L 2 740 -11090 740 -11060 {}
L 2 740 -11180 740 -11150 {}
L 2 830 -11000 830 -10920 {}
L 2 740 -11030 740 -10920 {}
L 2 740 -10920 830 -10920 {}
L 2 725 -6170 725 -6110 {}
L 2 725 -6160 740 -6160 {}
L 2 740 -6170 740 -6160 {}
L 2 725 -6120 740 -6120 {}
L 2 740 -6120 740 -6110 {}
L 2 715 -6155 715 -6125 {}
L 2 715 -6140 715 -6135 {}
L 2 700 -6140 707.5 -6140 {}
L 2 700 -6140 715 -6140 {}
L 2 730 -6140 740 -6140 {}
L 2 725 -6145 730 -6140 {}
L 2 725 -6135 730 -6140 {}
L 2 740 -6210 740 -6200 {}
L 2 740 -6210 747.5 -6212.5 {}
L 2 732.5 -6217.5 747.5 -6212.5 {}
L 2 732.5 -6217.5 747.5 -6222.5 {}
L 2 732.5 -6227.5 747.5 -6222.5 {}
L 2 732.5 -6227.5 747.5 -6232.5 {}
L 2 732.5 -6237.5 747.5 -6232.5 {}
L 2 732.5 -6237.5 747.5 -6242.5 {}
L 2 732.5 -6247.5 747.5 -6242.5 {}
L 2 732.5 -6247.5 740 -6250 {}
L 2 740 -6260 740 -6250 {}
L 2 742.5 -6252.5 747.5 -6252.5 {}
L 2 745 -6255 745 -6250 {}
L 2 830 -6135 830 -6110 {}
L 2 830 -6170 830 -6145 {}
L 2 820 -6145 840 -6145 {}
L 2 820 -6135 840 -6135 {}
L 2 832.5 -6162.5 837.5 -6162.5 {}
L 2 835 -6165 835 -6160 {}
L 2 740 -6200 740 -6170 {}
L 2 740 -6290 740 -6260 {}
L 2 830 -6110 830 -6030 {}
L 2 740 -6140 740 -6030 {}
L 2 740 -6030 830 -6030 {}
L 2 880 -6170 888.75 -6170 {}
L 2 740 -6170 880 -6170 {}
L 2 1285 -6170 1285 -6110 {}
L 2 1285 -6160 1300 -6160 {}
L 2 1300 -6170 1300 -6160 {}
L 2 1285 -6120 1300 -6120 {}
L 2 1300 -6120 1300 -6110 {}
L 2 1275 -6155 1275 -6125 {}
L 2 1275 -6140 1275 -6135 {}
L 2 1260 -6140 1267.5 -6140 {}
L 2 1260 -6140 1275 -6140 {}
L 2 1290 -6140 1300 -6140 {}
L 2 1285 -6145 1290 -6140 {}
L 2 1285 -6135 1290 -6140 {}
L 2 1300 -6210 1300 -6200 {}
L 2 1300 -6210 1307.5 -6212.5 {}
L 2 1292.5 -6217.5 1307.5 -6212.5 {}
L 2 1292.5 -6217.5 1307.5 -6222.5 {}
L 2 1292.5 -6227.5 1307.5 -6222.5 {}
L 2 1292.5 -6227.5 1307.5 -6232.5 {}
L 2 1292.5 -6237.5 1307.5 -6232.5 {}
L 2 1292.5 -6237.5 1307.5 -6242.5 {}
L 2 1292.5 -6247.5 1307.5 -6242.5 {}
L 2 1292.5 -6247.5 1300 -6250 {}
L 2 1300 -6260 1300 -6250 {}
L 2 1302.5 -6252.5 1307.5 -6252.5 {}
L 2 1305 -6255 1305 -6250 {}
L 2 1390 -6135 1390 -6110 {}
L 2 1390 -6170 1390 -6145 {}
L 2 1380 -6145 1400 -6145 {}
L 2 1380 -6135 1400 -6135 {}
L 2 1392.5 -6162.5 1397.5 -6162.5 {}
L 2 1395 -6165 1395 -6160 {}
L 2 1440 -6170 1448.75 -6170 {}
L 2 1300 -6200 1300 -6170 {}
L 2 1300 -6290 1300 -6260 {}
L 2 1300 -6170 1440 -6170 {}
L 2 1390 -6110 1390 -6030 {}
L 2 1300 -6140 1300 -6030 {}
L 2 1300 -6030 1390 -6030 {}
L 2 2105 -6170 2105 -6110 {}
L 2 2105 -6160 2120 -6160 {}
L 2 2120 -6170 2120 -6160 {}
L 2 2105 -6120 2120 -6120 {}
L 2 2120 -6120 2120 -6110 {}
L 2 2095 -6155 2095 -6125 {}
L 2 2095 -6140 2095 -6135 {}
L 2 2080 -6140 2087.5 -6140 {}
L 2 2080 -6140 2095 -6140 {}
L 2 2110 -6140 2120 -6140 {}
L 2 2105 -6145 2110 -6140 {}
L 2 2105 -6135 2110 -6140 {}
L 2 2120 -6210 2120 -6200 {}
L 2 2120 -6210 2127.5 -6212.5 {}
L 2 2112.5 -6217.5 2127.5 -6212.5 {}
L 2 2112.5 -6217.5 2127.5 -6222.5 {}
L 2 2112.5 -6227.5 2127.5 -6222.5 {}
L 2 2112.5 -6227.5 2127.5 -6232.5 {}
L 2 2112.5 -6237.5 2127.5 -6232.5 {}
L 2 2112.5 -6237.5 2127.5 -6242.5 {}
L 2 2112.5 -6247.5 2127.5 -6242.5 {}
L 2 2112.5 -6247.5 2120 -6250 {}
L 2 2120 -6260 2120 -6250 {}
L 2 2122.5 -6252.5 2127.5 -6252.5 {}
L 2 2125 -6255 2125 -6250 {}
L 2 2210 -6135 2210 -6110 {}
L 2 2210 -6170 2210 -6145 {}
L 2 2200 -6145 2220 -6145 {}
L 2 2200 -6135 2220 -6135 {}
L 2 2212.5 -6162.5 2217.5 -6162.5 {}
L 2 2215 -6165 2215 -6160 {}
L 2 2260 -6170 2268.75 -6170 {}
L 2 2120 -6200 2120 -6170 {}
L 2 2120 -6290 2120 -6260 {}
L 2 2120 -6170 2260 -6170 {}
L 2 2210 -6110 2210 -6030 {}
L 2 2120 -6140 2120 -6030 {}
L 2 2120 -6030 2210 -6030 {}
L 2 1770 -6140 2080 -6140 {}
L 2 1690 -6290 2120 -6290 {}
L 2 1690 -6030 2120 -6030 {}
L 2 1255 -10230 1255 -10170 {}
L 2 1255 -10220 1270 -10220 {}
L 2 1270 -10230 1270 -10220 {}
L 2 1255 -10180 1270 -10180 {}
L 2 1270 -10180 1270 -10170 {}
L 2 1245 -10215 1245 -10185 {}
L 2 1245 -10200 1245 -10195 {}
L 2 1230 -10200 1237.5 -10200 {}
L 2 1230 -10200 1245 -10200 {}
L 2 1260 -10200 1270 -10200 {}
L 2 1255 -10205 1260 -10200 {}
L 2 1255 -10195 1260 -10200 {}
L 2 1270 -10270 1270 -10260 {}
L 2 1270 -10270 1277.5 -10272.5 {}
L 2 1262.5 -10277.5 1277.5 -10272.5 {}
L 2 1262.5 -10277.5 1277.5 -10282.5 {}
L 2 1262.5 -10287.5 1277.5 -10282.5 {}
L 2 1262.5 -10287.5 1277.5 -10292.5 {}
L 2 1262.5 -10297.5 1277.5 -10292.5 {}
L 2 1262.5 -10297.5 1277.5 -10302.5 {}
L 2 1262.5 -10307.5 1277.5 -10302.5 {}
L 2 1262.5 -10307.5 1270 -10310 {}
L 2 1270 -10320 1270 -10310 {}
L 2 1272.5 -10312.5 1277.5 -10312.5 {}
L 2 1275 -10315 1275 -10310 {}
L 2 1360 -10195 1360 -10170 {}
L 2 1360 -10230 1360 -10205 {}
L 2 1350 -10205 1370 -10205 {}
L 2 1350 -10195 1370 -10195 {}
L 2 1362.5 -10222.5 1367.5 -10222.5 {}
L 2 1365 -10225 1365 -10220 {}
L 2 1270 -10260 1270 -10230 {}
L 2 1270 -10350 1270 -10320 {}
L 2 1360 -10170 1360 -10090 {}
L 2 1270 -10200 1270 -10090 {}
L 2 1270 -10090 1360 -10090 {}
L 2 2035 -10240 2035 -10180 {}
L 2 2035 -10230 2050 -10230 {}
L 2 2050 -10240 2050 -10230 {}
L 2 2035 -10190 2050 -10190 {}
L 2 2050 -10190 2050 -10180 {}
L 2 2025 -10225 2025 -10195 {}
L 2 2025 -10210 2025 -10205 {}
L 2 2010 -10210 2017.5 -10210 {}
L 2 2010 -10210 2025 -10210 {}
L 2 2040 -10210 2050 -10210 {}
L 2 2035 -10215 2040 -10210 {}
L 2 2035 -10205 2040 -10210 {}
L 2 2050 -10280 2050 -10270 {}
L 2 2050 -10280 2057.5 -10282.5 {}
L 2 2042.5 -10287.5 2057.5 -10282.5 {}
L 2 2042.5 -10287.5 2057.5 -10292.5 {}
L 2 2042.5 -10297.5 2057.5 -10292.5 {}
L 2 2042.5 -10297.5 2057.5 -10302.5 {}
L 2 2042.5 -10307.5 2057.5 -10302.5 {}
L 2 2042.5 -10307.5 2057.5 -10312.5 {}
L 2 2042.5 -10317.5 2057.5 -10312.5 {}
L 2 2042.5 -10317.5 2050 -10320 {}
L 2 2050 -10330 2050 -10320 {}
L 2 2052.5 -10322.5 2057.5 -10322.5 {}
L 2 2055 -10325 2055 -10320 {}
L 2 2140 -10205 2140 -10180 {}
L 2 2140 -10240 2140 -10215 {}
L 2 2130 -10215 2150 -10215 {}
L 2 2130 -10205 2150 -10205 {}
L 2 2142.5 -10232.5 2147.5 -10232.5 {}
L 2 2145 -10235 2145 -10230 {}
L 2 2050 -10270 2050 -10240 {}
L 2 2050 -10360 2050 -10330 {}
L 2 2140 -10180 2140 -10100 {}
L 2 2050 -10210 2050 -10100 {}
L 2 2050 -10100 2140 -10100 {}
L 2 725 -10230 725 -10170 {}
L 2 725 -10220 740 -10220 {}
L 2 740 -10230 740 -10220 {}
L 2 725 -10180 740 -10180 {}
L 2 740 -10180 740 -10170 {}
L 2 715 -10215 715 -10185 {}
L 2 715 -10200 715 -10195 {}
L 2 700 -10200 707.5 -10200 {}
L 2 700 -10200 715 -10200 {}
L 2 730 -10200 740 -10200 {}
L 2 725 -10205 730 -10200 {}
L 2 725 -10195 730 -10200 {}
L 2 740 -10270 740 -10260 {}
L 2 740 -10270 747.5 -10272.5 {}
L 2 732.5 -10277.5 747.5 -10272.5 {}
L 2 732.5 -10277.5 747.5 -10282.5 {}
L 2 732.5 -10287.5 747.5 -10282.5 {}
L 2 732.5 -10287.5 747.5 -10292.5 {}
L 2 732.5 -10297.5 747.5 -10292.5 {}
L 2 732.5 -10297.5 747.5 -10302.5 {}
L 2 732.5 -10307.5 747.5 -10302.5 {}
L 2 732.5 -10307.5 740 -10310 {}
L 2 740 -10320 740 -10310 {}
L 2 742.5 -10312.5 747.5 -10312.5 {}
L 2 745 -10315 745 -10310 {}
L 2 830 -10195 830 -10170 {}
L 2 830 -10230 830 -10205 {}
L 2 820 -10205 840 -10205 {}
L 2 820 -10195 840 -10195 {}
L 2 832.5 -10222.5 837.5 -10222.5 {}
L 2 835 -10225 835 -10220 {}
L 2 740 -10260 740 -10230 {}
L 2 740 -10350 740 -10320 {}
L 2 830 -10170 830 -10090 {}
L 2 740 -10200 740 -10090 {}
L 2 740 -10090 830 -10090 {}
L 2 1795 -11530 1795 -11470 {}
L 2 1795 -11520 1810 -11520 {}
L 2 1810 -11530 1810 -11520 {}
L 2 1795 -11480 1810 -11480 {}
L 2 1810 -11480 1810 -11470 {}
L 2 1785 -11515 1785 -11485 {}
L 2 1785 -11500 1785 -11495 {}
L 2 1770 -11500 1777.5 -11500 {}
L 2 1770 -11500 1785 -11500 {}
L 2 1800 -11500 1810 -11500 {}
L 2 1795 -11505 1800 -11500 {}
L 2 1795 -11495 1800 -11500 {}
L 2 1810 -11570 1810 -11560 {}
L 2 1810 -11570 1817.5 -11572.5 {}
L 2 1802.5 -11577.5 1817.5 -11572.5 {}
L 2 1802.5 -11577.5 1817.5 -11582.5 {}
L 2 1802.5 -11587.5 1817.5 -11582.5 {}
L 2 1802.5 -11587.5 1817.5 -11592.5 {}
L 2 1802.5 -11597.5 1817.5 -11592.5 {}
L 2 1802.5 -11597.5 1817.5 -11602.5 {}
L 2 1802.5 -11607.5 1817.5 -11602.5 {}
L 2 1802.5 -11607.5 1810 -11610 {}
L 2 1810 -11620 1810 -11610 {}
L 2 1812.5 -11612.5 1817.5 -11612.5 {}
L 2 1815 -11615 1815 -11610 {}
L 2 1900 -11495 1900 -11470 {}
L 2 1900 -11530 1900 -11505 {}
L 2 1890 -11505 1910 -11505 {}
L 2 1890 -11495 1910 -11495 {}
L 2 1902.5 -11522.5 1907.5 -11522.5 {}
L 2 1905 -11525 1905 -11520 {}
L 2 1810 -11560 1810 -11530 {}
L 2 1810 -11650 1810 -11620 {}
L 2 1900 -11470 1900 -11390 {}
L 2 1810 -11500 1810 -11390 {}
L 2 1810 -11390 1900 -11390 {}
L 2 670 -11530 670 -11470 {}
L 2 670 -11520 685 -11520 {}
L 2 685 -11530 685 -11520 {}
L 2 670 -11480 685 -11480 {}
L 2 685 -11480 685 -11470 {}
L 2 660 -11515 660 -11485 {}
L 2 660 -11500 660 -11495 {}
L 2 645 -11500 652.5 -11500 {}
L 2 645 -11500 660 -11500 {}
L 2 675 -11500 685 -11500 {}
L 2 670 -11505 675 -11500 {}
L 2 670 -11495 675 -11500 {}
L 2 685 -11570 685 -11560 {}
L 2 685 -11570 692.5 -11572.5 {}
L 2 677.5 -11577.5 692.5 -11572.5 {}
L 2 677.5 -11577.5 692.5 -11582.5 {}
L 2 677.5 -11587.5 692.5 -11582.5 {}
L 2 677.5 -11587.5 692.5 -11592.5 {}
L 2 677.5 -11597.5 692.5 -11592.5 {}
L 2 677.5 -11597.5 692.5 -11602.5 {}
L 2 677.5 -11607.5 692.5 -11602.5 {}
L 2 677.5 -11607.5 685 -11610 {}
L 2 685 -11620 685 -11610 {}
L 2 687.5 -11612.5 692.5 -11612.5 {}
L 2 690 -11615 690 -11610 {}
L 2 775 -11495 775 -11470 {}
L 2 775 -11530 775 -11505 {}
L 2 765 -11505 785 -11505 {}
L 2 765 -11495 785 -11495 {}
L 2 777.5 -11522.5 782.5 -11522.5 {}
L 2 780 -11525 780 -11520 {}
L 2 685 -11560 685 -11530 {}
L 2 685 -11650 685 -11620 {}
L 2 775 -11470 775 -11390 {}
L 2 685 -11500 685 -11390 {}
L 2 685 -11390 775 -11390 {}
L 2 1572.5 -11462.5 1577.5 -11462.5 {}
L 2 1575 -11465 1575 -11460 {}
L 2 1570 -11470 1570 -11410 {}
L 2 1570 -11410 1570 -11390 {}
L 2 1570 -11650 1570 -11470 {}
L 2 2255 -11530 2255 -11470 {}
L 2 2255 -11520 2270 -11520 {}
L 2 2270 -11530 2270 -11520 {}
L 2 2255 -11480 2270 -11480 {}
L 2 2270 -11480 2270 -11470 {}
L 2 2245 -11515 2245 -11485 {}
L 2 2245 -11500 2245 -11495 {}
L 2 2230 -11500 2237.5 -11500 {}
L 2 2230 -11500 2245 -11500 {}
L 2 2260 -11500 2270 -11500 {}
L 2 2255 -11505 2260 -11500 {}
L 2 2255 -11495 2260 -11500 {}
L 2 2270 -11570 2270 -11560 {}
L 2 2270 -11570 2277.5 -11572.5 {}
L 2 2262.5 -11577.5 2277.5 -11572.5 {}
L 2 2262.5 -11577.5 2277.5 -11582.5 {}
L 2 2262.5 -11587.5 2277.5 -11582.5 {}
L 2 2262.5 -11587.5 2277.5 -11592.5 {}
L 2 2262.5 -11597.5 2277.5 -11592.5 {}
L 2 2262.5 -11597.5 2277.5 -11602.5 {}
L 2 2262.5 -11607.5 2277.5 -11602.5 {}
L 2 2262.5 -11607.5 2270 -11610 {}
L 2 2270 -11620 2270 -11610 {}
L 2 2272.5 -11612.5 2277.5 -11612.5 {}
L 2 2275 -11615 2275 -11610 {}
L 2 2270 -11560 2270 -11530 {}
L 2 2270 -11650 2270 -11620 {}
L 2 2270 -11500 2270 -11390 {}
L 2 2270 -11390 2360 -11390 {}
L 2 2032.5 -11462.5 2037.5 -11462.5 {}
L 2 2035 -11465 2035 -11460 {}
L 2 2030 -11470 2030 -11410 {}
L 2 2030 -11410 2030 -11390 {}
L 2 2030 -11650 2030 -11470 {}
L 2 520 -9510 760 -9510 {}
L 2 1060 -9510 1300 -9510 {}
L 2 2190 -9510 2500 -9580 {}
L 2 1360 -5250 1360 -5240 {}
L 2 1360 -5250 1367.5 -5252.5 {}
L 2 1352.5 -5257.5 1367.5 -5252.5 {}
L 2 1352.5 -5257.5 1367.5 -5262.5 {}
L 2 1352.5 -5267.5 1367.5 -5262.5 {}
L 2 1352.5 -5267.5 1367.5 -5272.5 {}
L 2 1352.5 -5277.5 1367.5 -5272.5 {}
L 2 1352.5 -5277.5 1367.5 -5282.5 {}
L 2 1352.5 -5287.5 1367.5 -5282.5 {}
L 2 1352.5 -5287.5 1360 -5290 {}
L 2 1360 -5300 1360 -5290 {}
L 2 1362.5 -5292.5 1367.5 -5292.5 {}
L 2 1365 -5295 1365 -5290 {}
L 2 1900 -5280 1900 -5240 {}
L 2 1360 -4570 1360 -4470 {}
L 2 1250 -4570 1250 -4470 {}
L 2 1470 -4570 1470 -4470 {}
L 2 1900 -4570 1900 -4470 {}
L 2 1790 -4570 1790 -4470 {}
L 2 2010 -4570 2010 -4470 {}
L 2 2430 -4670 2430 -4470 {}
L 2 2320 -4670 2320 -4470 {}
L 2 2540 -4670 2540 -4470 {}
L 2 1360 -2640 1360 -2540 {}
L 2 1250 -2640 1250 -2540 {}
L 2 1470 -2640 1470 -2540 {}
L 2 1250 -2490 1250 -2480 {}
L 2 1250 -2490 1257.5 -2492.5 {}
L 2 1242.5 -2497.5 1257.5 -2492.5 {}
L 2 1242.5 -2497.5 1257.5 -2502.5 {}
L 2 1242.5 -2507.5 1257.5 -2502.5 {}
L 2 1242.5 -2507.5 1257.5 -2512.5 {}
L 2 1242.5 -2517.5 1257.5 -2512.5 {}
L 2 1242.5 -2517.5 1257.5 -2522.5 {}
L 2 1242.5 -2527.5 1257.5 -2522.5 {}
L 2 1242.5 -2527.5 1250 -2530 {}
L 2 1250 -2540 1250 -2530 {}
L 2 1252.5 -2532.5 1257.5 -2532.5 {}
L 2 1255 -2535 1255 -2530 {}
L 2 1360 -2490 1360 -2480 {}
L 2 1360 -2490 1367.5 -2492.5 {}
L 2 1352.5 -2497.5 1367.5 -2492.5 {}
L 2 1352.5 -2497.5 1367.5 -2502.5 {}
L 2 1352.5 -2507.5 1367.5 -2502.5 {}
L 2 1352.5 -2507.5 1367.5 -2512.5 {}
L 2 1352.5 -2517.5 1367.5 -2512.5 {}
L 2 1352.5 -2517.5 1367.5 -2522.5 {}
L 2 1352.5 -2527.5 1367.5 -2522.5 {}
L 2 1352.5 -2527.5 1360 -2530 {}
L 2 1360 -2540 1360 -2530 {}
L 2 1362.5 -2532.5 1367.5 -2532.5 {}
L 2 1365 -2535 1365 -2530 {}
L 2 1470 -2490 1470 -2480 {}
L 2 1470 -2490 1477.5 -2492.5 {}
L 2 1462.5 -2497.5 1477.5 -2492.5 {}
L 2 1462.5 -2497.5 1477.5 -2502.5 {}
L 2 1462.5 -2507.5 1477.5 -2502.5 {}
L 2 1462.5 -2507.5 1477.5 -2512.5 {}
L 2 1462.5 -2517.5 1477.5 -2512.5 {}
L 2 1462.5 -2517.5 1477.5 -2522.5 {}
L 2 1462.5 -2527.5 1477.5 -2522.5 {}
L 2 1462.5 -2527.5 1470 -2530 {}
L 2 1470 -2540 1470 -2530 {}
L 2 1472.5 -2532.5 1477.5 -2532.5 {}
L 2 1475 -2535 1475 -2530 {}
L 2 1360 -2480 1360 -2450 {}
L 2 1250 -2480 1250 -2450 {}
L 2 1470 -2480 1470 -2450 {}
L 2 1900 -2640 1900 -2590 {}
L 2 1790 -2640 1790 -2590 {}
L 2 2010 -2640 2010 -2590 {}
L 2 1790 -2540 1790 -2530 {}
L 2 1790 -2540 1797.5 -2542.5 {}
L 2 1782.5 -2547.5 1797.5 -2542.5 {}
L 2 1782.5 -2547.5 1797.5 -2552.5 {}
L 2 1782.5 -2557.5 1797.5 -2552.5 {}
L 2 1782.5 -2557.5 1797.5 -2562.5 {}
L 2 1782.5 -2567.5 1797.5 -2562.5 {}
L 2 1782.5 -2567.5 1797.5 -2572.5 {}
L 2 1782.5 -2577.5 1797.5 -2572.5 {}
L 2 1782.5 -2577.5 1790 -2580 {}
L 2 1790 -2590 1790 -2580 {}
L 2 1792.5 -2582.5 1797.5 -2582.5 {}
L 2 1795 -2585 1795 -2580 {}
L 2 1900 -2540 1900 -2530 {}
L 2 1900 -2540 1907.5 -2542.5 {}
L 2 1892.5 -2547.5 1907.5 -2542.5 {}
L 2 1892.5 -2547.5 1907.5 -2552.5 {}
L 2 1892.5 -2557.5 1907.5 -2552.5 {}
L 2 1892.5 -2557.5 1907.5 -2562.5 {}
L 2 1892.5 -2567.5 1907.5 -2562.5 {}
L 2 1892.5 -2567.5 1907.5 -2572.5 {}
L 2 1892.5 -2577.5 1907.5 -2572.5 {}
L 2 1892.5 -2577.5 1900 -2580 {}
L 2 1900 -2590 1900 -2580 {}
L 2 1902.5 -2582.5 1907.5 -2582.5 {}
L 2 1905 -2585 1905 -2580 {}
L 2 2010 -2540 2010 -2530 {}
L 2 2010 -2540 2017.5 -2542.5 {}
L 2 2002.5 -2547.5 2017.5 -2542.5 {}
L 2 2002.5 -2547.5 2017.5 -2552.5 {}
L 2 2002.5 -2557.5 2017.5 -2552.5 {}
L 2 2002.5 -2557.5 2017.5 -2562.5 {}
L 2 2002.5 -2567.5 2017.5 -2562.5 {}
L 2 2002.5 -2567.5 2017.5 -2572.5 {}
L 2 2002.5 -2577.5 2017.5 -2572.5 {}
L 2 2002.5 -2577.5 2010 -2580 {}
L 2 2010 -2590 2010 -2580 {}
L 2 2012.5 -2582.5 2017.5 -2582.5 {}
L 2 2015 -2585 2015 -2580 {}
L 2 1900 -2530 1900 -2450 {}
L 2 1790 -2530 1790 -2450 {}
L 2 2010 -2530 2010 -2450 {}
L 2 635 -4210 635 -4150 {}
L 2 635 -4200 650 -4200 {}
L 2 650 -4210 650 -4200 {}
L 2 635 -4160 650 -4160 {}
L 2 650 -4160 650 -4150 {}
L 2 625 -4195 625 -4165 {}
L 2 625 -4180 625 -4175 {}
L 2 610 -4180 617.5 -4180 {}
L 2 610 -4180 625 -4180 {}
L 2 640 -4180 650 -4180 {}
L 2 635 -4185 640 -4180 {}
L 2 635 -4175 640 -4180 {}
L 2 1215 -4210 1215 -4150 {}
L 2 1215 -4200 1230 -4200 {}
L 2 1230 -4210 1230 -4200 {}
L 2 1215 -4160 1230 -4160 {}
L 2 1230 -4160 1230 -4150 {}
L 2 1205 -4195 1205 -4165 {}
L 2 1205 -4180 1205 -4175 {}
L 2 1190 -4180 1197.5 -4180 {}
L 2 1190 -4180 1205 -4180 {}
L 2 1220 -4180 1230 -4180 {}
L 2 1215 -4185 1220 -4180 {}
L 2 1215 -4175 1220 -4180 {}
L 2 1255 -11530 1255 -11470 {}
L 2 1255 -11520 1270 -11520 {}
L 2 1270 -11530 1270 -11520 {}
L 2 1255 -11480 1270 -11480 {}
L 2 1270 -11480 1270 -11470 {}
L 2 1245 -11515 1245 -11485 {}
L 2 1245 -11500 1245 -11495 {}
L 2 1230 -11500 1237.5 -11500 {}
L 2 1230 -11500 1245 -11500 {}
L 2 1260 -11500 1270 -11500 {}
L 2 1255 -11505 1260 -11500 {}
L 2 1255 -11495 1260 -11500 {}
L 2 1270 -11570 1270 -11560 {}
L 2 1270 -11570 1277.5 -11572.5 {}
L 2 1262.5 -11577.5 1277.5 -11572.5 {}
L 2 1262.5 -11577.5 1277.5 -11582.5 {}
L 2 1262.5 -11587.5 1277.5 -11582.5 {}
L 2 1262.5 -11587.5 1277.5 -11592.5 {}
L 2 1262.5 -11597.5 1277.5 -11592.5 {}
L 2 1262.5 -11597.5 1277.5 -11602.5 {}
L 2 1262.5 -11607.5 1277.5 -11602.5 {}
L 2 1262.5 -11607.5 1270 -11610 {}
L 2 1270 -11620 1270 -11610 {}
L 2 1272.5 -11612.5 1277.5 -11612.5 {}
L 2 1275 -11615 1275 -11610 {}
L 2 1360 -11495 1360 -11470 {}
L 2 1360 -11530 1360 -11505 {}
L 2 1350 -11505 1370 -11505 {}
L 2 1350 -11495 1370 -11495 {}
L 2 1362.5 -11522.5 1367.5 -11522.5 {}
L 2 1365 -11525 1365 -11520 {}
L 2 1270 -11560 1270 -11530 {}
L 2 1270 -11650 1270 -11620 {}
L 2 1360 -11470 1360 -11390 {}
L 2 1270 -11500 1270 -11390 {}
L 2 1270 -11390 1360 -11390 {}
L 2 1360 -2260 1360 -2160 {}
L 2 1250 -2260 1250 -2160 {}
L 2 1470 -2260 1470 -2160 {}
L 2 1250 -2110 1250 -2100 {}
L 2 1250 -2110 1257.5 -2112.5 {}
L 2 1242.5 -2117.5 1257.5 -2112.5 {}
L 2 1242.5 -2117.5 1257.5 -2122.5 {}
L 2 1242.5 -2127.5 1257.5 -2122.5 {}
L 2 1242.5 -2127.5 1257.5 -2132.5 {}
L 2 1242.5 -2137.5 1257.5 -2132.5 {}
L 2 1242.5 -2137.5 1257.5 -2142.5 {}
L 2 1242.5 -2147.5 1257.5 -2142.5 {}
L 2 1242.5 -2147.5 1250 -2150 {}
L 2 1250 -2160 1250 -2150 {}
L 2 1252.5 -2152.5 1257.5 -2152.5 {}
L 2 1255 -2155 1255 -2150 {}
L 2 1360 -2110 1360 -2100 {}
L 2 1360 -2110 1367.5 -2112.5 {}
L 2 1352.5 -2117.5 1367.5 -2112.5 {}
L 2 1352.5 -2117.5 1367.5 -2122.5 {}
L 2 1352.5 -2127.5 1367.5 -2122.5 {}
L 2 1352.5 -2127.5 1367.5 -2132.5 {}
L 2 1352.5 -2137.5 1367.5 -2132.5 {}
L 2 1352.5 -2137.5 1367.5 -2142.5 {}
L 2 1352.5 -2147.5 1367.5 -2142.5 {}
L 2 1352.5 -2147.5 1360 -2150 {}
L 2 1360 -2160 1360 -2150 {}
L 2 1362.5 -2152.5 1367.5 -2152.5 {}
L 2 1365 -2155 1365 -2150 {}
L 2 1470 -2110 1470 -2100 {}
L 2 1470 -2110 1477.5 -2112.5 {}
L 2 1462.5 -2117.5 1477.5 -2112.5 {}
L 2 1462.5 -2117.5 1477.5 -2122.5 {}
L 2 1462.5 -2127.5 1477.5 -2122.5 {}
L 2 1462.5 -2127.5 1477.5 -2132.5 {}
L 2 1462.5 -2137.5 1477.5 -2132.5 {}
L 2 1462.5 -2137.5 1477.5 -2142.5 {}
L 2 1462.5 -2147.5 1477.5 -2142.5 {}
L 2 1462.5 -2147.5 1470 -2150 {}
L 2 1470 -2160 1470 -2150 {}
L 2 1472.5 -2152.5 1477.5 -2152.5 {}
L 2 1475 -2155 1475 -2150 {}
L 2 1900 -2260 1900 -2210 {}
L 2 1790 -2260 1790 -2210 {}
L 2 2010 -2260 2010 -2210 {}
L 2 1790 -2160 1790 -2150 {}
L 2 1790 -2160 1797.5 -2162.5 {}
L 2 1782.5 -2167.5 1797.5 -2162.5 {}
L 2 1782.5 -2167.5 1797.5 -2172.5 {}
L 2 1782.5 -2177.5 1797.5 -2172.5 {}
L 2 1782.5 -2177.5 1797.5 -2182.5 {}
L 2 1782.5 -2187.5 1797.5 -2182.5 {}
L 2 1782.5 -2187.5 1797.5 -2192.5 {}
L 2 1782.5 -2197.5 1797.5 -2192.5 {}
L 2 1782.5 -2197.5 1790 -2200 {}
L 2 1790 -2210 1790 -2200 {}
L 2 1792.5 -2202.5 1797.5 -2202.5 {}
L 2 1795 -2205 1795 -2200 {}
L 2 1900 -2160 1900 -2150 {}
L 2 1900 -2160 1907.5 -2162.5 {}
L 2 1892.5 -2167.5 1907.5 -2162.5 {}
L 2 1892.5 -2167.5 1907.5 -2172.5 {}
L 2 1892.5 -2177.5 1907.5 -2172.5 {}
L 2 1892.5 -2177.5 1907.5 -2182.5 {}
L 2 1892.5 -2187.5 1907.5 -2182.5 {}
L 2 1892.5 -2187.5 1907.5 -2192.5 {}
L 2 1892.5 -2197.5 1907.5 -2192.5 {}
L 2 1892.5 -2197.5 1900 -2200 {}
L 2 1900 -2210 1900 -2200 {}
L 2 1902.5 -2202.5 1907.5 -2202.5 {}
L 2 1905 -2205 1905 -2200 {}
L 2 2010 -2160 2010 -2150 {}
L 2 2010 -2160 2017.5 -2162.5 {}
L 2 2002.5 -2167.5 2017.5 -2162.5 {}
L 2 2002.5 -2167.5 2017.5 -2172.5 {}
L 2 2002.5 -2177.5 2017.5 -2172.5 {}
L 2 2002.5 -2177.5 2017.5 -2182.5 {}
L 2 2002.5 -2187.5 2017.5 -2182.5 {}
L 2 2002.5 -2187.5 2017.5 -2192.5 {}
L 2 2002.5 -2197.5 2017.5 -2192.5 {}
L 2 2002.5 -2197.5 2010 -2200 {}
L 2 2010 -2210 2010 -2200 {}
L 2 2012.5 -2202.5 2017.5 -2202.5 {}
L 2 2015 -2205 2015 -2200 {}
L 2 1900 -2150 1900 -2070 {}
L 2 1790 -2150 1790 -2070 {}
L 2 2010 -2150 2010 -2070 {}
L 2 600 -3930 720 -3930 {}
L 2 1220 -3840 1340 -3840 {}
L 2 740 -3710 740 -3590 {}
L 2 1280 -3680 1280 -3560 {}
L 2 2280 -3600 2410 -3600 {}
L 2 2360 -5090 2440 -4920 {}
L 2 1900 -5090 1900 -4920 {}
L 2 1760 -2880 1880 -2880 {}
L 2 680 -2930 680 -2920 {}
L 2 680 -2930 687.5 -2932.5 {}
L 2 672.5 -2937.5 687.5 -2932.5 {}
L 2 672.5 -2937.5 687.5 -2942.5 {}
L 2 672.5 -2947.5 687.5 -2942.5 {}
L 2 672.5 -2947.5 687.5 -2952.5 {}
L 2 672.5 -2957.5 687.5 -2952.5 {}
L 2 672.5 -2957.5 687.5 -2962.5 {}
L 2 672.5 -2967.5 687.5 -2962.5 {}
L 2 672.5 -2967.5 680 -2970 {}
L 2 680 -2980 680 -2970 {}
L 2 682.5 -2972.5 687.5 -2972.5 {}
L 2 685 -2975 685 -2970 {}
L 2 800 -2930 800 -2920 {}
L 2 800 -2930 807.5 -2932.5 {}
L 2 792.5 -2937.5 807.5 -2932.5 {}
L 2 792.5 -2937.5 807.5 -2942.5 {}
L 2 792.5 -2947.5 807.5 -2942.5 {}
L 2 792.5 -2947.5 807.5 -2952.5 {}
L 2 792.5 -2957.5 807.5 -2952.5 {}
L 2 792.5 -2957.5 807.5 -2962.5 {}
L 2 792.5 -2967.5 807.5 -2962.5 {}
L 2 792.5 -2967.5 800 -2970 {}
L 2 800 -2980 800 -2970 {}
L 2 802.5 -2972.5 807.5 -2972.5 {}
L 2 805 -2975 805 -2970 {}
L 2 1220 -2930 1220 -2920 {}
L 2 1220 -2930 1227.5 -2932.5 {}
L 2 1212.5 -2937.5 1227.5 -2932.5 {}
L 2 1212.5 -2937.5 1227.5 -2942.5 {}
L 2 1212.5 -2947.5 1227.5 -2942.5 {}
L 2 1212.5 -2947.5 1227.5 -2952.5 {}
L 2 1212.5 -2957.5 1227.5 -2952.5 {}
L 2 1212.5 -2957.5 1227.5 -2962.5 {}
L 2 1212.5 -2967.5 1227.5 -2962.5 {}
L 2 1212.5 -2967.5 1220 -2970 {}
L 2 1220 -2980 1220 -2970 {}
L 2 1222.5 -2972.5 1227.5 -2972.5 {}
L 2 1225 -2975 1225 -2970 {}
L 2 1340 -2930 1340 -2920 {}
L 2 1340 -2930 1347.5 -2932.5 {}
L 2 1332.5 -2937.5 1347.5 -2932.5 {}
L 2 1332.5 -2937.5 1347.5 -2942.5 {}
L 2 1332.5 -2947.5 1347.5 -2942.5 {}
L 2 1332.5 -2947.5 1347.5 -2952.5 {}
L 2 1332.5 -2957.5 1347.5 -2952.5 {}
L 2 1332.5 -2957.5 1347.5 -2962.5 {}
L 2 1332.5 -2967.5 1347.5 -2962.5 {}
L 2 1332.5 -2967.5 1340 -2970 {}
L 2 1340 -2980 1340 -2970 {}
L 2 1342.5 -2972.5 1347.5 -2972.5 {}
L 2 1345 -2975 1345 -2970 {}
L 2 1510 -1665 1510 -1640 {}
L 2 1510 -1700 1510 -1675 {}
L 2 1500 -1675 1520 -1675 {}
L 2 1500 -1665 1520 -1665 {}
L 2 1512.5 -1692.5 1517.5 -1692.5 {}
L 2 1515 -1695 1515 -1690 {}
L 2 1510 -1640 1510 -1560 {}
L 2 1180 -1580 1180 -1560 {}
L 2 1420 -1670 1420 -1560 {}
L 2 1420 -1560 1510 -1560 {}
L 2 1180 -1560 1420 -1560 {}
L 2 1420 -1700 1560 -1700 {}
L 2 740 -3280 740 -3160 {}
L 2 1200 -3330 1200 -3210 {}
L 2 2360 -3240 2610 -3240 {}
L 2 2430 -1845 2430 -1820 {}
L 2 2430 -1880 2430 -1855 {}
L 2 2420 -1855 2440 -1855 {}
L 2 2420 -1845 2440 -1845 {}
L 2 2432.5 -1872.5 2437.5 -1872.5 {}
L 2 2435 -1875 2435 -1870 {}
L 2 2430 -1820 2430 -1740 {}
L 2 2100 -1760 2100 -1740 {}
L 2 2340 -1850 2340 -1740 {}
L 2 2340 -1740 2430 -1740 {}
L 2 2100 -1740 2340 -1740 {}
L 2 2340 -1880 2480 -1880 {}
L 2 560 -9110 560 -9000 {}
L 2 1320 -9110 1380 -9110 {}
L 2 850 -5725 850 -5700 {}
L 2 850 -5760 850 -5735 {}
L 2 840 -5735 860 -5735 {}
L 2 840 -5725 860 -5725 {}
L 2 852.5 -5752.5 857.5 -5752.5 {}
L 2 855 -5755 855 -5750 {}
L 2 850 -5700 850 -5620 {}
L 2 1710 -5725 1710 -5700 {}
L 2 1710 -5760 1710 -5735 {}
L 2 1700 -5735 1720 -5735 {}
L 2 1700 -5725 1720 -5725 {}
L 2 1712.5 -5752.5 1717.5 -5752.5 {}
L 2 1715 -5755 1715 -5750 {}
L 2 1710 -5700 1710 -5620 {}
L 2 2470 -5725 2470 -5700 {}
L 2 2470 -5760 2470 -5735 {}
L 2 2460 -5735 2480 -5735 {}
L 2 2460 -5725 2480 -5725 {}
L 2 2472.5 -5752.5 2477.5 -5752.5 {}
L 2 2475 -5755 2475 -5750 {}
L 2 2470 -5700 2470 -5620 {}
L 2 805 -9920 885 -9920 {}
L 2 1330 -9810 1410 -9810 {}
L 2 1830 -9810 1910 -9810 {}
L 2 2260 -9810 2400 -9810 {}
L 2 1850 -9110 1910 -9110 {}
L 2 2150 -8940 2210 -8940 {}
L 2 515 -8750 515 -8690 {}
L 2 515 -8740 530 -8740 {}
L 2 530 -8750 530 -8740 {}
L 2 515 -8700 530 -8700 {}
L 2 530 -8700 530 -8690 {}
L 2 505 -8735 505 -8705 {}
L 2 505 -8720 505 -8715 {}
L 2 490 -8720 497.5 -8720 {}
L 2 490 -8720 505 -8720 {}
L 2 520 -8720 530 -8720 {}
L 2 515 -8725 520 -8720 {}
L 2 515 -8715 520 -8720 {}
L 2 455 -8720 460 -8720 {}
L 2 460 -8720 490 -8720 {}
L 2 530 -8720 530 -8610 {}
L 2 790 -8665 850 -8665 {}
L 2 840 -8665 840 -8650 {}
L 2 840 -8650 850 -8650 {}
L 2 800 -8665 800 -8650 {}
L 2 790 -8650 800 -8650 {}
L 2 805 -8675 835 -8675 {}
L 2 815 -8675 820 -8675 {}
L 2 820 -8690 820 -8682.5 {}
L 2 820 -8690 820 -8675 {}
L 2 820 -8660 820 -8650 {}
L 2 820 -8660 825 -8665 {}
L 2 815 -8665 820 -8660 {}
L 2 820 -8725 820 -8720 {}
L 2 820 -8720 820 -8690 {}
L 2 710 -8650 820 -8650 {}
L 2 1115 -8680 1115 -8620 {}
L 2 1100 -8630 1115 -8630 {}
L 2 1100 -8630 1100 -8620 {}
L 2 1100 -8670 1115 -8670 {}
L 2 1100 -8680 1100 -8670 {}
L 2 1125 -8665 1125 -8635 {}
L 2 1125 -8655 1125 -8650 {}
L 2 1132.5 -8650 1140 -8650 {}
L 2 1125 -8650 1140 -8650 {}
L 2 1100 -8650 1110 -8650 {}
L 2 1110 -8650 1115 -8645 {}
L 2 1110 -8650 1115 -8655 {}
L 2 1170 -8650 1175 -8650 {}
L 2 1140 -8650 1170 -8650 {}
L 2 1100 -8760 1100 -8650 {}
L 2 1380 -8715 1440 -8715 {}
L 2 1390 -8730 1390 -8715 {}
L 2 1380 -8730 1390 -8730 {}
L 2 1430 -8730 1430 -8715 {}
L 2 1430 -8730 1440 -8730 {}
L 2 1395 -8705 1425 -8705 {}
L 2 1410 -8705 1415 -8705 {}
L 2 1410 -8697.5 1410 -8690 {}
L 2 1410 -8705 1410 -8690 {}
L 2 1410 -8730 1410 -8720 {}
L 2 1405 -8715 1410 -8720 {}
L 2 1410 -8720 1415 -8715 {}
L 2 1410 -8660 1410 -8655 {}
L 2 1410 -8690 1410 -8660 {}
L 2 1410 -8730 1520 -8730 {}
L 2 1720 -8715 1780 -8715 {}
L 2 1770 -8730 1770 -8715 {}
L 2 1770 -8730 1780 -8730 {}
L 2 1730 -8730 1730 -8715 {}
L 2 1720 -8730 1730 -8730 {}
L 2 1735 -8705 1765 -8705 {}
L 2 1745 -8705 1750 -8705 {}
L 2 1750 -8697.5 1750 -8690 {}
L 2 1750 -8705 1750 -8690 {}
L 2 1750 -8730 1750 -8720 {}
L 2 1750 -8720 1755 -8715 {}
L 2 1745 -8715 1750 -8720 {}
L 2 1750 -8660 1750 -8655 {}
L 2 1750 -8690 1750 -8660 {}
L 2 1640 -8730 1750 -8730 {}
L 2 2050 -8675 2110 -8675 {}
L 2 2100 -8675 2100 -8660 {}
L 2 2100 -8660 2110 -8660 {}
L 2 2060 -8675 2060 -8660 {}
L 2 2050 -8660 2060 -8660 {}
L 2 2065 -8685 2095 -8685 {}
L 2 2075 -8685 2080 -8685 {}
L 2 2080 -8700 2080 -8692.5 {}
L 2 2080 -8700 2080 -8685 {}
L 2 2080 -8670 2080 -8660 {}
L 2 2080 -8670 2085 -8675 {}
L 2 2075 -8675 2080 -8670 {}
L 2 2080 -8735 2080 -8730 {}
L 2 2080 -8730 2080 -8700 {}
L 2 1970 -8660 2080 -8660 {}
L 2 530 -8370 770 -8370 {}
L 2 755 -8250 755 -8190 {}
L 2 755 -8240 770 -8240 {}
L 2 770 -8250 770 -8240 {}
L 2 755 -8200 770 -8200 {}
L 2 770 -8200 770 -8190 {}
L 2 745 -8235 745 -8205 {}
L 2 745 -8220 745 -8215 {}
L 2 730 -8220 737.5 -8220 {}
L 2 730 -8220 745 -8220 {}
L 2 760 -8220 770 -8220 {}
L 2 755 -8225 760 -8220 {}
L 2 755 -8215 760 -8220 {}
L 2 770 -8290 770 -8280 {}
L 2 770 -8290 777.5 -8292.5 {}
L 2 762.5 -8297.5 777.5 -8292.5 {}
L 2 762.5 -8297.5 777.5 -8302.5 {}
L 2 762.5 -8307.5 777.5 -8302.5 {}
L 2 762.5 -8307.5 777.5 -8312.5 {}
L 2 762.5 -8317.5 777.5 -8312.5 {}
L 2 762.5 -8317.5 777.5 -8322.5 {}
L 2 762.5 -8327.5 777.5 -8322.5 {}
L 2 762.5 -8327.5 770 -8330 {}
L 2 770 -8340 770 -8330 {}
L 2 772.5 -8332.5 777.5 -8332.5 {}
L 2 775 -8335 775 -8330 {}
L 2 860 -8215 860 -8190 {}
L 2 860 -8250 860 -8225 {}
L 2 850 -8225 870 -8225 {}
L 2 850 -8215 870 -8215 {}
L 2 862.5 -8242.5 867.5 -8242.5 {}
L 2 865 -8245 865 -8240 {}
L 2 532.5 -8182.5 537.5 -8182.5 {}
L 2 535 -8185 535 -8180 {}
L 2 530 -8190 530 -8130 {}
L 2 640 -8110 640 -8097.5 {}
L 2 635 -8097.5 645 -8097.5 {}
L 2 640 -8092.5 645 -8097.5 {}
L 2 635 -8097.5 640 -8092.5 {}
L 2 640 -8390 640 -8370 {}
L 2 630 -8390 650 -8390 {}
L 2 605 -8220 610 -8220 {}
L 2 610 -8220 730 -8220 {}
L 2 770 -8280 770 -8250 {}
L 2 770 -8370 770 -8340 {}
L 2 860 -8190 860 -8110 {}
L 2 530 -8130 530 -8110 {}
L 2 530 -8370 530 -8190 {}
L 2 770 -8220 770 -8110 {}
L 2 770 -8110 860 -8110 {}
L 2 530 -8110 770 -8110 {}
L 2 1005 -8370 1245 -8370 {}
L 2 1230 -8250 1230 -8190 {}
L 2 1230 -8240 1245 -8240 {}
L 2 1245 -8250 1245 -8240 {}
L 2 1230 -8200 1245 -8200 {}
L 2 1245 -8200 1245 -8190 {}
L 2 1220 -8235 1220 -8205 {}
L 2 1220 -8220 1220 -8215 {}
L 2 1205 -8220 1212.5 -8220 {}
L 2 1205 -8220 1220 -8220 {}
L 2 1235 -8220 1245 -8220 {}
L 2 1230 -8225 1235 -8220 {}
L 2 1230 -8215 1235 -8220 {}
L 2 1245 -8290 1245 -8280 {}
L 2 1245 -8290 1252.5 -8292.5 {}
L 2 1237.5 -8297.5 1252.5 -8292.5 {}
L 2 1237.5 -8297.5 1252.5 -8302.5 {}
L 2 1237.5 -8307.5 1252.5 -8302.5 {}
L 2 1237.5 -8307.5 1252.5 -8312.5 {}
L 2 1237.5 -8317.5 1252.5 -8312.5 {}
L 2 1237.5 -8317.5 1252.5 -8322.5 {}
L 2 1237.5 -8327.5 1252.5 -8322.5 {}
L 2 1237.5 -8327.5 1245 -8330 {}
L 2 1245 -8340 1245 -8330 {}
L 2 1247.5 -8332.5 1252.5 -8332.5 {}
L 2 1250 -8335 1250 -8330 {}
L 2 1335 -8215 1335 -8190 {}
L 2 1335 -8250 1335 -8225 {}
L 2 1325 -8225 1345 -8225 {}
L 2 1325 -8215 1345 -8215 {}
L 2 1337.5 -8242.5 1342.5 -8242.5 {}
L 2 1340 -8245 1340 -8240 {}
L 2 1007.5 -8182.5 1012.5 -8182.5 {}
L 2 1010 -8185 1010 -8180 {}
L 2 1005 -8190 1005 -8130 {}
L 2 1115 -8110 1115 -8097.5 {}
L 2 1110 -8097.5 1120 -8097.5 {}
L 2 1115 -8092.5 1120 -8097.5 {}
L 2 1110 -8097.5 1115 -8092.5 {}
L 2 1115 -8390 1115 -8370 {}
L 2 1105 -8390 1125 -8390 {}
L 2 1080 -8220 1085 -8220 {}
L 2 1085 -8220 1205 -8220 {}
L 2 1245 -8280 1245 -8250 {}
L 2 1245 -8370 1245 -8340 {}
L 2 1335 -8190 1335 -8110 {}
L 2 1005 -8130 1005 -8110 {}
L 2 1005 -8370 1005 -8190 {}
L 2 1245 -8220 1245 -8110 {}
L 2 1245 -8110 1335 -8110 {}
L 2 1005 -8110 1245 -8110 {}
L 2 1850 -8370 1850 -8130 {}
L 2 1670 -8145 1730 -8145 {}
L 2 1720 -8145 1720 -8130 {}
L 2 1720 -8130 1730 -8130 {}
L 2 1680 -8145 1680 -8130 {}
L 2 1670 -8130 1680 -8130 {}
L 2 1685 -8155 1715 -8155 {}
L 2 1695 -8155 1700 -8155 {}
L 2 1700 -8170 1700 -8162.5 {}
L 2 1700 -8170 1700 -8155 {}
L 2 1700 -8140 1700 -8130 {}
L 2 1700 -8140 1705 -8145 {}
L 2 1695 -8145 1700 -8140 {}
L 2 1760 -8130 1770 -8130 {}
L 2 1770 -8130 1772.5 -8122.5 {}
L 2 1772.5 -8122.5 1777.5 -8137.5 {}
L 2 1777.5 -8137.5 1782.5 -8122.5 {}
L 2 1782.5 -8122.5 1787.5 -8137.5 {}
L 2 1787.5 -8137.5 1792.5 -8122.5 {}
L 2 1792.5 -8122.5 1797.5 -8137.5 {}
L 2 1797.5 -8137.5 1802.5 -8122.5 {}
L 2 1802.5 -8122.5 1807.5 -8137.5 {}
L 2 1807.5 -8137.5 1810 -8130 {}
L 2 1810 -8130 1820 -8130 {}
L 2 1812.5 -8127.5 1812.5 -8122.5 {}
L 2 1810 -8125 1815 -8125 {}
L 2 1670 -8040 1695 -8040 {}
L 2 1705 -8040 1730 -8040 {}
L 2 1705 -8050 1705 -8030 {}
L 2 1695 -8050 1695 -8030 {}
L 2 1722.5 -8037.5 1722.5 -8032.5 {}
L 2 1720 -8035 1725 -8035 {}
L 2 1662.5 -8367.5 1662.5 -8362.5 {}
L 2 1660 -8365 1665 -8365 {}
L 2 1610 -8370 1670 -8370 {}
L 2 1577.5 -8260 1590 -8260 {}
L 2 1577.5 -8265 1577.5 -8255 {}
L 2 1572.5 -8260 1577.5 -8255 {}
L 2 1572.5 -8260 1577.5 -8265 {}
L 2 1850 -8260 1870 -8260 {}
L 2 1870 -8270 1870 -8250 {}
L 2 1700 -8295 1700 -8290 {}
L 2 1700 -8290 1700 -8170 {}
L 2 1730 -8130 1760 -8130 {}
L 2 1820 -8130 1850 -8130 {}
L 2 1590 -8040 1670 -8040 {}
L 2 1590 -8370 1610 -8370 {}
L 2 1670 -8370 1850 -8370 {}
L 2 1590 -8130 1700 -8130 {}
L 2 1590 -8130 1590 -8040 {}
L 2 1590 -8370 1590 -8130 {}
L 2 530 -7940 770 -7940 {}
L 2 755 -7820 755 -7760 {}
L 2 755 -7810 770 -7810 {}
L 2 770 -7820 770 -7810 {}
L 2 755 -7770 770 -7770 {}
L 2 770 -7770 770 -7760 {}
L 2 745 -7805 745 -7775 {}
L 2 745 -7790 745 -7785 {}
L 2 730 -7790 737.5 -7790 {}
L 2 730 -7790 745 -7790 {}
L 2 760 -7790 770 -7790 {}
L 2 755 -7795 760 -7790 {}
L 2 755 -7785 760 -7790 {}
L 2 770 -7860 770 -7850 {}
L 2 770 -7860 777.5 -7862.5 {}
L 2 762.5 -7867.5 777.5 -7862.5 {}
L 2 762.5 -7867.5 777.5 -7872.5 {}
L 2 762.5 -7877.5 777.5 -7872.5 {}
L 2 762.5 -7877.5 777.5 -7882.5 {}
L 2 762.5 -7887.5 777.5 -7882.5 {}
L 2 762.5 -7887.5 777.5 -7892.5 {}
L 2 762.5 -7897.5 777.5 -7892.5 {}
L 2 762.5 -7897.5 770 -7900 {}
L 2 770 -7910 770 -7900 {}
L 2 772.5 -7902.5 777.5 -7902.5 {}
L 2 775 -7905 775 -7900 {}
L 2 860 -7785 860 -7760 {}
L 2 860 -7820 860 -7795 {}
L 2 850 -7795 870 -7795 {}
L 2 850 -7785 870 -7785 {}
L 2 862.5 -7812.5 867.5 -7812.5 {}
L 2 865 -7815 865 -7810 {}
L 2 532.5 -7752.5 537.5 -7752.5 {}
L 2 535 -7755 535 -7750 {}
L 2 530 -7760 530 -7700 {}
L 2 640 -7680 640 -7667.5 {}
L 2 635 -7667.5 645 -7667.5 {}
L 2 640 -7662.5 645 -7667.5 {}
L 2 635 -7667.5 640 -7662.5 {}
L 2 640 -7960 640 -7940 {}
L 2 630 -7960 650 -7960 {}
L 2 605 -7790 610 -7790 {}
L 2 610 -7790 730 -7790 {}
L 2 770 -7850 770 -7820 {}
L 2 770 -7940 770 -7910 {}
L 2 860 -7760 860 -7680 {}
L 2 530 -7700 530 -7680 {}
L 2 530 -7940 530 -7760 {}
L 2 770 -7790 770 -7680 {}
L 2 770 -7680 860 -7680 {}
L 2 530 -7680 770 -7680 {}
L 2 980 -7940 1220 -7940 {}
L 2 1205 -7820 1205 -7760 {}
L 2 1205 -7810 1220 -7810 {}
L 2 1220 -7820 1220 -7810 {}
L 2 1205 -7770 1220 -7770 {}
L 2 1220 -7770 1220 -7760 {}
L 2 1195 -7805 1195 -7775 {}
L 2 1195 -7790 1195 -7785 {}
L 2 1180 -7790 1187.5 -7790 {}
L 2 1180 -7790 1195 -7790 {}
L 2 1210 -7790 1220 -7790 {}
L 2 1205 -7795 1210 -7790 {}
L 2 1205 -7785 1210 -7790 {}
L 2 1220 -7860 1220 -7850 {}
L 2 1220 -7860 1227.5 -7862.5 {}
L 2 1212.5 -7867.5 1227.5 -7862.5 {}
L 2 1212.5 -7867.5 1227.5 -7872.5 {}
L 2 1212.5 -7877.5 1227.5 -7872.5 {}
L 2 1212.5 -7877.5 1227.5 -7882.5 {}
L 2 1212.5 -7887.5 1227.5 -7882.5 {}
L 2 1212.5 -7887.5 1227.5 -7892.5 {}
L 2 1212.5 -7897.5 1227.5 -7892.5 {}
L 2 1212.5 -7897.5 1220 -7900 {}
L 2 1220 -7910 1220 -7900 {}
L 2 1222.5 -7902.5 1227.5 -7902.5 {}
L 2 1225 -7905 1225 -7900 {}
L 2 1310 -7785 1310 -7760 {}
L 2 1310 -7820 1310 -7795 {}
L 2 1300 -7795 1320 -7795 {}
L 2 1300 -7785 1320 -7785 {}
L 2 1312.5 -7812.5 1317.5 -7812.5 {}
L 2 1315 -7815 1315 -7810 {}
L 2 982.5 -7752.5 987.5 -7752.5 {}
L 2 985 -7755 985 -7750 {}
L 2 980 -7760 980 -7700 {}
L 2 1090 -7680 1090 -7667.5 {}
L 2 1085 -7667.5 1095 -7667.5 {}
L 2 1090 -7662.5 1095 -7667.5 {}
L 2 1085 -7667.5 1090 -7662.5 {}
L 2 1090 -7960 1090 -7940 {}
L 2 1080 -7960 1100 -7960 {}
L 2 1055 -7790 1060 -7790 {}
L 2 1060 -7790 1180 -7790 {}
L 2 1220 -7850 1220 -7820 {}
L 2 1220 -7940 1220 -7910 {}
L 2 1310 -7760 1310 -7680 {}
L 2 980 -7700 980 -7680 {}
L 2 980 -7940 980 -7760 {}
L 2 1220 -7790 1220 -7680 {}
L 2 1220 -7680 1310 -7680 {}
L 2 980 -7680 1220 -7680 {}
L 2 1600 -7940 1840 -7940 {}
L 2 1615 -7820 1615 -7760 {}
L 2 1600 -7810 1615 -7810 {}
L 2 1600 -7820 1600 -7810 {}
L 2 1600 -7770 1615 -7770 {}
L 2 1600 -7770 1600 -7760 {}
L 2 1625 -7805 1625 -7775 {}
L 2 1625 -7790 1625 -7785 {}
L 2 1632.5 -7790 1640 -7790 {}
L 2 1625 -7790 1640 -7790 {}
L 2 1600 -7790 1610 -7790 {}
L 2 1610 -7790 1615 -7795 {}
L 2 1610 -7790 1615 -7785 {}
L 2 1600 -7860 1600 -7850 {}
L 2 1592.5 -7862.5 1600 -7860 {}
L 2 1592.5 -7862.5 1607.5 -7867.5 {}
L 2 1592.5 -7872.5 1607.5 -7867.5 {}
L 2 1592.5 -7872.5 1607.5 -7877.5 {}
L 2 1592.5 -7882.5 1607.5 -7877.5 {}
L 2 1592.5 -7882.5 1607.5 -7887.5 {}
L 2 1592.5 -7892.5 1607.5 -7887.5 {}
L 2 1592.5 -7892.5 1607.5 -7897.5 {}
L 2 1600 -7900 1607.5 -7897.5 {}
L 2 1600 -7910 1600 -7900 {}
L 2 1592.5 -7902.5 1597.5 -7902.5 {}
L 2 1595 -7905 1595 -7900 {}
L 2 1510 -7785 1510 -7760 {}
L 2 1510 -7820 1510 -7795 {}
L 2 1500 -7795 1520 -7795 {}
L 2 1500 -7785 1520 -7785 {}
L 2 1502.5 -7812.5 1507.5 -7812.5 {}
L 2 1505 -7815 1505 -7810 {}
L 2 1832.5 -7752.5 1837.5 -7752.5 {}
L 2 1835 -7755 1835 -7750 {}
L 2 1840 -7760 1840 -7700 {}
L 2 1730 -7680 1730 -7667.5 {}
L 2 1725 -7667.5 1735 -7667.5 {}
L 2 1725 -7667.5 1730 -7662.5 {}
L 2 1730 -7662.5 1735 -7667.5 {}
L 2 1730 -7960 1730 -7940 {}
L 2 1720 -7960 1740 -7960 {}
L 2 1760 -7790 1765 -7790 {}
L 2 1640 -7790 1760 -7790 {}
L 2 1600 -7850 1600 -7820 {}
L 2 1600 -7940 1600 -7910 {}
L 2 1510 -7760 1510 -7680 {}
L 2 1840 -7700 1840 -7680 {}
L 2 1840 -7940 1840 -7760 {}
L 2 1600 -7790 1600 -7680 {}
L 2 1510 -7680 1600 -7680 {}
L 2 1600 -7680 1840 -7680 {}
L 2 610 -7510 610 -7500 {}
L 2 610 -7510 617.5 -7512.5 {}
L 2 602.5 -7517.5 617.5 -7512.5 {}
L 2 602.5 -7517.5 617.5 -7522.5 {}
L 2 602.5 -7527.5 617.5 -7522.5 {}
L 2 602.5 -7527.5 617.5 -7532.5 {}
L 2 602.5 -7537.5 617.5 -7532.5 {}
L 2 602.5 -7537.5 617.5 -7542.5 {}
L 2 602.5 -7547.5 617.5 -7542.5 {}
L 2 602.5 -7547.5 610 -7550 {}
L 2 610 -7560 610 -7550 {}
L 2 612.5 -7552.5 617.5 -7552.5 {}
L 2 615 -7555 615 -7550 {}
L 2 610 -7395 610 -7370 {}
L 2 610 -7430 610 -7405 {}
L 2 600 -7405 620 -7405 {}
L 2 600 -7395 620 -7395 {}
L 2 612.5 -7422.5 617.5 -7422.5 {}
L 2 615 -7425 615 -7420 {}
L 2 610 -7270 610 -7260 {}
L 2 610 -7270 617.5 -7272.5 {}
L 2 602.5 -7277.5 617.5 -7272.5 {}
L 2 602.5 -7277.5 617.5 -7282.5 {}
L 2 602.5 -7287.5 617.5 -7282.5 {}
L 2 602.5 -7287.5 617.5 -7292.5 {}
L 2 602.5 -7297.5 617.5 -7292.5 {}
L 2 602.5 -7297.5 617.5 -7302.5 {}
L 2 602.5 -7307.5 617.5 -7302.5 {}
L 2 602.5 -7307.5 610 -7310 {}
L 2 610 -7320 610 -7310 {}
L 2 612.5 -7312.5 617.5 -7312.5 {}
L 2 615 -7315 615 -7310 {}
L 2 900 -7530 910 -7530 {}
L 2 910 -7530 912.5 -7522.5 {}
L 2 912.5 -7522.5 917.5 -7537.5 {}
L 2 917.5 -7537.5 922.5 -7522.5 {}
L 2 922.5 -7522.5 927.5 -7537.5 {}
L 2 927.5 -7537.5 932.5 -7522.5 {}
L 2 932.5 -7522.5 937.5 -7537.5 {}
L 2 937.5 -7537.5 942.5 -7522.5 {}
L 2 942.5 -7522.5 947.5 -7537.5 {}
L 2 947.5 -7537.5 950 -7530 {}
L 2 950 -7530 960 -7530 {}
L 2 952.5 -7527.5 952.5 -7522.5 {}
L 2 950 -7525 955 -7525 {}
L 2 900 -7400 925 -7400 {}
L 2 935 -7400 960 -7400 {}
L 2 935 -7410 935 -7390 {}
L 2 925 -7410 925 -7390 {}
L 2 952.5 -7397.5 952.5 -7392.5 {}
L 2 950 -7395 955 -7395 {}
L 2 900 -7290 910 -7290 {}
L 2 910 -7290 912.5 -7282.5 {}
L 2 912.5 -7282.5 917.5 -7297.5 {}
L 2 917.5 -7297.5 922.5 -7282.5 {}
L 2 922.5 -7282.5 927.5 -7297.5 {}
L 2 927.5 -7297.5 932.5 -7282.5 {}
L 2 932.5 -7282.5 937.5 -7297.5 {}
L 2 937.5 -7297.5 942.5 -7282.5 {}
L 2 942.5 -7282.5 947.5 -7297.5 {}
L 2 947.5 -7297.5 950 -7290 {}
L 2 950 -7290 960 -7290 {}
L 2 952.5 -7287.5 952.5 -7282.5 {}
L 2 950 -7285 955 -7285 {}
L 2 2360 -8940 2420 -8940 {}
L 2 2420 -9110 2420 -9000 {}
L 2 1440 -1030 1510 -1030 {}
L 2 1440 -1010 1510 -1010 {}
L 2 1440 -990 1510 -990 {}
L 2 1440 -970 1510 -970 {}
L 2 2200 -1030 2290 -1030 {}
L 2 960 -1040 1080 -1040 {}
L 2 960 -960 1080 -960 {}
L 2 960 -1040 960 -960 {}
L 2 1080 -1040 1080 -960 {}
L 2 1080 -1030 1100 -1030 {}
L 2 940 -1030 960 -1030 {}
L 2 940 -1010 960 -1010 {}
L 2 940 -990 960 -990 {}
L 2 940 -970 960 -970 {}
L 2 540 -1040 660 -1040 {}
L 2 540 -960 660 -960 {}
L 2 540 -1040 540 -960 {}
L 2 660 -1040 660 -960 {}
L 2 660 -1030 680 -1030 {}
L 2 520 -1030 540 -1030 {}
L 2 520 -1010 540 -1010 {}
L 2 520 -990 540 -990 {}
L 2 520 -970 540 -970 {}
L 2 950 -80 950 -50 {}
L 2 935 -390 935 -330 {}
L 2 935 -340 950 -340 {}
L 2 950 -340 950 -330 {}
L 2 935 -380 950 -380 {}
L 2 950 -390 950 -380 {}
L 2 925 -375 925 -345 {}
L 2 925 -365 925 -360 {}
L 2 922.5 -365 925 -362.5 {}
L 2 920 -365 922.5 -365 {}
L 2 917.5 -362.5 920 -365 {}
L 2 917.5 -362.5 917.5 -357.5 {}
L 2 917.5 -357.5 920 -355 {}
L 2 920 -355 922.5 -355 {}
L 2 922.5 -355 925 -357.5 {}
L 2 910 -360 917.5 -360 {}
L 2 940 -360 950 -360 {}
L 2 935 -365 940 -360 {}
L 2 935 -355 940 -360 {}
L 2 1065 -390 1065 -330 {}
L 2 1065 -340 1080 -340 {}
L 2 1080 -340 1080 -330 {}
L 2 1065 -380 1080 -380 {}
L 2 1080 -390 1080 -380 {}
L 2 1055 -375 1055 -345 {}
L 2 1055 -365 1055 -360 {}
L 2 1052.5 -365 1055 -362.5 {}
L 2 1050 -365 1052.5 -365 {}
L 2 1047.5 -362.5 1050 -365 {}
L 2 1047.5 -362.5 1047.5 -357.5 {}
L 2 1047.5 -357.5 1050 -355 {}
L 2 1050 -355 1052.5 -355 {}
L 2 1052.5 -355 1055 -357.5 {}
L 2 1040 -360 1047.5 -360 {}
L 2 1070 -360 1080 -360 {}
L 2 1065 -365 1070 -360 {}
L 2 1065 -355 1070 -360 {}
L 2 935 -190 935 -130 {}
L 2 935 -180 950 -180 {}
L 2 950 -190 950 -180 {}
L 2 935 -140 950 -140 {}
L 2 950 -140 950 -130 {}
L 2 925 -175 925 -145 {}
L 2 925 -160 925 -155 {}
L 2 910 -160 917.5 -160 {}
L 2 910 -160 925 -160 {}
L 2 940 -160 950 -160 {}
L 2 935 -165 940 -160 {}
L 2 935 -155 940 -160 {}
L 2 935 -110 935 -50 {}
L 2 935 -100 950 -100 {}
L 2 950 -110 950 -100 {}
L 2 935 -60 950 -60 {}
L 2 950 -60 950 -50 {}
L 2 925 -95 925 -65 {}
L 2 925 -80 925 -75 {}
L 2 910 -80 917.5 -80 {}
L 2 910 -80 925 -80 {}
L 2 940 -80 950 -80 {}
L 2 935 -85 940 -80 {}
L 2 935 -75 940 -80 {}
L 4 1032.5 -10992.5 1037.5 -10992.5 {}
L 4 1035 -10995 1035 -10990 {}
L 4 1030 -11000 1030 -10940 {}
L 4 1140 -10920 1140 -10907.5 {}
L 4 1135 -10907.5 1145 -10907.5 {}
L 4 1140 -10902.5 1145 -10907.5 {}
L 4 1135 -10907.5 1140 -10902.5 {}
L 4 1140 -11200 1140 -11180 {}
L 4 1130 -11200 1150 -11200 {}
L 4 1572.5 -10992.5 1577.5 -10992.5 {}
L 4 1575 -10995 1575 -10990 {}
L 4 1570 -11000 1570 -10940 {}
L 4 1680 -10920 1680 -10907.5 {}
L 4 1675 -10907.5 1685 -10907.5 {}
L 4 1680 -10902.5 1685 -10907.5 {}
L 4 1675 -10907.5 1680 -10902.5 {}
L 4 1680 -11200 1680 -11180 {}
L 4 1670 -11200 1690 -11200 {}
L 4 502.5 -10992.5 507.5 -10992.5 {}
L 4 505 -10995 505 -10990 {}
L 4 500 -11000 500 -10940 {}
L 4 610 -10920 610 -10907.5 {}
L 4 605 -10907.5 615 -10907.5 {}
L 4 610 -10902.5 615 -10907.5 {}
L 4 605 -10907.5 610 -10902.5 {}
L 4 610 -11200 610 -11180 {}
L 4 600 -11200 620 -11200 {}
L 4 725 -10600 725 -10540 {}
L 4 725 -10590 740 -10590 {}
L 4 740 -10600 740 -10590 {}
L 4 725 -10550 740 -10550 {}
L 4 740 -10550 740 -10540 {}
L 4 715 -10585 715 -10555 {}
L 4 715 -10570 715 -10565 {}
L 4 700 -10570 707.5 -10570 {}
L 4 700 -10570 715 -10570 {}
L 4 730 -10570 740 -10570 {}
L 4 725 -10575 730 -10570 {}
L 4 725 -10565 730 -10570 {}
L 4 740 -10640 740 -10630 {}
L 4 740 -10640 747.5 -10642.5 {}
L 4 732.5 -10647.5 747.5 -10642.5 {}
L 4 732.5 -10647.5 747.5 -10652.5 {}
L 4 732.5 -10657.5 747.5 -10652.5 {}
L 4 732.5 -10657.5 747.5 -10662.5 {}
L 4 732.5 -10667.5 747.5 -10662.5 {}
L 4 732.5 -10667.5 747.5 -10672.5 {}
L 4 732.5 -10677.5 747.5 -10672.5 {}
L 4 732.5 -10677.5 740 -10680 {}
L 4 740 -10690 740 -10680 {}
L 4 742.5 -10682.5 747.5 -10682.5 {}
L 4 745 -10685 745 -10680 {}
L 4 830 -10565 830 -10540 {}
L 4 830 -10600 830 -10575 {}
L 4 820 -10575 840 -10575 {}
L 4 820 -10565 840 -10565 {}
L 4 832.5 -10592.5 837.5 -10592.5 {}
L 4 835 -10595 835 -10590 {}
L 4 502.5 -10532.5 507.5 -10532.5 {}
L 4 505 -10535 505 -10530 {}
L 4 500 -10540 500 -10480 {}
L 4 610 -10460 610 -10447.5 {}
L 4 605 -10447.5 615 -10447.5 {}
L 4 610 -10442.5 615 -10447.5 {}
L 4 605 -10447.5 610 -10442.5 {}
L 4 610 -10740 610 -10720 {}
L 4 600 -10740 620 -10740 {}
L 4 1265 -10600 1265 -10540 {}
L 4 1265 -10590 1280 -10590 {}
L 4 1280 -10600 1280 -10590 {}
L 4 1265 -10550 1280 -10550 {}
L 4 1280 -10550 1280 -10540 {}
L 4 1255 -10585 1255 -10555 {}
L 4 1255 -10570 1255 -10565 {}
L 4 1240 -10570 1247.5 -10570 {}
L 4 1240 -10570 1255 -10570 {}
L 4 1270 -10570 1280 -10570 {}
L 4 1265 -10575 1270 -10570 {}
L 4 1265 -10565 1270 -10570 {}
L 4 1370 -10565 1370 -10540 {}
L 4 1370 -10600 1370 -10575 {}
L 4 1360 -10575 1380 -10575 {}
L 4 1360 -10565 1380 -10565 {}
L 4 1372.5 -10592.5 1377.5 -10592.5 {}
L 4 1375 -10595 1375 -10590 {}
L 4 1042.5 -10532.5 1047.5 -10532.5 {}
L 4 1045 -10535 1045 -10530 {}
L 4 1040 -10540 1040 -10480 {}
L 4 1150 -10460 1150 -10447.5 {}
L 4 1145 -10447.5 1155 -10447.5 {}
L 4 1150 -10442.5 1155 -10447.5 {}
L 4 1145 -10447.5 1150 -10442.5 {}
L 4 1150 -10740 1150 -10720 {}
L 4 1140 -10740 1160 -10740 {}
L 4 725 -7010 725 -6950 {}
L 4 725 -7000 740 -7000 {}
L 4 740 -7010 740 -7000 {}
L 4 725 -6960 740 -6960 {}
L 4 740 -6960 740 -6950 {}
L 4 715 -6995 715 -6965 {}
L 4 715 -6980 715 -6975 {}
L 4 700 -6980 707.5 -6980 {}
L 4 700 -6980 715 -6980 {}
L 4 730 -6980 740 -6980 {}
L 4 725 -6985 730 -6980 {}
L 4 725 -6975 730 -6980 {}
L 4 740 -7050 740 -7040 {}
L 4 740 -7050 747.5 -7052.5 {}
L 4 732.5 -7057.5 747.5 -7052.5 {}
L 4 732.5 -7057.5 747.5 -7062.5 {}
L 4 732.5 -7067.5 747.5 -7062.5 {}
L 4 732.5 -7067.5 747.5 -7072.5 {}
L 4 732.5 -7077.5 747.5 -7072.5 {}
L 4 732.5 -7077.5 747.5 -7082.5 {}
L 4 732.5 -7087.5 747.5 -7082.5 {}
L 4 732.5 -7087.5 740 -7090 {}
L 4 740 -7100 740 -7090 {}
L 4 742.5 -7092.5 747.5 -7092.5 {}
L 4 745 -7095 745 -7090 {}
L 4 830 -6975 830 -6950 {}
L 4 830 -7010 830 -6985 {}
L 4 820 -6985 840 -6985 {}
L 4 820 -6975 840 -6975 {}
L 4 832.5 -7002.5 837.5 -7002.5 {}
L 4 835 -7005 835 -7000 {}
L 4 502.5 -6942.5 507.5 -6942.5 {}
L 4 505 -6945 505 -6940 {}
L 4 500 -6950 500 -6890 {}
L 4 610 -6870 610 -6857.5 {}
L 4 605 -6857.5 615 -6857.5 {}
L 4 610 -6852.5 615 -6857.5 {}
L 4 605 -6857.5 610 -6852.5 {}
L 4 610 -7150 610 -7130 {}
L 4 600 -7150 620 -7150 {}
L 4 1265 -7010 1265 -6950 {}
L 4 1265 -7000 1280 -7000 {}
L 4 1280 -7010 1280 -7000 {}
L 4 1265 -6960 1280 -6960 {}
L 4 1280 -6960 1280 -6950 {}
L 4 1255 -6995 1255 -6965 {}
L 4 1255 -6980 1255 -6975 {}
L 4 1240 -6980 1247.5 -6980 {}
L 4 1240 -6980 1255 -6980 {}
L 4 1270 -6980 1280 -6980 {}
L 4 1265 -6985 1270 -6980 {}
L 4 1265 -6975 1270 -6980 {}
L 4 1370 -6975 1370 -6950 {}
L 4 1370 -7010 1370 -6985 {}
L 4 1360 -6985 1380 -6985 {}
L 4 1360 -6975 1380 -6975 {}
L 4 1372.5 -7002.5 1377.5 -7002.5 {}
L 4 1375 -7005 1375 -7000 {}
L 4 1042.5 -6942.5 1047.5 -6942.5 {}
L 4 1045 -6945 1045 -6940 {}
L 4 1040 -6950 1040 -6890 {}
L 4 1150 -6870 1150 -6857.5 {}
L 4 1145 -6857.5 1155 -6857.5 {}
L 4 1150 -6852.5 1155 -6857.5 {}
L 4 1145 -6857.5 1150 -6852.5 {}
L 4 1150 -7150 1150 -7130 {}
L 4 1140 -7150 1160 -7150 {}
L 4 725 -6610 725 -6550 {}
L 4 725 -6600 740 -6600 {}
L 4 740 -6610 740 -6600 {}
L 4 725 -6560 740 -6560 {}
L 4 740 -6560 740 -6550 {}
L 4 715 -6595 715 -6565 {}
L 4 715 -6580 715 -6575 {}
L 4 700 -6580 707.5 -6580 {}
L 4 700 -6580 715 -6580 {}
L 4 730 -6580 740 -6580 {}
L 4 725 -6585 730 -6580 {}
L 4 725 -6575 730 -6580 {}
L 4 740 -6650 740 -6640 {}
L 4 740 -6650 747.5 -6652.5 {}
L 4 732.5 -6657.5 747.5 -6652.5 {}
L 4 732.5 -6657.5 747.5 -6662.5 {}
L 4 732.5 -6667.5 747.5 -6662.5 {}
L 4 732.5 -6667.5 747.5 -6672.5 {}
L 4 732.5 -6677.5 747.5 -6672.5 {}
L 4 732.5 -6677.5 747.5 -6682.5 {}
L 4 732.5 -6687.5 747.5 -6682.5 {}
L 4 732.5 -6687.5 740 -6690 {}
L 4 740 -6700 740 -6690 {}
L 4 742.5 -6692.5 747.5 -6692.5 {}
L 4 745 -6695 745 -6690 {}
L 4 830 -6575 830 -6550 {}
L 4 830 -6610 830 -6585 {}
L 4 820 -6585 840 -6585 {}
L 4 820 -6575 840 -6575 {}
L 4 832.5 -6602.5 837.5 -6602.5 {}
L 4 835 -6605 835 -6600 {}
L 4 502.5 -6542.5 507.5 -6542.5 {}
L 4 505 -6545 505 -6540 {}
L 4 500 -6550 500 -6490 {}
L 4 610 -6470 610 -6457.5 {}
L 4 605 -6457.5 615 -6457.5 {}
L 4 610 -6452.5 615 -6457.5 {}
L 4 605 -6457.5 610 -6452.5 {}
L 4 610 -6750 610 -6730 {}
L 4 600 -6750 620 -6750 {}
L 4 1265 -6610 1265 -6550 {}
L 4 1265 -6600 1280 -6600 {}
L 4 1280 -6610 1280 -6600 {}
L 4 1265 -6560 1280 -6560 {}
L 4 1280 -6560 1280 -6550 {}
L 4 1255 -6595 1255 -6565 {}
L 4 1255 -6580 1255 -6575 {}
L 4 1240 -6580 1247.5 -6580 {}
L 4 1240 -6580 1255 -6580 {}
L 4 1270 -6580 1280 -6580 {}
L 4 1265 -6585 1270 -6580 {}
L 4 1265 -6575 1270 -6580 {}
L 4 1370 -6575 1370 -6550 {}
L 4 1370 -6610 1370 -6585 {}
L 4 1360 -6585 1380 -6585 {}
L 4 1360 -6575 1380 -6575 {}
L 4 1372.5 -6602.5 1377.5 -6602.5 {}
L 4 1375 -6605 1375 -6600 {}
L 4 1042.5 -6542.5 1047.5 -6542.5 {}
L 4 1045 -6545 1045 -6540 {}
L 4 1040 -6550 1040 -6490 {}
L 4 1150 -6470 1150 -6457.5 {}
L 4 1145 -6457.5 1155 -6457.5 {}
L 4 1150 -6452.5 1155 -6457.5 {}
L 4 1145 -6457.5 1150 -6452.5 {}
L 4 1150 -6750 1150 -6730 {}
L 4 1140 -6750 1160 -6750 {}
L 4 502.5 -6102.5 507.5 -6102.5 {}
L 4 505 -6105 505 -6100 {}
L 4 500 -6110 500 -6050 {}
L 4 610 -6030 610 -6017.5 {}
L 4 605 -6017.5 615 -6017.5 {}
L 4 610 -6012.5 615 -6017.5 {}
L 4 605 -6017.5 610 -6012.5 {}
L 4 610 -6310 610 -6290 {}
L 4 600 -6310 620 -6310 {}
L 4 1692.5 -6102.5 1697.5 -6102.5 {}
L 4 1695 -6105 1695 -6100 {}
L 4 1690 -6110 1690 -6050 {}
L 4 1800 -6030 1800 -6017.5 {}
L 4 1795 -6017.5 1805 -6017.5 {}
L 4 1800 -6012.5 1805 -6017.5 {}
L 4 1795 -6017.5 1800 -6012.5 {}
L 4 1800 -6310 1800 -6290 {}
L 4 1790 -6310 1810 -6310 {}
L 4 1062.5 -6102.5 1067.5 -6102.5 {}
L 4 1065 -6105 1065 -6100 {}
L 4 1060 -6110 1060 -6050 {}
L 4 1170 -6030 1170 -6017.5 {}
L 4 1165 -6017.5 1175 -6017.5 {}
L 4 1170 -6012.5 1175 -6017.5 {}
L 4 1165 -6017.5 1170 -6012.5 {}
L 4 1170 -6310 1170 -6290 {}
L 4 1160 -6310 1180 -6310 {}
L 4 1032.5 -10162.5 1037.5 -10162.5 {}
L 4 1035 -10165 1035 -10160 {}
L 4 1030 -10170 1030 -10110 {}
L 4 1140 -10090 1140 -10077.5 {}
L 4 1135 -10077.5 1145 -10077.5 {}
L 4 1140 -10072.5 1145 -10077.5 {}
L 4 1135 -10077.5 1140 -10072.5 {}
L 4 1140 -10370 1140 -10350 {}
L 4 1130 -10370 1150 -10370 {}
L 4 502.5 -10162.5 507.5 -10162.5 {}
L 4 505 -10165 505 -10160 {}
L 4 500 -10170 500 -10110 {}
L 4 610 -10090 610 -10077.5 {}
L 4 605 -10077.5 615 -10077.5 {}
L 4 610 -10072.5 615 -10077.5 {}
L 4 605 -10077.5 610 -10072.5 {}
L 4 610 -10370 610 -10350 {}
L 4 600 -10370 620 -10370 {}
L 4 1755 -10230 1755 -10170 {}
L 4 1755 -10220 1770 -10220 {}
L 4 1770 -10230 1770 -10220 {}
L 4 1755 -10180 1770 -10180 {}
L 4 1770 -10180 1770 -10170 {}
L 4 1745 -10215 1745 -10185 {}
L 4 1745 -10200 1745 -10195 {}
L 4 1730 -10200 1737.5 -10200 {}
L 4 1730 -10200 1745 -10200 {}
L 4 1760 -10200 1770 -10200 {}
L 4 1755 -10205 1760 -10200 {}
L 4 1755 -10195 1760 -10200 {}
L 4 1770 -10270 1770 -10260 {}
L 4 1770 -10270 1777.5 -10272.5 {}
L 4 1762.5 -10277.5 1777.5 -10272.5 {}
L 4 1762.5 -10277.5 1777.5 -10282.5 {}
L 4 1762.5 -10287.5 1777.5 -10282.5 {}
L 4 1762.5 -10287.5 1777.5 -10292.5 {}
L 4 1762.5 -10297.5 1777.5 -10292.5 {}
L 4 1762.5 -10297.5 1777.5 -10302.5 {}
L 4 1762.5 -10307.5 1777.5 -10302.5 {}
L 4 1762.5 -10307.5 1770 -10310 {}
L 4 1770 -10320 1770 -10310 {}
L 4 1772.5 -10312.5 1777.5 -10312.5 {}
L 4 1775 -10315 1775 -10310 {}
L 4 1860 -10195 1860 -10170 {}
L 4 1860 -10230 1860 -10205 {}
L 4 1850 -10205 1870 -10205 {}
L 4 1850 -10195 1870 -10195 {}
L 4 1862.5 -10222.5 1867.5 -10222.5 {}
L 4 1865 -10225 1865 -10220 {}
L 4 1532.5 -10162.5 1537.5 -10162.5 {}
L 4 1535 -10165 1535 -10160 {}
L 4 1530 -10170 1530 -10110 {}
L 4 1640 -10090 1640 -10077.5 {}
L 4 1635 -10077.5 1645 -10077.5 {}
L 4 1640 -10072.5 1645 -10077.5 {}
L 4 1635 -10077.5 1640 -10072.5 {}
L 4 1640 -10370 1640 -10350 {}
L 4 1630 -10370 1650 -10370 {}
L 4 1680 -11390 1680 -11377.5 {}
L 4 1675 -11377.5 1685 -11377.5 {}
L 4 1680 -11372.5 1685 -11377.5 {}
L 4 1675 -11377.5 1680 -11372.5 {}
L 4 1680 -11670 1680 -11650 {}
L 4 1670 -11670 1690 -11670 {}
L 4 447.5 -11462.5 452.5 -11462.5 {}
L 4 450 -11465 450 -11460 {}
L 4 445 -11470 445 -11410 {}
L 4 555 -11390 555 -11377.5 {}
L 4 550 -11377.5 560 -11377.5 {}
L 4 555 -11372.5 560 -11377.5 {}
L 4 550 -11377.5 555 -11372.5 {}
L 4 555 -11670 555 -11650 {}
L 4 545 -11670 565 -11670 {}
L 4 2140 -11390 2140 -11377.5 {}
L 4 2135 -11377.5 2145 -11377.5 {}
L 4 2140 -11372.5 2145 -11377.5 {}
L 4 2135 -11377.5 2140 -11372.5 {}
L 4 2140 -11670 2140 -11650 {}
L 4 2130 -11670 2150 -11670 {}
L 4 2360 -11495 2360 -11470 {}
L 4 2360 -11530 2360 -11505 {}
L 4 2350 -11505 2370 -11505 {}
L 4 2350 -11495 2370 -11495 {}
L 4 2362.5 -11522.5 2367.5 -11522.5 {}
L 4 2365 -11525 2365 -11520 {}
L 4 745 -9390 745 -9330 {}
L 4 745 -9380 760 -9380 {}
L 4 760 -9390 760 -9380 {}
L 4 745 -9340 760 -9340 {}
L 4 760 -9340 760 -9330 {}
L 4 735 -9375 735 -9345 {}
L 4 735 -9360 735 -9355 {}
L 4 720 -9360 727.5 -9360 {}
L 4 720 -9360 735 -9360 {}
L 4 750 -9360 760 -9360 {}
L 4 745 -9365 750 -9360 {}
L 4 745 -9355 750 -9360 {}
L 4 760 -9430 760 -9420 {}
L 4 760 -9430 767.5 -9432.5 {}
L 4 752.5 -9437.5 767.5 -9432.5 {}
L 4 752.5 -9437.5 767.5 -9442.5 {}
L 4 752.5 -9447.5 767.5 -9442.5 {}
L 4 752.5 -9447.5 767.5 -9452.5 {}
L 4 752.5 -9457.5 767.5 -9452.5 {}
L 4 752.5 -9457.5 767.5 -9462.5 {}
L 4 752.5 -9467.5 767.5 -9462.5 {}
L 4 752.5 -9467.5 760 -9470 {}
L 4 760 -9480 760 -9470 {}
L 4 762.5 -9472.5 767.5 -9472.5 {}
L 4 765 -9475 765 -9470 {}
L 4 850 -9355 850 -9330 {}
L 4 850 -9390 850 -9365 {}
L 4 840 -9365 860 -9365 {}
L 4 840 -9355 860 -9355 {}
L 4 852.5 -9382.5 857.5 -9382.5 {}
L 4 855 -9385 855 -9380 {}
L 4 522.5 -9322.5 527.5 -9322.5 {}
L 4 525 -9325 525 -9320 {}
L 4 520 -9330 520 -9270 {}
L 4 630 -9250 630 -9237.5 {}
L 4 625 -9237.5 635 -9237.5 {}
L 4 630 -9232.5 635 -9237.5 {}
L 4 625 -9237.5 630 -9232.5 {}
L 4 630 -9530 630 -9510 {}
L 4 620 -9530 640 -9530 {}
L 4 1285 -9390 1285 -9330 {}
L 4 1285 -9380 1300 -9380 {}
L 4 1300 -9390 1300 -9380 {}
L 4 1285 -9340 1300 -9340 {}
L 4 1300 -9340 1300 -9330 {}
L 4 1275 -9375 1275 -9345 {}
L 4 1275 -9360 1275 -9355 {}
L 4 1260 -9360 1267.5 -9360 {}
L 4 1260 -9360 1275 -9360 {}
L 4 1290 -9360 1300 -9360 {}
L 4 1285 -9365 1290 -9360 {}
L 4 1285 -9355 1290 -9360 {}
L 4 1300 -9430 1300 -9420 {}
L 4 1300 -9430 1307.5 -9432.5 {}
L 4 1292.5 -9437.5 1307.5 -9432.5 {}
L 4 1292.5 -9437.5 1307.5 -9442.5 {}
L 4 1292.5 -9447.5 1307.5 -9442.5 {}
L 4 1292.5 -9447.5 1307.5 -9452.5 {}
L 4 1292.5 -9457.5 1307.5 -9452.5 {}
L 4 1292.5 -9457.5 1307.5 -9462.5 {}
L 4 1292.5 -9467.5 1307.5 -9462.5 {}
L 4 1292.5 -9467.5 1300 -9470 {}
L 4 1300 -9480 1300 -9470 {}
L 4 1302.5 -9472.5 1307.5 -9472.5 {}
L 4 1305 -9475 1305 -9470 {}
L 4 1390 -9355 1390 -9330 {}
L 4 1390 -9390 1390 -9365 {}
L 4 1380 -9365 1400 -9365 {}
L 4 1380 -9355 1400 -9355 {}
L 4 1392.5 -9382.5 1397.5 -9382.5 {}
L 4 1395 -9385 1395 -9380 {}
L 4 1062.5 -9322.5 1067.5 -9322.5 {}
L 4 1065 -9325 1065 -9320 {}
L 4 1060 -9330 1060 -9270 {}
L 4 1170 -9250 1170 -9237.5 {}
L 4 1165 -9237.5 1175 -9237.5 {}
L 4 1170 -9232.5 1175 -9237.5 {}
L 4 1165 -9237.5 1170 -9232.5 {}
L 4 1170 -9530 1170 -9510 {}
L 4 1160 -9530 1180 -9530 {}
L 4 2415 -9390 2415 -9330 {}
L 4 2415 -9380 2430 -9380 {}
L 4 2430 -9390 2430 -9380 {}
L 4 2415 -9340 2430 -9340 {}
L 4 2430 -9340 2430 -9330 {}
L 4 2405 -9375 2405 -9345 {}
L 4 2405 -9360 2405 -9355 {}
L 4 2390 -9360 2397.5 -9360 {}
L 4 2390 -9360 2405 -9360 {}
L 4 2420 -9360 2430 -9360 {}
L 4 2415 -9365 2420 -9360 {}
L 4 2415 -9355 2420 -9360 {}
L 4 2430 -9430 2430 -9420 {}
L 4 2430 -9430 2437.5 -9432.5 {}
L 4 2422.5 -9437.5 2437.5 -9432.5 {}
L 4 2422.5 -9437.5 2437.5 -9442.5 {}
L 4 2422.5 -9447.5 2437.5 -9442.5 {}
L 4 2422.5 -9447.5 2437.5 -9452.5 {}
L 4 2422.5 -9457.5 2437.5 -9452.5 {}
L 4 2422.5 -9457.5 2437.5 -9462.5 {}
L 4 2422.5 -9467.5 2437.5 -9462.5 {}
L 4 2422.5 -9467.5 2430 -9470 {}
L 4 2430 -9480 2430 -9470 {}
L 4 2432.5 -9472.5 2437.5 -9472.5 {}
L 4 2435 -9475 2435 -9470 {}
L 4 2520 -9355 2520 -9330 {}
L 4 2520 -9390 2520 -9365 {}
L 4 2510 -9365 2530 -9365 {}
L 4 2510 -9355 2530 -9355 {}
L 4 2522.5 -9382.5 2527.5 -9382.5 {}
L 4 2525 -9385 2525 -9380 {}
L 4 2192.5 -9322.5 2197.5 -9322.5 {}
L 4 2195 -9325 2195 -9320 {}
L 4 2190 -9330 2190 -9270 {}
L 4 2300 -9250 2300 -9237.5 {}
L 4 2295 -9237.5 2305 -9237.5 {}
L 4 2300 -9232.5 2305 -9237.5 {}
L 4 2295 -9237.5 2300 -9232.5 {}
L 4 2300 -9530 2300 -9510 {}
L 4 2290 -9530 2310 -9530 {}
L 4 820 -5250 820 -5240 {}
L 4 820 -5250 827.5 -5252.5 {}
L 4 812.5 -5257.5 827.5 -5252.5 {}
L 4 812.5 -5257.5 827.5 -5262.5 {}
L 4 812.5 -5267.5 827.5 -5262.5 {}
L 4 812.5 -5267.5 827.5 -5272.5 {}
L 4 812.5 -5277.5 827.5 -5272.5 {}
L 4 812.5 -5277.5 827.5 -5282.5 {}
L 4 812.5 -5287.5 827.5 -5282.5 {}
L 4 812.5 -5287.5 820 -5290 {}
L 4 820 -5300 820 -5290 {}
L 4 822.5 -5292.5 827.5 -5292.5 {}
L 4 825 -5295 825 -5290 {}
L 4 820 -5190 820 -5180 {}
L 4 820 -5190 827.5 -5192.5 {}
L 4 812.5 -5197.5 827.5 -5192.5 {}
L 4 812.5 -5197.5 827.5 -5202.5 {}
L 4 812.5 -5207.5 827.5 -5202.5 {}
L 4 812.5 -5207.5 827.5 -5212.5 {}
L 4 812.5 -5217.5 827.5 -5212.5 {}
L 4 812.5 -5217.5 827.5 -5222.5 {}
L 4 812.5 -5227.5 827.5 -5222.5 {}
L 4 812.5 -5227.5 820 -5230 {}
L 4 820 -5240 820 -5230 {}
L 4 822.5 -5232.5 827.5 -5232.5 {}
L 4 825 -5235 825 -5230 {}
L 4 1360 -5190 1360 -5180 {}
L 4 1360 -5190 1367.5 -5192.5 {}
L 4 1352.5 -5197.5 1367.5 -5192.5 {}
L 4 1352.5 -5197.5 1367.5 -5202.5 {}
L 4 1352.5 -5207.5 1367.5 -5202.5 {}
L 4 1352.5 -5207.5 1367.5 -5212.5 {}
L 4 1352.5 -5217.5 1367.5 -5212.5 {}
L 4 1352.5 -5217.5 1367.5 -5222.5 {}
L 4 1352.5 -5227.5 1367.5 -5222.5 {}
L 4 1352.5 -5227.5 1360 -5230 {}
L 4 1360 -5240 1360 -5230 {}
L 4 1362.5 -5232.5 1367.5 -5232.5 {}
L 4 1365 -5235 1365 -5230 {}
L 4 1900 -5290 1900 -5280 {}
L 4 1900 -5290 1907.5 -5292.5 {}
L 4 1892.5 -5297.5 1907.5 -5292.5 {}
L 4 1892.5 -5297.5 1907.5 -5302.5 {}
L 4 1892.5 -5307.5 1907.5 -5302.5 {}
L 4 1892.5 -5307.5 1907.5 -5312.5 {}
L 4 1892.5 -5317.5 1907.5 -5312.5 {}
L 4 1892.5 -5317.5 1907.5 -5322.5 {}
L 4 1892.5 -5327.5 1907.5 -5322.5 {}
L 4 1892.5 -5327.5 1900 -5330 {}
L 4 1900 -5340 1900 -5330 {}
L 4 1902.5 -5332.5 1907.5 -5332.5 {}
L 4 1905 -5335 1905 -5330 {}
L 4 1900 -5190 1900 -5180 {}
L 4 1900 -5190 1907.5 -5192.5 {}
L 4 1892.5 -5197.5 1907.5 -5192.5 {}
L 4 1892.5 -5197.5 1907.5 -5202.5 {}
L 4 1892.5 -5207.5 1907.5 -5202.5 {}
L 4 1892.5 -5207.5 1907.5 -5212.5 {}
L 4 1892.5 -5217.5 1907.5 -5212.5 {}
L 4 1892.5 -5217.5 1907.5 -5222.5 {}
L 4 1892.5 -5227.5 1907.5 -5222.5 {}
L 4 1892.5 -5227.5 1900 -5230 {}
L 4 1900 -5240 1900 -5230 {}
L 4 1902.5 -5232.5 1907.5 -5232.5 {}
L 4 1905 -5235 1905 -5230 {}
L 4 710 -4420 710 -4410 {}
L 4 710 -4420 717.5 -4422.5 {}
L 4 702.5 -4427.5 717.5 -4422.5 {}
L 4 702.5 -4427.5 717.5 -4432.5 {}
L 4 702.5 -4437.5 717.5 -4432.5 {}
L 4 702.5 -4437.5 717.5 -4442.5 {}
L 4 702.5 -4447.5 717.5 -4442.5 {}
L 4 702.5 -4447.5 717.5 -4452.5 {}
L 4 702.5 -4457.5 717.5 -4452.5 {}
L 4 702.5 -4457.5 710 -4460 {}
L 4 710 -4470 710 -4460 {}
L 4 712.5 -4462.5 717.5 -4462.5 {}
L 4 715 -4465 715 -4460 {}
L 4 820 -4420 820 -4410 {}
L 4 820 -4420 827.5 -4422.5 {}
L 4 812.5 -4427.5 827.5 -4422.5 {}
L 4 812.5 -4427.5 827.5 -4432.5 {}
L 4 812.5 -4437.5 827.5 -4432.5 {}
L 4 812.5 -4437.5 827.5 -4442.5 {}
L 4 812.5 -4447.5 827.5 -4442.5 {}
L 4 812.5 -4447.5 827.5 -4452.5 {}
L 4 812.5 -4457.5 827.5 -4452.5 {}
L 4 812.5 -4457.5 820 -4460 {}
L 4 820 -4470 820 -4460 {}
L 4 822.5 -4462.5 827.5 -4462.5 {}
L 4 825 -4465 825 -4460 {}
L 4 930 -4420 930 -4410 {}
L 4 930 -4420 937.5 -4422.5 {}
L 4 922.5 -4427.5 937.5 -4422.5 {}
L 4 922.5 -4427.5 937.5 -4432.5 {}
L 4 922.5 -4437.5 937.5 -4432.5 {}
L 4 922.5 -4437.5 937.5 -4442.5 {}
L 4 922.5 -4447.5 937.5 -4442.5 {}
L 4 922.5 -4447.5 937.5 -4452.5 {}
L 4 922.5 -4457.5 937.5 -4452.5 {}
L 4 922.5 -4457.5 930 -4460 {}
L 4 930 -4470 930 -4460 {}
L 4 932.5 -4462.5 937.5 -4462.5 {}
L 4 935 -4465 935 -4460 {}
L 4 1250 -4420 1250 -4410 {}
L 4 1250 -4420 1257.5 -4422.5 {}
L 4 1242.5 -4427.5 1257.5 -4422.5 {}
L 4 1242.5 -4427.5 1257.5 -4432.5 {}
L 4 1242.5 -4437.5 1257.5 -4432.5 {}
L 4 1242.5 -4437.5 1257.5 -4442.5 {}
L 4 1242.5 -4447.5 1257.5 -4442.5 {}
L 4 1242.5 -4447.5 1257.5 -4452.5 {}
L 4 1242.5 -4457.5 1257.5 -4452.5 {}
L 4 1242.5 -4457.5 1250 -4460 {}
L 4 1250 -4470 1250 -4460 {}
L 4 1252.5 -4462.5 1257.5 -4462.5 {}
L 4 1255 -4465 1255 -4460 {}
L 4 1360 -4420 1360 -4410 {}
L 4 1360 -4420 1367.5 -4422.5 {}
L 4 1352.5 -4427.5 1367.5 -4422.5 {}
L 4 1352.5 -4427.5 1367.5 -4432.5 {}
L 4 1352.5 -4437.5 1367.5 -4432.5 {}
L 4 1352.5 -4437.5 1367.5 -4442.5 {}
L 4 1352.5 -4447.5 1367.5 -4442.5 {}
L 4 1352.5 -4447.5 1367.5 -4452.5 {}
L 4 1352.5 -4457.5 1367.5 -4452.5 {}
L 4 1352.5 -4457.5 1360 -4460 {}
L 4 1360 -4470 1360 -4460 {}
L 4 1362.5 -4462.5 1367.5 -4462.5 {}
L 4 1365 -4465 1365 -4460 {}
L 4 1470 -4420 1470 -4410 {}
L 4 1470 -4420 1477.5 -4422.5 {}
L 4 1462.5 -4427.5 1477.5 -4422.5 {}
L 4 1462.5 -4427.5 1477.5 -4432.5 {}
L 4 1462.5 -4437.5 1477.5 -4432.5 {}
L 4 1462.5 -4437.5 1477.5 -4442.5 {}
L 4 1462.5 -4447.5 1477.5 -4442.5 {}
L 4 1462.5 -4447.5 1477.5 -4452.5 {}
L 4 1462.5 -4457.5 1477.5 -4452.5 {}
L 4 1462.5 -4457.5 1470 -4460 {}
L 4 1470 -4470 1470 -4460 {}
L 4 1472.5 -4462.5 1477.5 -4462.5 {}
L 4 1475 -4465 1475 -4460 {}
L 4 1790 -4420 1790 -4410 {}
L 4 1790 -4420 1797.5 -4422.5 {}
L 4 1782.5 -4427.5 1797.5 -4422.5 {}
L 4 1782.5 -4427.5 1797.5 -4432.5 {}
L 4 1782.5 -4437.5 1797.5 -4432.5 {}
L 4 1782.5 -4437.5 1797.5 -4442.5 {}
L 4 1782.5 -4447.5 1797.5 -4442.5 {}
L 4 1782.5 -4447.5 1797.5 -4452.5 {}
L 4 1782.5 -4457.5 1797.5 -4452.5 {}
L 4 1782.5 -4457.5 1790 -4460 {}
L 4 1790 -4470 1790 -4460 {}
L 4 1792.5 -4462.5 1797.5 -4462.5 {}
L 4 1795 -4465 1795 -4460 {}
L 4 1900 -4420 1900 -4410 {}
L 4 1900 -4420 1907.5 -4422.5 {}
L 4 1892.5 -4427.5 1907.5 -4422.5 {}
L 4 1892.5 -4427.5 1907.5 -4432.5 {}
L 4 1892.5 -4437.5 1907.5 -4432.5 {}
L 4 1892.5 -4437.5 1907.5 -4442.5 {}
L 4 1892.5 -4447.5 1907.5 -4442.5 {}
L 4 1892.5 -4447.5 1907.5 -4452.5 {}
L 4 1892.5 -4457.5 1907.5 -4452.5 {}
L 4 1892.5 -4457.5 1900 -4460 {}
L 4 1900 -4470 1900 -4460 {}
L 4 1902.5 -4462.5 1907.5 -4462.5 {}
L 4 1905 -4465 1905 -4460 {}
L 4 2010 -4420 2010 -4410 {}
L 4 2010 -4420 2017.5 -4422.5 {}
L 4 2002.5 -4427.5 2017.5 -4422.5 {}
L 4 2002.5 -4427.5 2017.5 -4432.5 {}
L 4 2002.5 -4437.5 2017.5 -4432.5 {}
L 4 2002.5 -4437.5 2017.5 -4442.5 {}
L 4 2002.5 -4447.5 2017.5 -4442.5 {}
L 4 2002.5 -4447.5 2017.5 -4452.5 {}
L 4 2002.5 -4457.5 2017.5 -4452.5 {}
L 4 2002.5 -4457.5 2010 -4460 {}
L 4 2010 -4470 2010 -4460 {}
L 4 2012.5 -4462.5 2017.5 -4462.5 {}
L 4 2015 -4465 2015 -4460 {}
L 4 2320 -4420 2320 -4410 {}
L 4 2320 -4420 2327.5 -4422.5 {}
L 4 2312.5 -4427.5 2327.5 -4422.5 {}
L 4 2312.5 -4427.5 2327.5 -4432.5 {}
L 4 2312.5 -4437.5 2327.5 -4432.5 {}
L 4 2312.5 -4437.5 2327.5 -4442.5 {}
L 4 2312.5 -4447.5 2327.5 -4442.5 {}
L 4 2312.5 -4447.5 2327.5 -4452.5 {}
L 4 2312.5 -4457.5 2327.5 -4452.5 {}
L 4 2312.5 -4457.5 2320 -4460 {}
L 4 2320 -4470 2320 -4460 {}
L 4 2322.5 -4462.5 2327.5 -4462.5 {}
L 4 2325 -4465 2325 -4460 {}
L 4 2430 -4420 2430 -4410 {}
L 4 2430 -4420 2437.5 -4422.5 {}
L 4 2422.5 -4427.5 2437.5 -4422.5 {}
L 4 2422.5 -4427.5 2437.5 -4432.5 {}
L 4 2422.5 -4437.5 2437.5 -4432.5 {}
L 4 2422.5 -4437.5 2437.5 -4442.5 {}
L 4 2422.5 -4447.5 2437.5 -4442.5 {}
L 4 2422.5 -4447.5 2437.5 -4452.5 {}
L 4 2422.5 -4457.5 2437.5 -4452.5 {}
L 4 2422.5 -4457.5 2430 -4460 {}
L 4 2430 -4470 2430 -4460 {}
L 4 2432.5 -4462.5 2437.5 -4462.5 {}
L 4 2435 -4465 2435 -4460 {}
L 4 2540 -4420 2540 -4410 {}
L 4 2540 -4420 2547.5 -4422.5 {}
L 4 2532.5 -4427.5 2547.5 -4422.5 {}
L 4 2532.5 -4427.5 2547.5 -4432.5 {}
L 4 2532.5 -4437.5 2547.5 -4432.5 {}
L 4 2532.5 -4437.5 2547.5 -4442.5 {}
L 4 2532.5 -4447.5 2547.5 -4442.5 {}
L 4 2532.5 -4447.5 2547.5 -4452.5 {}
L 4 2532.5 -4457.5 2547.5 -4452.5 {}
L 4 2532.5 -4457.5 2540 -4460 {}
L 4 2540 -4470 2540 -4460 {}
L 4 2542.5 -4462.5 2547.5 -4462.5 {}
L 4 2545 -4465 2545 -4460 {}
L 4 710 -2490 710 -2480 {}
L 4 710 -2490 717.5 -2492.5 {}
L 4 702.5 -2497.5 717.5 -2492.5 {}
L 4 702.5 -2497.5 717.5 -2502.5 {}
L 4 702.5 -2507.5 717.5 -2502.5 {}
L 4 702.5 -2507.5 717.5 -2512.5 {}
L 4 702.5 -2517.5 717.5 -2512.5 {}
L 4 702.5 -2517.5 717.5 -2522.5 {}
L 4 702.5 -2527.5 717.5 -2522.5 {}
L 4 702.5 -2527.5 710 -2530 {}
L 4 710 -2540 710 -2530 {}
L 4 712.5 -2532.5 717.5 -2532.5 {}
L 4 715 -2535 715 -2530 {}
L 4 820 -2490 820 -2480 {}
L 4 820 -2490 827.5 -2492.5 {}
L 4 812.5 -2497.5 827.5 -2492.5 {}
L 4 812.5 -2497.5 827.5 -2502.5 {}
L 4 812.5 -2507.5 827.5 -2502.5 {}
L 4 812.5 -2507.5 827.5 -2512.5 {}
L 4 812.5 -2517.5 827.5 -2512.5 {}
L 4 812.5 -2517.5 827.5 -2522.5 {}
L 4 812.5 -2527.5 827.5 -2522.5 {}
L 4 812.5 -2527.5 820 -2530 {}
L 4 820 -2540 820 -2530 {}
L 4 822.5 -2532.5 827.5 -2532.5 {}
L 4 825 -2535 825 -2530 {}
L 4 930 -2490 930 -2480 {}
L 4 930 -2490 937.5 -2492.5 {}
L 4 922.5 -2497.5 937.5 -2492.5 {}
L 4 922.5 -2497.5 937.5 -2502.5 {}
L 4 922.5 -2507.5 937.5 -2502.5 {}
L 4 922.5 -2507.5 937.5 -2512.5 {}
L 4 922.5 -2517.5 937.5 -2512.5 {}
L 4 922.5 -2517.5 937.5 -2522.5 {}
L 4 922.5 -2527.5 937.5 -2522.5 {}
L 4 922.5 -2527.5 930 -2530 {}
L 4 930 -2540 930 -2530 {}
L 4 932.5 -2532.5 937.5 -2532.5 {}
L 4 935 -2535 935 -2530 {}
L 4 710 -2400 710 -2390 {}
L 4 710 -2400 717.5 -2402.5 {}
L 4 702.5 -2407.5 717.5 -2402.5 {}
L 4 702.5 -2407.5 717.5 -2412.5 {}
L 4 702.5 -2417.5 717.5 -2412.5 {}
L 4 702.5 -2417.5 717.5 -2422.5 {}
L 4 702.5 -2427.5 717.5 -2422.5 {}
L 4 702.5 -2427.5 717.5 -2432.5 {}
L 4 702.5 -2437.5 717.5 -2432.5 {}
L 4 702.5 -2437.5 710 -2440 {}
L 4 710 -2450 710 -2440 {}
L 4 712.5 -2442.5 717.5 -2442.5 {}
L 4 715 -2445 715 -2440 {}
L 4 820 -2400 820 -2390 {}
L 4 820 -2400 827.5 -2402.5 {}
L 4 812.5 -2407.5 827.5 -2402.5 {}
L 4 812.5 -2407.5 827.5 -2412.5 {}
L 4 812.5 -2417.5 827.5 -2412.5 {}
L 4 812.5 -2417.5 827.5 -2422.5 {}
L 4 812.5 -2427.5 827.5 -2422.5 {}
L 4 812.5 -2427.5 827.5 -2432.5 {}
L 4 812.5 -2437.5 827.5 -2432.5 {}
L 4 812.5 -2437.5 820 -2440 {}
L 4 820 -2450 820 -2440 {}
L 4 822.5 -2442.5 827.5 -2442.5 {}
L 4 825 -2445 825 -2440 {}
L 4 930 -2400 930 -2390 {}
L 4 930 -2400 937.5 -2402.5 {}
L 4 922.5 -2407.5 937.5 -2402.5 {}
L 4 922.5 -2407.5 937.5 -2412.5 {}
L 4 922.5 -2417.5 937.5 -2412.5 {}
L 4 922.5 -2417.5 937.5 -2422.5 {}
L 4 922.5 -2427.5 937.5 -2422.5 {}
L 4 922.5 -2427.5 937.5 -2432.5 {}
L 4 922.5 -2437.5 937.5 -2432.5 {}
L 4 922.5 -2437.5 930 -2440 {}
L 4 930 -2450 930 -2440 {}
L 4 932.5 -2442.5 937.5 -2442.5 {}
L 4 935 -2445 935 -2440 {}
L 4 1250 -2400 1250 -2390 {}
L 4 1250 -2400 1257.5 -2402.5 {}
L 4 1242.5 -2407.5 1257.5 -2402.5 {}
L 4 1242.5 -2407.5 1257.5 -2412.5 {}
L 4 1242.5 -2417.5 1257.5 -2412.5 {}
L 4 1242.5 -2417.5 1257.5 -2422.5 {}
L 4 1242.5 -2427.5 1257.5 -2422.5 {}
L 4 1242.5 -2427.5 1257.5 -2432.5 {}
L 4 1242.5 -2437.5 1257.5 -2432.5 {}
L 4 1242.5 -2437.5 1250 -2440 {}
L 4 1250 -2450 1250 -2440 {}
L 4 1252.5 -2442.5 1257.5 -2442.5 {}
L 4 1255 -2445 1255 -2440 {}
L 4 1360 -2400 1360 -2390 {}
L 4 1360 -2400 1367.5 -2402.5 {}
L 4 1352.5 -2407.5 1367.5 -2402.5 {}
L 4 1352.5 -2407.5 1367.5 -2412.5 {}
L 4 1352.5 -2417.5 1367.5 -2412.5 {}
L 4 1352.5 -2417.5 1367.5 -2422.5 {}
L 4 1352.5 -2427.5 1367.5 -2422.5 {}
L 4 1352.5 -2427.5 1367.5 -2432.5 {}
L 4 1352.5 -2437.5 1367.5 -2432.5 {}
L 4 1352.5 -2437.5 1360 -2440 {}
L 4 1360 -2450 1360 -2440 {}
L 4 1362.5 -2442.5 1367.5 -2442.5 {}
L 4 1365 -2445 1365 -2440 {}
L 4 1470 -2400 1470 -2390 {}
L 4 1470 -2400 1477.5 -2402.5 {}
L 4 1462.5 -2407.5 1477.5 -2402.5 {}
L 4 1462.5 -2407.5 1477.5 -2412.5 {}
L 4 1462.5 -2417.5 1477.5 -2412.5 {}
L 4 1462.5 -2417.5 1477.5 -2422.5 {}
L 4 1462.5 -2427.5 1477.5 -2422.5 {}
L 4 1462.5 -2427.5 1477.5 -2432.5 {}
L 4 1462.5 -2437.5 1477.5 -2432.5 {}
L 4 1462.5 -2437.5 1470 -2440 {}
L 4 1470 -2450 1470 -2440 {}
L 4 1472.5 -2442.5 1477.5 -2442.5 {}
L 4 1475 -2445 1475 -2440 {}
L 4 1790 -2400 1790 -2390 {}
L 4 1790 -2400 1797.5 -2402.5 {}
L 4 1782.5 -2407.5 1797.5 -2402.5 {}
L 4 1782.5 -2407.5 1797.5 -2412.5 {}
L 4 1782.5 -2417.5 1797.5 -2412.5 {}
L 4 1782.5 -2417.5 1797.5 -2422.5 {}
L 4 1782.5 -2427.5 1797.5 -2422.5 {}
L 4 1782.5 -2427.5 1797.5 -2432.5 {}
L 4 1782.5 -2437.5 1797.5 -2432.5 {}
L 4 1782.5 -2437.5 1790 -2440 {}
L 4 1790 -2450 1790 -2440 {}
L 4 1792.5 -2442.5 1797.5 -2442.5 {}
L 4 1795 -2445 1795 -2440 {}
L 4 1900 -2400 1900 -2390 {}
L 4 1900 -2400 1907.5 -2402.5 {}
L 4 1892.5 -2407.5 1907.5 -2402.5 {}
L 4 1892.5 -2407.5 1907.5 -2412.5 {}
L 4 1892.5 -2417.5 1907.5 -2412.5 {}
L 4 1892.5 -2417.5 1907.5 -2422.5 {}
L 4 1892.5 -2427.5 1907.5 -2422.5 {}
L 4 1892.5 -2427.5 1907.5 -2432.5 {}
L 4 1892.5 -2437.5 1907.5 -2432.5 {}
L 4 1892.5 -2437.5 1900 -2440 {}
L 4 1900 -2450 1900 -2440 {}
L 4 1902.5 -2442.5 1907.5 -2442.5 {}
L 4 1905 -2445 1905 -2440 {}
L 4 2010 -2400 2010 -2390 {}
L 4 2010 -2400 2017.5 -2402.5 {}
L 4 2002.5 -2407.5 2017.5 -2402.5 {}
L 4 2002.5 -2407.5 2017.5 -2412.5 {}
L 4 2002.5 -2417.5 2017.5 -2412.5 {}
L 4 2002.5 -2417.5 2017.5 -2422.5 {}
L 4 2002.5 -2427.5 2017.5 -2422.5 {}
L 4 2002.5 -2427.5 2017.5 -2432.5 {}
L 4 2002.5 -2437.5 2017.5 -2432.5 {}
L 4 2002.5 -2437.5 2010 -2440 {}
L 4 2010 -2450 2010 -2440 {}
L 4 2012.5 -2442.5 2017.5 -2442.5 {}
L 4 2015 -2445 2015 -2440 {}
L 4 1865 -4210 1865 -4150 {}
L 4 1865 -4200 1880 -4200 {}
L 4 1880 -4210 1880 -4200 {}
L 4 1865 -4160 1880 -4160 {}
L 4 1880 -4160 1880 -4150 {}
L 4 1855 -4195 1855 -4165 {}
L 4 1855 -4180 1855 -4175 {}
L 4 1840 -4180 1847.5 -4180 {}
L 4 1840 -4180 1855 -4180 {}
L 4 1870 -4180 1880 -4180 {}
L 4 1865 -4185 1870 -4180 {}
L 4 1865 -4175 1870 -4180 {}
L 4 1140 -11390 1140 -11377.5 {}
L 4 1135 -11377.5 1145 -11377.5 {}
L 4 1140 -11372.5 1145 -11377.5 {}
L 4 1135 -11377.5 1140 -11372.5 {}
L 4 1140 -11670 1140 -11650 {}
L 4 1130 -11670 1150 -11670 {}
L 4 1032.5 -11462.5 1037.5 -11462.5 {}
L 4 1035 -11465 1035 -11460 {}
L 4 1030 -11470 1030 -11410 {}
L 4 710 -2110 710 -2100 {}
L 4 710 -2110 717.5 -2112.5 {}
L 4 702.5 -2117.5 717.5 -2112.5 {}
L 4 702.5 -2117.5 717.5 -2122.5 {}
L 4 702.5 -2127.5 717.5 -2122.5 {}
L 4 702.5 -2127.5 717.5 -2132.5 {}
L 4 702.5 -2137.5 717.5 -2132.5 {}
L 4 702.5 -2137.5 717.5 -2142.5 {}
L 4 702.5 -2147.5 717.5 -2142.5 {}
L 4 702.5 -2147.5 710 -2150 {}
L 4 710 -2160 710 -2150 {}
L 4 712.5 -2152.5 717.5 -2152.5 {}
L 4 715 -2155 715 -2150 {}
L 4 820 -2110 820 -2100 {}
L 4 820 -2110 827.5 -2112.5 {}
L 4 812.5 -2117.5 827.5 -2112.5 {}
L 4 812.5 -2117.5 827.5 -2122.5 {}
L 4 812.5 -2127.5 827.5 -2122.5 {}
L 4 812.5 -2127.5 827.5 -2132.5 {}
L 4 812.5 -2137.5 827.5 -2132.5 {}
L 4 812.5 -2137.5 827.5 -2142.5 {}
L 4 812.5 -2147.5 827.5 -2142.5 {}
L 4 812.5 -2147.5 820 -2150 {}
L 4 820 -2160 820 -2150 {}
L 4 822.5 -2152.5 827.5 -2152.5 {}
L 4 825 -2155 825 -2150 {}
L 4 930 -2110 930 -2100 {}
L 4 930 -2110 937.5 -2112.5 {}
L 4 922.5 -2117.5 937.5 -2112.5 {}
L 4 922.5 -2117.5 937.5 -2122.5 {}
L 4 922.5 -2127.5 937.5 -2122.5 {}
L 4 922.5 -2127.5 937.5 -2132.5 {}
L 4 922.5 -2137.5 937.5 -2132.5 {}
L 4 922.5 -2137.5 937.5 -2142.5 {}
L 4 922.5 -2147.5 937.5 -2142.5 {}
L 4 922.5 -2147.5 930 -2150 {}
L 4 930 -2160 930 -2150 {}
L 4 932.5 -2152.5 937.5 -2152.5 {}
L 4 935 -2155 935 -2150 {}
L 4 710 -2050 710 -2040 {}
L 4 710 -2050 717.5 -2052.5 {}
L 4 702.5 -2057.5 717.5 -2052.5 {}
L 4 702.5 -2057.5 717.5 -2062.5 {}
L 4 702.5 -2067.5 717.5 -2062.5 {}
L 4 702.5 -2067.5 717.5 -2072.5 {}
L 4 702.5 -2077.5 717.5 -2072.5 {}
L 4 702.5 -2077.5 717.5 -2082.5 {}
L 4 702.5 -2087.5 717.5 -2082.5 {}
L 4 702.5 -2087.5 710 -2090 {}
L 4 710 -2100 710 -2090 {}
L 4 712.5 -2092.5 717.5 -2092.5 {}
L 4 715 -2095 715 -2090 {}
L 4 820 -2050 820 -2040 {}
L 4 820 -2050 827.5 -2052.5 {}
L 4 812.5 -2057.5 827.5 -2052.5 {}
L 4 812.5 -2057.5 827.5 -2062.5 {}
L 4 812.5 -2067.5 827.5 -2062.5 {}
L 4 812.5 -2067.5 827.5 -2072.5 {}
L 4 812.5 -2077.5 827.5 -2072.5 {}
L 4 812.5 -2077.5 827.5 -2082.5 {}
L 4 812.5 -2087.5 827.5 -2082.5 {}
L 4 812.5 -2087.5 820 -2090 {}
L 4 820 -2100 820 -2090 {}
L 4 822.5 -2092.5 827.5 -2092.5 {}
L 4 825 -2095 825 -2090 {}
L 4 930 -2050 930 -2040 {}
L 4 930 -2050 937.5 -2052.5 {}
L 4 922.5 -2057.5 937.5 -2052.5 {}
L 4 922.5 -2057.5 937.5 -2062.5 {}
L 4 922.5 -2067.5 937.5 -2062.5 {}
L 4 922.5 -2067.5 937.5 -2072.5 {}
L 4 922.5 -2077.5 937.5 -2072.5 {}
L 4 922.5 -2077.5 937.5 -2082.5 {}
L 4 922.5 -2087.5 937.5 -2082.5 {}
L 4 922.5 -2087.5 930 -2090 {}
L 4 930 -2100 930 -2090 {}
L 4 932.5 -2092.5 937.5 -2092.5 {}
L 4 935 -2095 935 -2090 {}
L 4 1250 -2050 1250 -2040 {}
L 4 1250 -2050 1257.5 -2052.5 {}
L 4 1242.5 -2057.5 1257.5 -2052.5 {}
L 4 1242.5 -2057.5 1257.5 -2062.5 {}
L 4 1242.5 -2067.5 1257.5 -2062.5 {}
L 4 1242.5 -2067.5 1257.5 -2072.5 {}
L 4 1242.5 -2077.5 1257.5 -2072.5 {}
L 4 1242.5 -2077.5 1257.5 -2082.5 {}
L 4 1242.5 -2087.5 1257.5 -2082.5 {}
L 4 1242.5 -2087.5 1250 -2090 {}
L 4 1250 -2100 1250 -2090 {}
L 4 1252.5 -2092.5 1257.5 -2092.5 {}
L 4 1255 -2095 1255 -2090 {}
L 4 1360 -2050 1360 -2040 {}
L 4 1360 -2050 1367.5 -2052.5 {}
L 4 1352.5 -2057.5 1367.5 -2052.5 {}
L 4 1352.5 -2057.5 1367.5 -2062.5 {}
L 4 1352.5 -2067.5 1367.5 -2062.5 {}
L 4 1352.5 -2067.5 1367.5 -2072.5 {}
L 4 1352.5 -2077.5 1367.5 -2072.5 {}
L 4 1352.5 -2077.5 1367.5 -2082.5 {}
L 4 1352.5 -2087.5 1367.5 -2082.5 {}
L 4 1352.5 -2087.5 1360 -2090 {}
L 4 1360 -2100 1360 -2090 {}
L 4 1362.5 -2092.5 1367.5 -2092.5 {}
L 4 1365 -2095 1365 -2090 {}
L 4 1470 -2050 1470 -2040 {}
L 4 1470 -2050 1477.5 -2052.5 {}
L 4 1462.5 -2057.5 1477.5 -2052.5 {}
L 4 1462.5 -2057.5 1477.5 -2062.5 {}
L 4 1462.5 -2067.5 1477.5 -2062.5 {}
L 4 1462.5 -2067.5 1477.5 -2072.5 {}
L 4 1462.5 -2077.5 1477.5 -2072.5 {}
L 4 1462.5 -2077.5 1477.5 -2082.5 {}
L 4 1462.5 -2087.5 1477.5 -2082.5 {}
L 4 1462.5 -2087.5 1470 -2090 {}
L 4 1470 -2100 1470 -2090 {}
L 4 1472.5 -2092.5 1477.5 -2092.5 {}
L 4 1475 -2095 1475 -2090 {}
L 4 1790 -2020 1790 -2010 {}
L 4 1790 -2020 1797.5 -2022.5 {}
L 4 1782.5 -2027.5 1797.5 -2022.5 {}
L 4 1782.5 -2027.5 1797.5 -2032.5 {}
L 4 1782.5 -2037.5 1797.5 -2032.5 {}
L 4 1782.5 -2037.5 1797.5 -2042.5 {}
L 4 1782.5 -2047.5 1797.5 -2042.5 {}
L 4 1782.5 -2047.5 1797.5 -2052.5 {}
L 4 1782.5 -2057.5 1797.5 -2052.5 {}
L 4 1782.5 -2057.5 1790 -2060 {}
L 4 1790 -2070 1790 -2060 {}
L 4 1792.5 -2062.5 1797.5 -2062.5 {}
L 4 1795 -2065 1795 -2060 {}
L 4 1900 -2020 1900 -2010 {}
L 4 1900 -2020 1907.5 -2022.5 {}
L 4 1892.5 -2027.5 1907.5 -2022.5 {}
L 4 1892.5 -2027.5 1907.5 -2032.5 {}
L 4 1892.5 -2037.5 1907.5 -2032.5 {}
L 4 1892.5 -2037.5 1907.5 -2042.5 {}
L 4 1892.5 -2047.5 1907.5 -2042.5 {}
L 4 1892.5 -2047.5 1907.5 -2052.5 {}
L 4 1892.5 -2057.5 1907.5 -2052.5 {}
L 4 1892.5 -2057.5 1900 -2060 {}
L 4 1900 -2070 1900 -2060 {}
L 4 1902.5 -2062.5 1907.5 -2062.5 {}
L 4 1905 -2065 1905 -2060 {}
L 4 2010 -2020 2010 -2010 {}
L 4 2010 -2020 2017.5 -2022.5 {}
L 4 2002.5 -2027.5 2017.5 -2022.5 {}
L 4 2002.5 -2027.5 2017.5 -2032.5 {}
L 4 2002.5 -2037.5 2017.5 -2032.5 {}
L 4 2002.5 -2037.5 2017.5 -2042.5 {}
L 4 2002.5 -2047.5 2017.5 -2042.5 {}
L 4 2002.5 -2047.5 2017.5 -2052.5 {}
L 4 2002.5 -2057.5 2017.5 -2052.5 {}
L 4 2002.5 -2057.5 2010 -2060 {}
L 4 2010 -2070 2010 -2060 {}
L 4 2012.5 -2062.5 2017.5 -2062.5 {}
L 4 2015 -2065 2015 -2060 {}
L 4 1760 -2800 1760 -2790 {}
L 4 1760 -2800 1767.5 -2802.5 {}
L 4 1752.5 -2807.5 1767.5 -2802.5 {}
L 4 1752.5 -2807.5 1767.5 -2812.5 {}
L 4 1752.5 -2817.5 1767.5 -2812.5 {}
L 4 1752.5 -2817.5 1767.5 -2822.5 {}
L 4 1752.5 -2827.5 1767.5 -2822.5 {}
L 4 1752.5 -2827.5 1767.5 -2832.5 {}
L 4 1752.5 -2837.5 1767.5 -2832.5 {}
L 4 1752.5 -2837.5 1760 -2840 {}
L 4 1760 -2850 1760 -2840 {}
L 4 1762.5 -2842.5 1767.5 -2842.5 {}
L 4 1765 -2845 1765 -2840 {}
L 4 1880 -2800 1880 -2790 {}
L 4 1880 -2800 1887.5 -2802.5 {}
L 4 1872.5 -2807.5 1887.5 -2802.5 {}
L 4 1872.5 -2807.5 1887.5 -2812.5 {}
L 4 1872.5 -2817.5 1887.5 -2812.5 {}
L 4 1872.5 -2817.5 1887.5 -2822.5 {}
L 4 1872.5 -2827.5 1887.5 -2822.5 {}
L 4 1872.5 -2827.5 1887.5 -2832.5 {}
L 4 1872.5 -2837.5 1887.5 -2832.5 {}
L 4 1872.5 -2837.5 1880 -2840 {}
L 4 1880 -2850 1880 -2840 {}
L 4 1882.5 -2842.5 1887.5 -2842.5 {}
L 4 1885 -2845 1885 -2840 {}
L 4 805 -1700 805 -1640 {}
L 4 805 -1690 820 -1690 {}
L 4 820 -1700 820 -1690 {}
L 4 805 -1650 820 -1650 {}
L 4 820 -1650 820 -1640 {}
L 4 795 -1685 795 -1655 {}
L 4 795 -1670 795 -1665 {}
L 4 780 -1670 787.5 -1670 {}
L 4 780 -1670 795 -1670 {}
L 4 810 -1670 820 -1670 {}
L 4 805 -1675 810 -1670 {}
L 4 805 -1665 810 -1670 {}
L 4 820 -1740 820 -1730 {}
L 4 820 -1740 827.5 -1742.5 {}
L 4 812.5 -1747.5 827.5 -1742.5 {}
L 4 812.5 -1747.5 827.5 -1752.5 {}
L 4 812.5 -1757.5 827.5 -1752.5 {}
L 4 812.5 -1757.5 827.5 -1762.5 {}
L 4 812.5 -1767.5 827.5 -1762.5 {}
L 4 812.5 -1767.5 827.5 -1772.5 {}
L 4 812.5 -1777.5 827.5 -1772.5 {}
L 4 812.5 -1777.5 820 -1780 {}
L 4 820 -1790 820 -1780 {}
L 4 822.5 -1782.5 827.5 -1782.5 {}
L 4 825 -1785 825 -1780 {}
L 4 910 -1665 910 -1640 {}
L 4 910 -1700 910 -1675 {}
L 4 900 -1675 920 -1675 {}
L 4 900 -1665 920 -1665 {}
L 4 912.5 -1692.5 917.5 -1692.5 {}
L 4 915 -1695 915 -1690 {}
L 4 582.5 -1632.5 587.5 -1632.5 {}
L 4 585 -1635 585 -1630 {}
L 4 580 -1640 580 -1580 {}
L 4 690 -1560 690 -1547.5 {}
L 4 685 -1547.5 695 -1547.5 {}
L 4 690 -1542.5 695 -1547.5 {}
L 4 685 -1547.5 690 -1542.5 {}
L 4 690 -1840 690 -1820 {}
L 4 680 -1840 700 -1840 {}
L 4 1405 -1700 1405 -1640 {}
L 4 1405 -1690 1420 -1690 {}
L 4 1420 -1700 1420 -1690 {}
L 4 1405 -1650 1420 -1650 {}
L 4 1420 -1650 1420 -1640 {}
L 4 1395 -1685 1395 -1655 {}
L 4 1395 -1670 1395 -1665 {}
L 4 1380 -1670 1387.5 -1670 {}
L 4 1380 -1670 1395 -1670 {}
L 4 1410 -1670 1420 -1670 {}
L 4 1405 -1675 1410 -1670 {}
L 4 1405 -1665 1410 -1670 {}
L 4 1420 -1740 1420 -1730 {}
L 4 1420 -1740 1427.5 -1742.5 {}
L 4 1412.5 -1747.5 1427.5 -1742.5 {}
L 4 1412.5 -1747.5 1427.5 -1752.5 {}
L 4 1412.5 -1757.5 1427.5 -1752.5 {}
L 4 1412.5 -1757.5 1427.5 -1762.5 {}
L 4 1412.5 -1767.5 1427.5 -1762.5 {}
L 4 1412.5 -1767.5 1427.5 -1772.5 {}
L 4 1412.5 -1777.5 1427.5 -1772.5 {}
L 4 1412.5 -1777.5 1420 -1780 {}
L 4 1420 -1790 1420 -1780 {}
L 4 1422.5 -1782.5 1427.5 -1782.5 {}
L 4 1425 -1785 1425 -1780 {}
L 4 1182.5 -1632.5 1187.5 -1632.5 {}
L 4 1185 -1635 1185 -1630 {}
L 4 1180 -1640 1180 -1580 {}
L 4 1290 -1560 1290 -1547.5 {}
L 4 1285 -1547.5 1295 -1547.5 {}
L 4 1290 -1542.5 1295 -1547.5 {}
L 4 1285 -1547.5 1290 -1542.5 {}
L 4 1290 -1840 1290 -1820 {}
L 4 1280 -1840 1300 -1840 {}
L 4 2015 -1700 2015 -1640 {}
L 4 2015 -1690 2030 -1690 {}
L 4 2030 -1700 2030 -1690 {}
L 4 2015 -1650 2030 -1650 {}
L 4 2030 -1650 2030 -1640 {}
L 4 2005 -1685 2005 -1655 {}
L 4 2005 -1670 2005 -1665 {}
L 4 1990 -1670 1997.5 -1670 {}
L 4 1990 -1670 2005 -1670 {}
L 4 2020 -1670 2030 -1670 {}
L 4 2015 -1675 2020 -1670 {}
L 4 2015 -1665 2020 -1670 {}
L 4 2030 -1740 2030 -1730 {}
L 4 2030 -1740 2037.5 -1742.5 {}
L 4 2022.5 -1747.5 2037.5 -1742.5 {}
L 4 2022.5 -1747.5 2037.5 -1752.5 {}
L 4 2022.5 -1757.5 2037.5 -1752.5 {}
L 4 2022.5 -1757.5 2037.5 -1762.5 {}
L 4 2022.5 -1767.5 2037.5 -1762.5 {}
L 4 2022.5 -1767.5 2037.5 -1772.5 {}
L 4 2022.5 -1777.5 2037.5 -1772.5 {}
L 4 2022.5 -1777.5 2030 -1780 {}
L 4 2030 -1790 2030 -1780 {}
L 4 2032.5 -1782.5 2037.5 -1782.5 {}
L 4 2035 -1785 2035 -1780 {}
L 4 1792.5 -1632.5 1797.5 -1632.5 {}
L 4 1795 -1635 1795 -1630 {}
L 4 1790 -1640 1790 -1580 {}
L 4 1900 -1560 1900 -1547.5 {}
L 4 1895 -1547.5 1905 -1547.5 {}
L 4 1900 -1542.5 1905 -1547.5 {}
L 4 1895 -1547.5 1900 -1542.5 {}
L 4 1900 -1840 1900 -1820 {}
L 4 1890 -1840 1910 -1840 {}
L 4 360 -8950 360 -8940 {}
L 4 360 -8950 367.5 -8952.5 {}
L 4 352.5 -8957.5 367.5 -8952.5 {}
L 4 352.5 -8957.5 367.5 -8962.5 {}
L 4 352.5 -8967.5 367.5 -8962.5 {}
L 4 352.5 -8967.5 367.5 -8972.5 {}
L 4 352.5 -8977.5 367.5 -8972.5 {}
L 4 352.5 -8977.5 367.5 -8982.5 {}
L 4 352.5 -8987.5 367.5 -8982.5 {}
L 4 352.5 -8987.5 360 -8990 {}
L 4 360 -9000 360 -8990 {}
L 4 362.5 -8992.5 367.5 -8992.5 {}
L 4 365 -8995 365 -8990 {}
L 4 560 -8950 560 -8940 {}
L 4 560 -8950 567.5 -8952.5 {}
L 4 552.5 -8957.5 567.5 -8952.5 {}
L 4 552.5 -8957.5 567.5 -8962.5 {}
L 4 552.5 -8967.5 567.5 -8962.5 {}
L 4 552.5 -8967.5 567.5 -8972.5 {}
L 4 552.5 -8977.5 567.5 -8972.5 {}
L 4 552.5 -8977.5 567.5 -8982.5 {}
L 4 552.5 -8987.5 567.5 -8982.5 {}
L 4 552.5 -8987.5 560 -8990 {}
L 4 560 -9000 560 -8990 {}
L 4 562.5 -8992.5 567.5 -8992.5 {}
L 4 565 -8995 565 -8990 {}
L 4 800 -8950 800 -8940 {}
L 4 800 -8950 807.5 -8952.5 {}
L 4 792.5 -8957.5 807.5 -8952.5 {}
L 4 792.5 -8957.5 807.5 -8962.5 {}
L 4 792.5 -8967.5 807.5 -8962.5 {}
L 4 792.5 -8967.5 807.5 -8972.5 {}
L 4 792.5 -8977.5 807.5 -8972.5 {}
L 4 792.5 -8977.5 807.5 -8982.5 {}
L 4 792.5 -8987.5 807.5 -8982.5 {}
L 4 792.5 -8987.5 800 -8990 {}
L 4 800 -9000 800 -8990 {}
L 4 802.5 -8992.5 807.5 -8992.5 {}
L 4 805 -8995 805 -8990 {}
L 4 1090 -8950 1090 -8940 {}
L 4 1090 -8950 1097.5 -8952.5 {}
L 4 1082.5 -8957.5 1097.5 -8952.5 {}
L 4 1082.5 -8957.5 1097.5 -8962.5 {}
L 4 1082.5 -8967.5 1097.5 -8962.5 {}
L 4 1082.5 -8967.5 1097.5 -8972.5 {}
L 4 1082.5 -8977.5 1097.5 -8972.5 {}
L 4 1082.5 -8977.5 1097.5 -8982.5 {}
L 4 1082.5 -8987.5 1097.5 -8982.5 {}
L 4 1082.5 -8987.5 1090 -8990 {}
L 4 1090 -9000 1090 -8990 {}
L 4 1092.5 -8992.5 1097.5 -8992.5 {}
L 4 1095 -8995 1095 -8990 {}
L 4 1320 -8950 1320 -8940 {}
L 4 1320 -8950 1327.5 -8952.5 {}
L 4 1312.5 -8957.5 1327.5 -8952.5 {}
L 4 1312.5 -8957.5 1327.5 -8962.5 {}
L 4 1312.5 -8967.5 1327.5 -8962.5 {}
L 4 1312.5 -8967.5 1327.5 -8972.5 {}
L 4 1312.5 -8977.5 1327.5 -8972.5 {}
L 4 1312.5 -8977.5 1327.5 -8982.5 {}
L 4 1312.5 -8987.5 1327.5 -8982.5 {}
L 4 1312.5 -8987.5 1320 -8990 {}
L 4 1320 -9000 1320 -8990 {}
L 4 1322.5 -8992.5 1327.5 -8992.5 {}
L 4 1325 -8995 1325 -8990 {}
L 4 1610 -8950 1610 -8940 {}
L 4 1610 -8950 1617.5 -8952.5 {}
L 4 1602.5 -8957.5 1617.5 -8952.5 {}
L 4 1602.5 -8957.5 1617.5 -8962.5 {}
L 4 1602.5 -8967.5 1617.5 -8962.5 {}
L 4 1602.5 -8967.5 1617.5 -8972.5 {}
L 4 1602.5 -8977.5 1617.5 -8972.5 {}
L 4 1602.5 -8977.5 1617.5 -8982.5 {}
L 4 1602.5 -8987.5 1617.5 -8982.5 {}
L 4 1602.5 -8987.5 1610 -8990 {}
L 4 1610 -9000 1610 -8990 {}
L 4 1612.5 -8992.5 1617.5 -8992.5 {}
L 4 1615 -8995 1615 -8990 {}
L 4 1850 -8950 1850 -8940 {}
L 4 1850 -8950 1857.5 -8952.5 {}
L 4 1842.5 -8957.5 1857.5 -8952.5 {}
L 4 1842.5 -8957.5 1857.5 -8962.5 {}
L 4 1842.5 -8967.5 1857.5 -8962.5 {}
L 4 1842.5 -8967.5 1857.5 -8972.5 {}
L 4 1842.5 -8977.5 1857.5 -8972.5 {}
L 4 1842.5 -8977.5 1857.5 -8982.5 {}
L 4 1842.5 -8987.5 1857.5 -8982.5 {}
L 4 1842.5 -8987.5 1850 -8990 {}
L 4 1850 -9000 1850 -8990 {}
L 4 1852.5 -8992.5 1857.5 -8992.5 {}
L 4 1855 -8995 1855 -8990 {}
L 4 2150 -8950 2150 -8940 {}
L 4 2150 -8950 2157.5 -8952.5 {}
L 4 2142.5 -8957.5 2157.5 -8952.5 {}
L 4 2142.5 -8957.5 2157.5 -8962.5 {}
L 4 2142.5 -8967.5 2157.5 -8962.5 {}
L 4 2142.5 -8967.5 2157.5 -8972.5 {}
L 4 2142.5 -8977.5 2157.5 -8972.5 {}
L 4 2142.5 -8977.5 2157.5 -8982.5 {}
L 4 2142.5 -8987.5 2157.5 -8982.5 {}
L 4 2142.5 -8987.5 2150 -8990 {}
L 4 2150 -9000 2150 -8990 {}
L 4 2152.5 -8992.5 2157.5 -8992.5 {}
L 4 2155 -8995 2155 -8990 {}
L 4 745 -5760 745 -5700 {}
L 4 745 -5750 760 -5750 {}
L 4 760 -5760 760 -5750 {}
L 4 745 -5710 760 -5710 {}
L 4 760 -5710 760 -5700 {}
L 4 735 -5745 735 -5715 {}
L 4 735 -5730 735 -5725 {}
L 4 720 -5730 727.5 -5730 {}
L 4 720 -5730 735 -5730 {}
L 4 750 -5730 760 -5730 {}
L 4 745 -5735 750 -5730 {}
L 4 745 -5725 750 -5730 {}
L 4 760 -5800 760 -5790 {}
L 4 760 -5800 767.5 -5802.5 {}
L 4 752.5 -5807.5 767.5 -5802.5 {}
L 4 752.5 -5807.5 767.5 -5812.5 {}
L 4 752.5 -5817.5 767.5 -5812.5 {}
L 4 752.5 -5817.5 767.5 -5822.5 {}
L 4 752.5 -5827.5 767.5 -5822.5 {}
L 4 752.5 -5827.5 767.5 -5832.5 {}
L 4 752.5 -5837.5 767.5 -5832.5 {}
L 4 752.5 -5837.5 760 -5840 {}
L 4 760 -5850 760 -5840 {}
L 4 762.5 -5842.5 767.5 -5842.5 {}
L 4 765 -5845 765 -5840 {}
L 4 522.5 -5692.5 527.5 -5692.5 {}
L 4 525 -5695 525 -5690 {}
L 4 520 -5700 520 -5640 {}
L 4 630 -5620 630 -5607.5 {}
L 4 625 -5607.5 635 -5607.5 {}
L 4 630 -5602.5 635 -5607.5 {}
L 4 625 -5607.5 630 -5602.5 {}
L 4 630 -5900 630 -5880 {}
L 4 620 -5900 640 -5900 {}
L 4 1305 -5760 1305 -5700 {}
L 4 1305 -5750 1320 -5750 {}
L 4 1320 -5760 1320 -5750 {}
L 4 1305 -5710 1320 -5710 {}
L 4 1320 -5710 1320 -5700 {}
L 4 1295 -5745 1295 -5715 {}
L 4 1295 -5730 1295 -5725 {}
L 4 1280 -5730 1287.5 -5730 {}
L 4 1280 -5730 1295 -5730 {}
L 4 1310 -5730 1320 -5730 {}
L 4 1305 -5735 1310 -5730 {}
L 4 1305 -5725 1310 -5730 {}
L 4 1320 -5800 1320 -5790 {}
L 4 1320 -5800 1327.5 -5802.5 {}
L 4 1312.5 -5807.5 1327.5 -5802.5 {}
L 4 1312.5 -5807.5 1327.5 -5812.5 {}
L 4 1312.5 -5817.5 1327.5 -5812.5 {}
L 4 1312.5 -5817.5 1327.5 -5822.5 {}
L 4 1312.5 -5827.5 1327.5 -5822.5 {}
L 4 1312.5 -5827.5 1327.5 -5832.5 {}
L 4 1312.5 -5837.5 1327.5 -5832.5 {}
L 4 1312.5 -5837.5 1320 -5840 {}
L 4 1320 -5850 1320 -5840 {}
L 4 1322.5 -5842.5 1327.5 -5842.5 {}
L 4 1325 -5845 1325 -5840 {}
L 4 1082.5 -5692.5 1087.5 -5692.5 {}
L 4 1085 -5695 1085 -5690 {}
L 4 1080 -5700 1080 -5640 {}
L 4 1190 -5620 1190 -5607.5 {}
L 4 1185 -5607.5 1195 -5607.5 {}
L 4 1190 -5602.5 1195 -5607.5 {}
L 4 1185 -5607.5 1190 -5602.5 {}
L 4 1190 -5900 1190 -5880 {}
L 4 1180 -5900 1200 -5900 {}
L 4 690 -9810 690 -9750 {}
L 4 690 -9800 705 -9800 {}
L 4 705 -9810 705 -9800 {}
L 4 690 -9760 705 -9760 {}
L 4 705 -9760 705 -9750 {}
L 4 680 -9795 680 -9765 {}
L 4 680 -9780 680 -9775 {}
L 4 665 -9780 672.5 -9780 {}
L 4 665 -9780 680 -9780 {}
L 4 695 -9780 705 -9780 {}
L 4 690 -9785 695 -9780 {}
L 4 690 -9775 695 -9780 {}
L 4 705 -9850 705 -9840 {}
L 4 705 -9850 712.5 -9852.5 {}
L 4 697.5 -9857.5 712.5 -9852.5 {}
L 4 697.5 -9857.5 712.5 -9862.5 {}
L 4 697.5 -9867.5 712.5 -9862.5 {}
L 4 697.5 -9867.5 712.5 -9872.5 {}
L 4 697.5 -9877.5 712.5 -9872.5 {}
L 4 697.5 -9877.5 712.5 -9882.5 {}
L 4 697.5 -9887.5 712.5 -9882.5 {}
L 4 697.5 -9887.5 705 -9890 {}
L 4 705 -9900 705 -9890 {}
L 4 707.5 -9892.5 712.5 -9892.5 {}
L 4 710 -9895 710 -9890 {}
L 4 795 -9775 795 -9750 {}
L 4 795 -9810 795 -9785 {}
L 4 785 -9785 805 -9785 {}
L 4 785 -9775 805 -9775 {}
L 4 797.5 -9802.5 802.5 -9802.5 {}
L 4 800 -9805 800 -9800 {}
L 4 467.5 -9742.5 472.5 -9742.5 {}
L 4 470 -9745 470 -9740 {}
L 4 465 -9750 465 -9690 {}
L 4 575 -9670 575 -9657.5 {}
L 4 570 -9657.5 580 -9657.5 {}
L 4 575 -9652.5 580 -9657.5 {}
L 4 570 -9657.5 575 -9652.5 {}
L 4 575 -9950 575 -9930 {}
L 4 565 -9950 585 -9950 {}
L 4 1255 -9810 1255 -9750 {}
L 4 1255 -9800 1270 -9800 {}
L 4 1270 -9810 1270 -9800 {}
L 4 1255 -9760 1270 -9760 {}
L 4 1270 -9760 1270 -9750 {}
L 4 1245 -9795 1245 -9765 {}
L 4 1245 -9780 1245 -9775 {}
L 4 1230 -9780 1237.5 -9780 {}
L 4 1230 -9780 1245 -9780 {}
L 4 1260 -9780 1270 -9780 {}
L 4 1255 -9785 1260 -9780 {}
L 4 1255 -9775 1260 -9780 {}
L 4 1270 -9850 1270 -9840 {}
L 4 1270 -9850 1277.5 -9852.5 {}
L 4 1262.5 -9857.5 1277.5 -9852.5 {}
L 4 1262.5 -9857.5 1277.5 -9862.5 {}
L 4 1262.5 -9867.5 1277.5 -9862.5 {}
L 4 1262.5 -9867.5 1277.5 -9872.5 {}
L 4 1262.5 -9877.5 1277.5 -9872.5 {}
L 4 1262.5 -9877.5 1277.5 -9882.5 {}
L 4 1262.5 -9887.5 1277.5 -9882.5 {}
L 4 1262.5 -9887.5 1270 -9890 {}
L 4 1270 -9900 1270 -9890 {}
L 4 1272.5 -9892.5 1277.5 -9892.5 {}
L 4 1275 -9895 1275 -9890 {}
L 4 1360 -9775 1360 -9750 {}
L 4 1360 -9810 1360 -9785 {}
L 4 1350 -9785 1370 -9785 {}
L 4 1350 -9775 1370 -9775 {}
L 4 1362.5 -9802.5 1367.5 -9802.5 {}
L 4 1365 -9805 1365 -9800 {}
L 4 1032.5 -9742.5 1037.5 -9742.5 {}
L 4 1035 -9745 1035 -9740 {}
L 4 1030 -9750 1030 -9690 {}
L 4 1140 -9670 1140 -9657.5 {}
L 4 1135 -9657.5 1145 -9657.5 {}
L 4 1140 -9652.5 1145 -9657.5 {}
L 4 1135 -9657.5 1140 -9652.5 {}
L 4 1140 -9950 1140 -9930 {}
L 4 1130 -9950 1150 -9950 {}
L 4 1755 -9810 1755 -9750 {}
L 4 1755 -9800 1770 -9800 {}
L 4 1770 -9810 1770 -9800 {}
L 4 1755 -9760 1770 -9760 {}
L 4 1770 -9760 1770 -9750 {}
L 4 1745 -9795 1745 -9765 {}
L 4 1745 -9780 1745 -9775 {}
L 4 1730 -9780 1737.5 -9780 {}
L 4 1730 -9780 1745 -9780 {}
L 4 1760 -9780 1770 -9780 {}
L 4 1755 -9785 1760 -9780 {}
L 4 1755 -9775 1760 -9780 {}
L 4 1770 -9850 1770 -9840 {}
L 4 1770 -9850 1777.5 -9852.5 {}
L 4 1762.5 -9857.5 1777.5 -9852.5 {}
L 4 1762.5 -9857.5 1777.5 -9862.5 {}
L 4 1762.5 -9867.5 1777.5 -9862.5 {}
L 4 1762.5 -9867.5 1777.5 -9872.5 {}
L 4 1762.5 -9877.5 1777.5 -9872.5 {}
L 4 1762.5 -9877.5 1777.5 -9882.5 {}
L 4 1762.5 -9887.5 1777.5 -9882.5 {}
L 4 1762.5 -9887.5 1770 -9890 {}
L 4 1770 -9900 1770 -9890 {}
L 4 1772.5 -9892.5 1777.5 -9892.5 {}
L 4 1775 -9895 1775 -9890 {}
L 4 1860 -9775 1860 -9750 {}
L 4 1860 -9810 1860 -9785 {}
L 4 1850 -9785 1870 -9785 {}
L 4 1850 -9775 1870 -9775 {}
L 4 1862.5 -9802.5 1867.5 -9802.5 {}
L 4 1865 -9805 1865 -9800 {}
L 4 1532.5 -9742.5 1537.5 -9742.5 {}
L 4 1535 -9745 1535 -9740 {}
L 4 1530 -9750 1530 -9690 {}
L 4 1640 -9670 1640 -9657.5 {}
L 4 1635 -9657.5 1645 -9657.5 {}
L 4 1640 -9652.5 1645 -9657.5 {}
L 4 1635 -9657.5 1640 -9652.5 {}
L 4 1640 -9950 1640 -9930 {}
L 4 1630 -9950 1650 -9950 {}
L 4 2245 -9810 2245 -9750 {}
L 4 2245 -9800 2260 -9800 {}
L 4 2260 -9810 2260 -9800 {}
L 4 2245 -9760 2260 -9760 {}
L 4 2260 -9760 2260 -9750 {}
L 4 2235 -9795 2235 -9765 {}
L 4 2235 -9780 2235 -9775 {}
L 4 2220 -9780 2227.5 -9780 {}
L 4 2220 -9780 2235 -9780 {}
L 4 2250 -9780 2260 -9780 {}
L 4 2245 -9785 2250 -9780 {}
L 4 2245 -9775 2250 -9780 {}
L 4 2260 -9850 2260 -9840 {}
L 4 2260 -9850 2267.5 -9852.5 {}
L 4 2252.5 -9857.5 2267.5 -9852.5 {}
L 4 2252.5 -9857.5 2267.5 -9862.5 {}
L 4 2252.5 -9867.5 2267.5 -9862.5 {}
L 4 2252.5 -9867.5 2267.5 -9872.5 {}
L 4 2252.5 -9877.5 2267.5 -9872.5 {}
L 4 2252.5 -9877.5 2267.5 -9882.5 {}
L 4 2252.5 -9887.5 2267.5 -9882.5 {}
L 4 2252.5 -9887.5 2260 -9890 {}
L 4 2260 -9900 2260 -9890 {}
L 4 2262.5 -9892.5 2267.5 -9892.5 {}
L 4 2265 -9895 2265 -9890 {}
L 4 2350 -9775 2350 -9750 {}
L 4 2350 -9810 2350 -9785 {}
L 4 2340 -9785 2360 -9785 {}
L 4 2340 -9775 2360 -9775 {}
L 4 2352.5 -9802.5 2357.5 -9802.5 {}
L 4 2355 -9805 2355 -9800 {}
L 4 2022.5 -9742.5 2027.5 -9742.5 {}
L 4 2025 -9745 2025 -9740 {}
L 4 2020 -9750 2020 -9690 {}
L 4 2130 -9670 2130 -9657.5 {}
L 4 2125 -9657.5 2135 -9657.5 {}
L 4 2130 -9652.5 2135 -9657.5 {}
L 4 2125 -9657.5 2130 -9652.5 {}
L 4 2130 -9950 2130 -9930 {}
L 4 2120 -9950 2140 -9950 {}
L 4 420 -8965 420 -8940 {}
L 4 420 -9000 420 -8975 {}
L 4 410 -8975 430 -8975 {}
L 4 410 -8965 430 -8965 {}
L 4 422.5 -8992.5 427.5 -8992.5 {}
L 4 425 -8995 425 -8990 {}
L 4 620 -8965 620 -8940 {}
L 4 620 -9000 620 -8975 {}
L 4 610 -8975 630 -8975 {}
L 4 610 -8965 630 -8965 {}
L 4 622.5 -8992.5 627.5 -8992.5 {}
L 4 625 -8995 625 -8990 {}
L 4 860 -8965 860 -8940 {}
L 4 860 -9000 860 -8975 {}
L 4 850 -8975 870 -8975 {}
L 4 850 -8965 870 -8965 {}
L 4 862.5 -8992.5 867.5 -8992.5 {}
L 4 865 -8995 865 -8990 {}
L 4 1150 -8965 1150 -8940 {}
L 4 1150 -9000 1150 -8975 {}
L 4 1140 -8975 1160 -8975 {}
L 4 1140 -8965 1160 -8965 {}
L 4 1152.5 -8992.5 1157.5 -8992.5 {}
L 4 1155 -8995 1155 -8990 {}
L 4 1380 -8965 1380 -8940 {}
L 4 1380 -9000 1380 -8975 {}
L 4 1370 -8975 1390 -8975 {}
L 4 1370 -8965 1390 -8965 {}
L 4 1382.5 -8992.5 1387.5 -8992.5 {}
L 4 1385 -8995 1385 -8990 {}
L 4 1670 -8965 1670 -8940 {}
L 4 1670 -9000 1670 -8975 {}
L 4 1660 -8975 1680 -8975 {}
L 4 1660 -8965 1680 -8965 {}
L 4 1672.5 -8992.5 1677.5 -8992.5 {}
L 4 1675 -8995 1675 -8990 {}
L 4 1910 -8965 1910 -8940 {}
L 4 1910 -9000 1910 -8975 {}
L 4 1900 -8975 1920 -8975 {}
L 4 1900 -8965 1920 -8965 {}
L 4 1912.5 -8992.5 1917.5 -8992.5 {}
L 4 1915 -8995 1915 -8990 {}
L 4 2210 -8965 2210 -8940 {}
L 4 2210 -9000 2210 -8975 {}
L 4 2200 -8975 2220 -8975 {}
L 4 2200 -8965 2220 -8965 {}
L 4 2212.5 -8992.5 2217.5 -8992.5 {}
L 4 2215 -8995 2215 -8990 {}
L 4 2360 -8950 2360 -8940 {}
L 4 2360 -8950 2367.5 -8952.5 {}
L 4 2352.5 -8957.5 2367.5 -8952.5 {}
L 4 2352.5 -8957.5 2367.5 -8962.5 {}
L 4 2352.5 -8967.5 2367.5 -8962.5 {}
L 4 2352.5 -8967.5 2367.5 -8972.5 {}
L 4 2352.5 -8977.5 2367.5 -8972.5 {}
L 4 2352.5 -8977.5 2367.5 -8982.5 {}
L 4 2352.5 -8987.5 2367.5 -8982.5 {}
L 4 2352.5 -8987.5 2360 -8990 {}
L 4 2360 -9000 2360 -8990 {}
L 4 2362.5 -8992.5 2367.5 -8992.5 {}
L 4 2365 -8995 2365 -8990 {}
L 4 2420 -8965 2420 -8940 {}
L 4 2420 -9000 2420 -8975 {}
L 4 2410 -8975 2430 -8975 {}
L 4 2410 -8965 2430 -8965 {}
L 4 2422.5 -8992.5 2427.5 -8992.5 {}
L 4 2425 -8995 2425 -8990 {}
L 4 1120 -7890 1120 -7830 {}
L 4 1530 -1040 1650 -1040 {}
L 4 1530 -960 1650 -960 {}
L 4 1530 -1040 1530 -960 {}
L 4 1650 -1040 1650 -960 {}
L 4 1650 -1030 1670 -1030 {}
L 4 1510 -1030 1530 -1030 {}
L 4 1510 -1010 1530 -1010 {}
L 4 1510 -990 1530 -990 {}
L 4 1510 -970 1530 -970 {}
L 4 2060 -1040 2180 -1040 {}
L 4 2060 -960 2180 -960 {}
L 4 2060 -1040 2060 -960 {}
L 4 2180 -1040 2180 -960 {}
L 4 2180 -1030 2200 -1030 {}
L 4 2040 -1030 2060 -1030 {}
L 4 2040 -1010 2060 -1010 {}
L 4 2040 -990 2060 -990 {}
L 4 2040 -970 2060 -970 {}
L 4 2670 -12080 2670 -12060 {}
L 4 2650 -12080 2670 -12080 {}
L 4 565 -390 565 -330 {}
L 4 565 -340 580 -340 {}
L 4 580 -340 580 -330 {}
L 4 565 -380 580 -380 {}
L 4 580 -390 580 -380 {}
L 4 555 -375 555 -345 {}
L 4 555 -365 555 -360 {}
L 4 552.5 -365 555 -362.5 {}
L 4 550 -365 552.5 -365 {}
L 4 547.5 -362.5 550 -365 {}
L 4 547.5 -362.5 547.5 -357.5 {}
L 4 547.5 -357.5 550 -355 {}
L 4 550 -355 552.5 -355 {}
L 4 552.5 -355 555 -357.5 {}
L 4 540 -360 547.5 -360 {}
L 4 570 -360 580 -360 {}
L 4 565 -365 570 -360 {}
L 4 565 -355 570 -360 {}
L 4 695 -390 695 -330 {}
L 4 695 -340 710 -340 {}
L 4 710 -340 710 -330 {}
L 4 695 -380 710 -380 {}
L 4 710 -390 710 -380 {}
L 4 685 -375 685 -345 {}
L 4 685 -365 685 -360 {}
L 4 682.5 -365 685 -362.5 {}
L 4 680 -365 682.5 -365 {}
L 4 677.5 -362.5 680 -365 {}
L 4 677.5 -362.5 677.5 -357.5 {}
L 4 677.5 -357.5 680 -355 {}
L 4 680 -355 682.5 -355 {}
L 4 682.5 -355 685 -357.5 {}
L 4 670 -360 677.5 -360 {}
L 4 700 -360 710 -360 {}
L 4 695 -365 700 -360 {}
L 4 695 -355 700 -360 {}
L 4 565 -190 565 -130 {}
L 4 565 -180 580 -180 {}
L 4 580 -190 580 -180 {}
L 4 565 -140 580 -140 {}
L 4 580 -140 580 -130 {}
L 4 555 -175 555 -145 {}
L 4 555 -160 555 -155 {}
L 4 540 -160 547.5 -160 {}
L 4 540 -160 555 -160 {}
L 4 570 -160 580 -160 {}
L 4 565 -165 570 -160 {}
L 4 565 -155 570 -160 {}
L 4 565 -110 565 -50 {}
L 4 565 -100 580 -100 {}
L 4 580 -110 580 -100 {}
L 4 565 -60 580 -60 {}
L 4 580 -60 580 -50 {}
L 4 555 -95 555 -65 {}
L 4 555 -80 555 -75 {}
L 4 540 -80 547.5 -80 {}
L 4 540 -80 555 -80 {}
L 4 570 -80 580 -80 {}
L 4 565 -85 570 -80 {}
L 4 565 -75 570 -80 {}
L 4 2225 -390 2225 -330 {}
L 4 2225 -340 2240 -340 {}
L 4 2240 -340 2240 -330 {}
L 4 2225 -380 2240 -380 {}
L 4 2240 -390 2240 -380 {}
L 4 2215 -375 2215 -345 {}
L 4 2215 -365 2215 -360 {}
L 4 2212.5 -365 2215 -362.5 {}
L 4 2210 -365 2212.5 -365 {}
L 4 2207.5 -362.5 2210 -365 {}
L 4 2207.5 -362.5 2207.5 -357.5 {}
L 4 2207.5 -357.5 2210 -355 {}
L 4 2210 -355 2212.5 -355 {}
L 4 2212.5 -355 2215 -357.5 {}
L 4 2200 -360 2207.5 -360 {}
L 4 2230 -360 2240 -360 {}
L 4 2225 -365 2230 -360 {}
L 4 2225 -355 2230 -360 {}
L 4 2355 -390 2355 -330 {}
L 4 2355 -340 2370 -340 {}
L 4 2370 -340 2370 -330 {}
L 4 2355 -380 2370 -380 {}
L 4 2370 -390 2370 -380 {}
L 4 2345 -375 2345 -345 {}
L 4 2345 -365 2345 -360 {}
L 4 2342.5 -365 2345 -362.5 {}
L 4 2340 -365 2342.5 -365 {}
L 4 2337.5 -362.5 2340 -365 {}
L 4 2337.5 -362.5 2337.5 -357.5 {}
L 4 2337.5 -357.5 2340 -355 {}
L 4 2340 -355 2342.5 -355 {}
L 4 2342.5 -355 2345 -357.5 {}
L 4 2330 -360 2337.5 -360 {}
L 4 2360 -360 2370 -360 {}
L 4 2355 -365 2360 -360 {}
L 4 2355 -355 2360 -360 {}
L 4 2225 -190 2225 -130 {}
L 4 2225 -180 2240 -180 {}
L 4 2240 -190 2240 -180 {}
L 4 2225 -140 2240 -140 {}
L 4 2240 -140 2240 -130 {}
L 4 2215 -175 2215 -145 {}
L 4 2215 -160 2215 -155 {}
L 4 2200 -160 2207.5 -160 {}
L 4 2200 -160 2215 -160 {}
L 4 2230 -160 2240 -160 {}
L 4 2225 -165 2230 -160 {}
L 4 2225 -155 2230 -160 {}
L 4 2225 -110 2225 -50 {}
L 4 2225 -100 2240 -100 {}
L 4 2240 -110 2240 -100 {}
L 4 2225 -60 2240 -60 {}
L 4 2240 -60 2240 -50 {}
L 4 2215 -95 2215 -65 {}
L 4 2215 -80 2215 -75 {}
L 4 2200 -80 2207.5 -80 {}
L 4 2200 -80 2215 -80 {}
L 4 2230 -80 2240 -80 {}
L 4 2225 -85 2230 -80 {}
L 4 2225 -75 2230 -80 {}
L 5 1105 -11030 1110 -11030 {}
L 5 1410 -11060 1418.75 -11060 {}
L 5 1645 -11030 1650 -11030 {}
L 5 1950 -11060 1958.75 -11060 {}
L 5 575 -11030 580 -11030 {}
L 5 880 -11060 888.75 -11060 {}
L 5 575 -10570 580 -10570 {}
L 5 880 -10600 888.75 -10600 {}
L 5 1115 -10570 1120 -10570 {}
L 5 1420 -10600 1428.75 -10600 {}
L 5 575 -6980 580 -6980 {}
L 5 880 -7010 888.75 -7010 {}
L 5 1115 -6980 1120 -6980 {}
L 5 1420 -7010 1428.75 -7010 {}
L 5 575 -6580 580 -6580 {}
L 5 880 -6610 888.75 -6610 {}
L 5 1115 -6580 1120 -6580 {}
L 5 1420 -6610 1428.75 -6610 {}
L 5 575 -6140 580 -6140 {}
L 5 1765 -6140 1770 -6140 {}
L 5 1135 -6140 1140 -6140 {}
L 5 1105 -10200 1110 -10200 {}
L 5 1410 -10230 1418.75 -10230 {}
L 5 575 -10200 580 -10200 {}
L 5 880 -10230 888.75 -10230 {}
L 5 1605 -10200 1610 -10200 {}
L 5 1910 -10230 1918.75 -10230 {}
L 5 1645 -11500 1650 -11500 {}
L 5 1950 -11530 1958.75 -11530 {}
L 5 520 -11500 525 -11500 {}
L 5 825 -11530 833.75 -11530 {}
L 5 2105 -11500 2110 -11500 {}
L 5 2410 -11530 2418.75 -11530 {}
L 5 595 -9360 600 -9360 {}
L 5 900 -9390 908.75 -9390 {}
L 5 1135 -9360 1140 -9360 {}
L 5 1440 -9390 1448.75 -9390 {}
L 5 2265 -9360 2270 -9360 {}
L 5 2570 -9390 2578.75 -9390 {}
L 5 1105 -11500 1110 -11500 {}
L 5 1410 -11530 1418.75 -11530 {}
L 5 655 -1670 660 -1670 {}
L 5 960 -1700 968.75 -1700 {}
L 5 1255 -1670 1260 -1670 {}
L 5 1560 -1700 1568.75 -1700 {}
L 5 1865 -1670 1870 -1670 {}
L 5 2170 -1700 2178.75 -1700 {}
L 5 595 -5730 600 -5730 {}
L 5 900 -5760 908.75 -5760 {}
L 5 1155 -5730 1160 -5730 {}
L 5 1460 -5760 1468.75 -5760 {}
L 5 540 -9780 545 -9780 {}
L 5 845 -9810 853.75 -9810 {}
L 5 1105 -9780 1110 -9780 {}
L 5 1410 -9810 1418.75 -9810 {}
L 5 1605 -9780 1610 -9780 {}
L 5 1910 -9810 1918.75 -9810 {}
L 5 2095 -9780 2100 -9780 {}
L 5 2400 -9810 2408.75 -9810 {}
L 7 600 -7530 620 -7530 {dash=3}
L 7 610 -7540 610 -7520 {dash=3}
L 7 600 -7400 620 -7400 {dash=3}
L 7 610 -7410 610 -7390 {dash=3}
L 7 600 -7290 620 -7290 {dash=3}
L 7 610 -7300 610 -7280 {dash=3}
L 7 920 -7530 940 -7530 {dash=3}
L 7 930 -7540 930 -7520 {dash=3}
L 7 920 -7400 940 -7400 {dash=3}
L 7 930 -7410 930 -7390 {dash=3}
L 7 920 -7290 940 -7290 {dash=3}
L 7 930 -7300 930 -7280 {dash=3}
L 7 1510 -1440 1510 -1120 {dash=3}
L 7 1260 -1290 1780 -1290 {dash=3}
L 9 0 -6430 2670 -6430 {dash=4}
L 9 0 -6820 2670 -6820 {dash=4}
L 9 0 -9980 2670 -9980 {dash=4}
L 9 0 -10810 2670 -10810 {dash=4}
L 9 0 -10420 2670 -10420 {dash=4}
L 9 0 -11260 2670 -11260 {dash=4}
L 9 0 -5140 2670 -5140 {dash=4}
L 9 0 -5520 2670 -5520 {dash=4}
L 9 0 -5950 2670 -5950 {dash=4}
L 9 0 -4720 2670 -4720 {dash=4}
L 9 0 -4340 2670 -4340 {dash=4}
L 9 0 -2310 2670 -2310 {dash=4}
L 9 0 -4020 2670 -4020 {dash=4}
L 9 0 -3080 2670 -3080 {dash=4}
L 9 0 -2710 2670 -2710 {dash=4}
L 9 0 -1910 2670 -1910 {dash=4}
L 9 0 -1480 2670 -1480 {dash=4}
L 9 0 -3790 2670 -3790 {dash=4}
L 9 0 -3420 2670 -3420 {dash=4}
L 9 0 -9200 2670 -9200 {dash=4}
L 9 0 -9630 2670 -9630 {dash=4}
L 9 0 -8810 2670 -8810 {dash=4}
L 9 0 -8420 2670 -8420 {dash=4}
L 9 0 -8000 2670 -8000 {dash=4}
L 9 0 -7610 2670 -7610 {dash=4}
L 9 0 -7210 2670 -7210 {dash=4}
L 9 490 -9130 490 -8880 {dash=4}
L 9 710 -9130 710 -8880 {dash=4}
L 9 1000 -9130 1000 -8880 {dash=4}
L 9 1240 -9130 1240 -8880 {dash=4}
L 9 1520 -9130 1520 -8880 {dash=4}
L 9 1760 -9130 1760 -8880 {dash=4}
L 9 2070 -9130 2070 -8880 {dash=4}
L 9 2310 -9130 2310 -8880 {dash=4}
L 9 980 -9925 980 -9675 {dash=4}
L 9 1490 -9925 1490 -9675 {dash=4}
L 9 1965 -9925 1965 -9675 {dash=4}
L 9 975 -10335 975 -10085 {dash=4}
L 9 1460 -10335 1460 -10085 {dash=4}
L 9 930 -11625 930 -11375 {dash=4}
L 9 1475 -11625 1475 -11375 {dash=4}
L 9 1990 -11625 1990 -11375 {dash=4}
L 9 975 -11175 975 -10925 {dash=4}
L 9 1480 -11175 1480 -10925 {dash=4}
L 9 960 -10735 960 -10485 {dash=4}
L 9 970 -9515 970 -9265 {dash=4}
L 9 1545 -9515 1545 -9265 {dash=4}
L 9 2070 -9515 2070 -9265 {dash=4}
L 9 920 -8350 920 -8100 {dash=4}
L 9 1435 -8350 1435 -8100 {dash=4}
L 9 920 -7935 920 -7685 {dash=4}
L 9 1435 -7935 1435 -7685 {dash=4}
L 9 765 -7540 765 -7290 {dash=4}
L 9 960 -7140 960 -6890 {dash=4}
L 9 955 -6760 955 -6510 {dash=4}
L 9 1000 -6320 1000 -6070 {dash=4}
L 9 1610 -6320 1610 -6070 {dash=4}
L 9 990 -5880 990 -5630 {dash=4}
L 9 1080 -5430 1080 -5180 {dash=4}
L 9 1650 -5430 1650 -5180 {dash=4}
L 9 1080 -5040 1080 -4790 {dash=4}
L 9 1650 -5040 1650 -4790 {dash=4}
L 9 2230 -5040 2230 -4790 {dash=4}
L 9 1080 -4660 1080 -4410 {dash=4}
L 9 1680 -4660 1680 -4410 {dash=4}
L 9 2230 -4660 2230 -4410 {dash=4}
L 9 960 -4310 960 -4060 {dash=4}
L 9 1480 -4300 1480 -4050 {dash=4}
L 9 970 -3950 970 -3840 {dash=4}
L 9 1610 -3950 1610 -3840 {dash=4}
L 9 2130 -3950 2130 -3840 {dash=4}
L 9 1000 -3710 1000 -3460 {dash=4}
L 9 1620 -3710 1620 -3460 {dash=4}
L 9 2160 -3710 2160 -3460 {dash=4}
L 9 990 -3350 990 -3100 {dash=4}
L 9 1580 -3350 1580 -3100 {dash=4}
L 9 2210 -3350 2210 -3100 {dash=4}
L 9 1000 -3030 1000 -2780 {dash=4}
L 9 1570 -3030 1570 -2780 {dash=4}
L 9 1070 -2620 1070 -2370 {dash=4}
L 9 1680 -2620 1680 -2370 {dash=4}
L 9 1060 -2230 1060 -1980 {dash=4}
L 9 1660 -2230 1660 -1980 {dash=4}
L 9 1060 -1850 1060 -1600 {dash=4}
L 9 1720 -1840 1720 -1590 {dash=4}
L 9 0 -1080 2670 -1080 {dash=4}
L 9 1030 -1410 1030 -1160 {dash=4}
L 9 1970 -1410 1970 -1160 {dash=4}
L 9 1260 -1040 1260 -790 {dash=4}
L 9 1830 -1040 1830 -790 {dash=4}
L 9 0 -770 2670 -770 {dash=4}
L 9 0 -440 2670 -440 {dash=4}
L 9 790 -730 790 -480 {dash=4}
L 9 1150 -730 1150 -480 {dash=4}
L 9 1500 -730 1500 -480 {dash=4}
L 9 1810 -730 1810 -480 {dash=4}
L 9 790 -1040 790 -790 {dash=4}
L 9 790 -370 790 -120 {dash=4}
L 9 1310 -370 1310 -120 {dash=4}
L 9 2090 -370 2090 -120 {dash=4}
L 9 0 0 2670 0 {dash=4}
B 1 1790 -9420 1820 -9270 {}
B 2 660 -11200 860 -10880 {}
B 2 1267.5 -11062.5 1272.5 -11057.5 {name=d dir=inout}
B 2 1227.5 -11032.5 1232.5 -11027.5 {name=g dir=in}
B 2 1267.5 -11002.5 1272.5 -10997.5 {name=s dir=inout}
B 2 1267.5 -11032.5 1272.5 -11027.5 {name=b dir=in}
B 2 1267.5 -11152.5 1272.5 -11147.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -11092.5 1272.5 -11087.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -11062.5 1362.5 -11057.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -11002.5 1362.5 -10997.5 {name=m dir=inout pinnumber=2}
B 2 2047.5 -11072.5 2052.5 -11067.5 {name=d dir=inout}
B 2 2007.5 -11042.5 2012.5 -11037.5 {name=g dir=in}
B 2 2047.5 -11012.5 2052.5 -11007.5 {name=s dir=inout}
B 2 2047.5 -11042.5 2052.5 -11037.5 {name=b dir=in}
B 2 2047.5 -11162.5 2052.5 -11157.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2047.5 -11102.5 2052.5 -11097.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2137.5 -11072.5 2142.5 -11067.5 {name=p dir=inout pinnumber=1}
B 2 2137.5 -11012.5 2142.5 -11007.5 {name=m dir=inout pinnumber=2}
B 2 1357.5 -10692.5 1362.5 -10687.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -10632.5 1362.5 -10627.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -7102.5 1362.5 -7097.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -7042.5 1362.5 -7037.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -6702.5 1362.5 -6697.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -6642.5 1362.5 -6637.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 660 -6320 900 -6000 {}
B 2 737.5 -11062.5 742.5 -11057.5 {name=d dir=inout}
B 2 737.5 -11002.5 742.5 -10997.5 {name=s dir=inout}
B 2 737.5 -11032.5 742.5 -11027.5 {name=b dir=in}
B 2 737.5 -11152.5 742.5 -11147.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -11092.5 742.5 -11087.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -11062.5 832.5 -11057.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -11002.5 832.5 -10997.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -6172.5 742.5 -6167.5 {name=d dir=inout}
B 2 737.5 -6112.5 742.5 -6107.5 {name=s dir=inout}
B 2 737.5 -6142.5 742.5 -6137.5 {name=b dir=in}
B 2 737.5 -6262.5 742.5 -6257.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -6202.5 742.5 -6197.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -6172.5 832.5 -6167.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -6112.5 832.5 -6107.5 {name=m dir=inout pinnumber=2}
B 2 878.75 -6171.25 881.25 -6168.75 {name=p dir=in}
B 2 1297.5 -6172.5 1302.5 -6167.5 {name=d dir=inout}
B 2 1257.5 -6142.5 1262.5 -6137.5 {name=g dir=in}
B 2 1297.5 -6112.5 1302.5 -6107.5 {name=s dir=inout}
B 2 1297.5 -6142.5 1302.5 -6137.5 {name=b dir=in}
B 2 1297.5 -6262.5 1302.5 -6257.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1297.5 -6202.5 1302.5 -6197.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1387.5 -6172.5 1392.5 -6167.5 {name=p dir=inout pinnumber=1}
B 2 1387.5 -6112.5 1392.5 -6107.5 {name=m dir=inout pinnumber=2}
B 2 1438.75 -6171.25 1441.25 -6168.75 {name=p dir=in}
B 2 2117.5 -6172.5 2122.5 -6167.5 {name=d dir=inout}
B 2 2077.5 -6142.5 2082.5 -6137.5 {name=g dir=in}
B 2 2117.5 -6112.5 2122.5 -6107.5 {name=s dir=inout}
B 2 2117.5 -6142.5 2122.5 -6137.5 {name=b dir=in}
B 2 2117.5 -6262.5 2122.5 -6257.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2117.5 -6202.5 2122.5 -6197.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2207.5 -6172.5 2212.5 -6167.5 {name=p dir=inout pinnumber=1}
B 2 2207.5 -6112.5 2212.5 -6107.5 {name=m dir=inout pinnumber=2}
B 2 2258.75 -6171.25 2261.25 -6168.75 {name=p dir=in}
B 2 660 -10370 860 -10050 {}
B 2 1267.5 -10232.5 1272.5 -10227.5 {name=d dir=inout}
B 2 1227.5 -10202.5 1232.5 -10197.5 {name=g dir=in}
B 2 1267.5 -10172.5 1272.5 -10167.5 {name=s dir=inout}
B 2 1267.5 -10202.5 1272.5 -10197.5 {name=b dir=in}
B 2 1267.5 -10322.5 1272.5 -10317.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -10262.5 1272.5 -10257.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -10232.5 1362.5 -10227.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -10172.5 1362.5 -10167.5 {name=m dir=inout pinnumber=2}
B 2 2047.5 -10242.5 2052.5 -10237.5 {name=d dir=inout}
B 2 2007.5 -10212.5 2012.5 -10207.5 {name=g dir=in}
B 2 2047.5 -10182.5 2052.5 -10177.5 {name=s dir=inout}
B 2 2047.5 -10212.5 2052.5 -10207.5 {name=b dir=in}
B 2 2047.5 -10332.5 2052.5 -10327.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2047.5 -10272.5 2052.5 -10267.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2137.5 -10242.5 2142.5 -10237.5 {name=p dir=inout pinnumber=1}
B 2 2137.5 -10182.5 2142.5 -10177.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -10232.5 742.5 -10227.5 {name=d dir=inout}
B 2 737.5 -10172.5 742.5 -10167.5 {name=s dir=inout}
B 2 737.5 -10202.5 742.5 -10197.5 {name=b dir=in}
B 2 737.5 -10322.5 742.5 -10317.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -10262.5 742.5 -10257.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -10232.5 832.5 -10227.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -10172.5 832.5 -10167.5 {name=m dir=inout pinnumber=2}
B 2 605 -11670 805 -11350 {}
B 2 1807.5 -11532.5 1812.5 -11527.5 {name=d dir=inout}
B 2 1767.5 -11502.5 1772.5 -11497.5 {name=g dir=in}
B 2 1807.5 -11472.5 1812.5 -11467.5 {name=s dir=inout}
B 2 1807.5 -11502.5 1812.5 -11497.5 {name=b dir=in}
B 2 1807.5 -11622.5 1812.5 -11617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1807.5 -11562.5 1812.5 -11557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -11532.5 1902.5 -11527.5 {name=p dir=inout pinnumber=1}
B 2 1897.5 -11472.5 1902.5 -11467.5 {name=m dir=inout pinnumber=2}
B 2 682.5 -11532.5 687.5 -11527.5 {name=d dir=inout}
B 2 682.5 -11472.5 687.5 -11467.5 {name=s dir=inout}
B 2 682.5 -11502.5 687.5 -11497.5 {name=b dir=in}
B 2 682.5 -11622.5 687.5 -11617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 682.5 -11562.5 687.5 -11557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 772.5 -11532.5 777.5 -11527.5 {name=p dir=inout pinnumber=1}
B 2 772.5 -11472.5 777.5 -11467.5 {name=m dir=inout pinnumber=2}
B 2 1530 -11660 1610 -11380 {}
B 2 1567.5 -11472.5 1572.5 -11467.5 {name=p dir=inout}
B 2 1567.5 -11412.5 1572.5 -11407.5 {name=m dir=inout}
B 2 2267.5 -11532.5 2272.5 -11527.5 {name=d dir=inout}
B 2 2227.5 -11502.5 2232.5 -11497.5 {name=g dir=in}
B 2 2267.5 -11472.5 2272.5 -11467.5 {name=s dir=inout}
B 2 2267.5 -11502.5 2272.5 -11497.5 {name=b dir=in}
B 2 2267.5 -11622.5 2272.5 -11617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2267.5 -11562.5 2272.5 -11557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2027.5 -11472.5 2032.5 -11467.5 {name=p dir=inout}
B 2 2027.5 -11412.5 2032.5 -11407.5 {name=m dir=inout}
B 2 2320 -11550 2390 -11370 {}
B 2 1670 -9450 1820 -9420 {}
B 2 1357.5 -5302.5 1362.5 -5297.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -5242.5 1362.5 -5237.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1210 -4630 1500 -4560 {}
B 2 1210 -2550 1500 -2470 {}
B 2 1247.5 -2542.5 1252.5 -2537.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1247.5 -2482.5 1252.5 -2477.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -2542.5 1362.5 -2537.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -2482.5 1362.5 -2477.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1467.5 -2542.5 1472.5 -2537.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1467.5 -2482.5 1472.5 -2477.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1787.5 -2592.5 1792.5 -2587.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1787.5 -2532.5 1792.5 -2527.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -2592.5 1902.5 -2587.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1897.5 -2532.5 1902.5 -2527.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2007.5 -2592.5 2012.5 -2587.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2007.5 -2532.5 2012.5 -2527.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 647.5 -4212.5 652.5 -4207.5 {name=d dir=inout}
B 2 607.5 -4182.5 612.5 -4177.5 {name=g dir=in}
B 2 647.5 -4152.5 652.5 -4147.5 {name=s dir=inout}
B 2 647.5 -4182.5 652.5 -4177.5 {name=b dir=in}
B 2 1227.5 -4212.5 1232.5 -4207.5 {name=d dir=inout}
B 2 1187.5 -4182.5 1192.5 -4177.5 {name=g dir=in}
B 2 1227.5 -4152.5 1232.5 -4147.5 {name=s dir=inout}
B 2 1227.5 -4182.5 1232.5 -4177.5 {name=b dir=in}
B 2 1267.5 -11532.5 1272.5 -11527.5 {name=d dir=inout}
B 2 1227.5 -11502.5 1232.5 -11497.5 {name=g dir=in}
B 2 1267.5 -11472.5 1272.5 -11467.5 {name=s dir=inout}
B 2 1267.5 -11502.5 1272.5 -11497.5 {name=b dir=in}
B 2 1267.5 -11622.5 1272.5 -11617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -11562.5 1272.5 -11557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -11532.5 1362.5 -11527.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -11472.5 1362.5 -11467.5 {name=m dir=inout pinnumber=2}
B 2 1210 -2170 1500 -2090 {}
B 2 1247.5 -2162.5 1252.5 -2157.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1247.5 -2102.5 1252.5 -2097.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -2162.5 1362.5 -2157.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -2102.5 1362.5 -2097.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1467.5 -2162.5 1472.5 -2157.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1467.5 -2102.5 1472.5 -2097.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1787.5 -2212.5 1792.5 -2207.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1787.5 -2152.5 1792.5 -2147.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -2212.5 1902.5 -2207.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1897.5 -2152.5 1902.5 -2147.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2007.5 -2212.5 2012.5 -2207.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2007.5 -2152.5 2012.5 -2147.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 677.5 -2982.5 682.5 -2977.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 677.5 -2922.5 682.5 -2917.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 797.5 -2982.5 802.5 -2977.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1217.5 -2982.5 1222.5 -2977.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1217.5 -2922.5 1222.5 -2917.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1337.5 -2982.5 1342.5 -2977.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1337.5 -2922.5 1342.5 -2917.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1507.5 -1702.5 1512.5 -1697.5 {name=p dir=inout pinnumber=1}
B 2 1507.5 -1642.5 1512.5 -1637.5 {name=m dir=inout pinnumber=2}
B 2 2427.5 -1882.5 2432.5 -1877.5 {name=p dir=inout pinnumber=1}
B 2 2427.5 -1822.5 2432.5 -1817.5 {name=m dir=inout pinnumber=2}
B 2 820 -5780 870 -5600 {}
B 2 847.5 -5762.5 852.5 -5757.5 {name=p dir=inout pinnumber=1}
B 2 847.5 -5702.5 852.5 -5697.5 {name=m dir=inout pinnumber=2}
B 2 1707.5 -5762.5 1712.5 -5757.5 {name=p dir=inout pinnumber=1}
B 2 1707.5 -5702.5 1712.5 -5697.5 {name=m dir=inout pinnumber=2}
B 2 2467.5 -5762.5 2472.5 -5757.5 {name=p dir=inout pinnumber=1}
B 2 2467.5 -5702.5 2472.5 -5697.5 {name=m dir=inout pinnumber=2}
B 2 527.5 -8752.5 532.5 -8747.5 {name=d dir=inout}
B 2 487.5 -8722.5 492.5 -8717.5 {name=g dir=in}
B 2 527.5 -8692.5 532.5 -8687.5 {name=s dir=inout}
B 2 527.5 -8722.5 532.5 -8717.5 {name=b dir=in}
B 2 458.75 -8721.25 461.25 -8718.75 {name=p dir=out}
B 2 847.5 -8652.5 852.5 -8647.5 {name=d dir=inout}
B 2 817.5 -8692.5 822.5 -8687.5 {name=g dir=in}
B 2 787.5 -8652.5 792.5 -8647.5 {name=s dir=inout}
B 2 817.5 -8652.5 822.5 -8647.5 {name=b dir=in}
B 2 818.75 -8721.25 821.25 -8718.75 {name=p dir=out}
B 2 1097.5 -8622.5 1102.5 -8617.5 {name=d dir=inout}
B 2 1137.5 -8652.5 1142.5 -8647.5 {name=g dir=in}
B 2 1097.5 -8682.5 1102.5 -8677.5 {name=s dir=inout}
B 2 1097.5 -8652.5 1102.5 -8647.5 {name=b dir=in}
B 2 1168.75 -8651.25 1171.25 -8648.75 {name=p dir=out}
B 2 1377.5 -8732.5 1382.5 -8727.5 {name=d dir=inout}
B 2 1407.5 -8692.5 1412.5 -8687.5 {name=g dir=in}
B 2 1437.5 -8732.5 1442.5 -8727.5 {name=s dir=inout}
B 2 1407.5 -8732.5 1412.5 -8727.5 {name=b dir=in}
B 2 1408.75 -8661.25 1411.25 -8658.75 {name=p dir=out}
B 2 1777.5 -8732.5 1782.5 -8727.5 {name=d dir=inout}
B 2 1747.5 -8692.5 1752.5 -8687.5 {name=g dir=in}
B 2 1717.5 -8732.5 1722.5 -8727.5 {name=s dir=inout}
B 2 1747.5 -8732.5 1752.5 -8727.5 {name=b dir=in}
B 2 1748.75 -8661.25 1751.25 -8658.75 {name=p dir=out}
B 2 2107.5 -8662.5 2112.5 -8657.5 {name=d dir=inout}
B 2 2077.5 -8702.5 2082.5 -8697.5 {name=g dir=in}
B 2 2047.5 -8662.5 2052.5 -8657.5 {name=s dir=inout}
B 2 2077.5 -8662.5 2082.5 -8657.5 {name=b dir=in}
B 2 2078.75 -8731.25 2081.25 -8728.75 {name=p dir=out}
B 2 767.5 -8252.5 772.5 -8247.5 {name=d dir=inout}
B 2 727.5 -8222.5 732.5 -8217.5 {name=g dir=in}
B 2 767.5 -8192.5 772.5 -8187.5 {name=s dir=inout}
B 2 767.5 -8222.5 772.5 -8217.5 {name=b dir=in}
B 2 767.5 -8342.5 772.5 -8337.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 767.5 -8282.5 772.5 -8277.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 857.5 -8252.5 862.5 -8247.5 {name=p dir=inout pinnumber=1}
B 2 857.5 -8192.5 862.5 -8187.5 {name=m dir=inout pinnumber=2}
B 2 527.5 -8192.5 532.5 -8187.5 {name=p dir=inout}
B 2 527.5 -8132.5 532.5 -8127.5 {name=m dir=inout}
B 2 608.75 -8221.25 611.25 -8218.75 {name=p dir=out}
B 2 637.5 -8112.5 642.5 -8107.5 {name=p dir=inout goto=0}
B 2 637.5 -8372.5 642.5 -8367.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1242.5 -8252.5 1247.5 -8247.5 {name=d dir=inout}
B 2 1202.5 -8222.5 1207.5 -8217.5 {name=g dir=in}
B 2 1242.5 -8192.5 1247.5 -8187.5 {name=s dir=inout}
B 2 1242.5 -8222.5 1247.5 -8217.5 {name=b dir=in}
B 2 1242.5 -8342.5 1247.5 -8337.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1242.5 -8282.5 1247.5 -8277.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1332.5 -8252.5 1337.5 -8247.5 {name=p dir=inout pinnumber=1}
B 2 1332.5 -8192.5 1337.5 -8187.5 {name=m dir=inout pinnumber=2}
B 2 1002.5 -8192.5 1007.5 -8187.5 {name=p dir=inout}
B 2 1002.5 -8132.5 1007.5 -8127.5 {name=m dir=inout}
B 2 1083.75 -8221.25 1086.25 -8218.75 {name=p dir=out}
B 2 1112.5 -8112.5 1117.5 -8107.5 {name=p dir=inout goto=0}
B 2 1112.5 -8372.5 1117.5 -8367.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1727.5 -8132.5 1732.5 -8127.5 {name=d dir=inout}
B 2 1697.5 -8172.5 1702.5 -8167.5 {name=g dir=in}
B 2 1667.5 -8132.5 1672.5 -8127.5 {name=s dir=inout}
B 2 1697.5 -8132.5 1702.5 -8127.5 {name=b dir=in}
B 2 1817.5 -8132.5 1822.5 -8127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1757.5 -8132.5 1762.5 -8127.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1727.5 -8042.5 1732.5 -8037.5 {name=p dir=inout pinnumber=1}
B 2 1667.5 -8042.5 1672.5 -8037.5 {name=m dir=inout pinnumber=2}
B 2 1667.5 -8372.5 1672.5 -8367.5 {name=p dir=inout}
B 2 1607.5 -8372.5 1612.5 -8367.5 {name=m dir=inout}
B 2 1698.75 -8291.25 1701.25 -8288.75 {name=p dir=out}
B 2 1587.5 -8262.5 1592.5 -8257.5 {name=p dir=inout goto=0}
B 2 1847.5 -8262.5 1852.5 -8257.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 767.5 -7822.5 772.5 -7817.5 {name=d dir=inout}
B 2 727.5 -7792.5 732.5 -7787.5 {name=g dir=in}
B 2 767.5 -7762.5 772.5 -7757.5 {name=s dir=inout}
B 2 767.5 -7792.5 772.5 -7787.5 {name=b dir=in}
B 2 767.5 -7912.5 772.5 -7907.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 767.5 -7852.5 772.5 -7847.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 857.5 -7822.5 862.5 -7817.5 {name=p dir=inout pinnumber=1}
B 2 857.5 -7762.5 862.5 -7757.5 {name=m dir=inout pinnumber=2}
B 2 527.5 -7762.5 532.5 -7757.5 {name=p dir=inout}
B 2 527.5 -7702.5 532.5 -7697.5 {name=m dir=inout}
B 2 608.75 -7791.25 611.25 -7788.75 {name=p dir=out}
B 2 637.5 -7682.5 642.5 -7677.5 {name=p dir=inout goto=0}
B 2 637.5 -7942.5 642.5 -7937.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1217.5 -7822.5 1222.5 -7817.5 {name=d dir=inout}
B 2 1177.5 -7792.5 1182.5 -7787.5 {name=g dir=in}
B 2 1217.5 -7762.5 1222.5 -7757.5 {name=s dir=inout}
B 2 1217.5 -7792.5 1222.5 -7787.5 {name=b dir=in}
B 2 1217.5 -7912.5 1222.5 -7907.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1217.5 -7852.5 1222.5 -7847.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1307.5 -7822.5 1312.5 -7817.5 {name=p dir=inout pinnumber=1}
B 2 1307.5 -7762.5 1312.5 -7757.5 {name=m dir=inout pinnumber=2}
B 2 977.5 -7762.5 982.5 -7757.5 {name=p dir=inout}
B 2 977.5 -7702.5 982.5 -7697.5 {name=m dir=inout}
B 2 1058.75 -7791.25 1061.25 -7788.75 {name=p dir=out}
B 2 1087.5 -7682.5 1092.5 -7677.5 {name=p dir=inout goto=0}
B 2 1087.5 -7942.5 1092.5 -7937.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1597.5 -7822.5 1602.5 -7817.5 {name=d dir=inout}
B 2 1637.5 -7792.5 1642.5 -7787.5 {name=g dir=in}
B 2 1597.5 -7762.5 1602.5 -7757.5 {name=s dir=inout}
B 2 1597.5 -7792.5 1602.5 -7787.5 {name=b dir=in}
B 2 1597.5 -7912.5 1602.5 -7907.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1597.5 -7852.5 1602.5 -7847.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1507.5 -7822.5 1512.5 -7817.5 {name=p dir=inout pinnumber=1}
B 2 1507.5 -7762.5 1512.5 -7757.5 {name=m dir=inout pinnumber=2}
B 2 1837.5 -7762.5 1842.5 -7757.5 {name=p dir=inout}
B 2 1837.5 -7702.5 1842.5 -7697.5 {name=m dir=inout}
B 2 1758.75 -7791.25 1761.25 -7788.75 {name=p dir=out}
B 2 1727.5 -7682.5 1732.5 -7677.5 {name=p dir=inout goto=0}
B 2 1727.5 -7942.5 1732.5 -7937.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 607.5 -7562.5 612.5 -7557.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 607.5 -7502.5 612.5 -7497.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 607.5 -7432.5 612.5 -7427.5 {name=p dir=inout pinnumber=1}
B 2 607.5 -7372.5 612.5 -7367.5 {name=m dir=inout pinnumber=2}
B 2 607.5 -7322.5 612.5 -7317.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 607.5 -7262.5 612.5 -7257.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 957.5 -7532.5 962.5 -7527.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 897.5 -7532.5 902.5 -7527.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 957.5 -7402.5 962.5 -7397.5 {name=p dir=inout pinnumber=1}
B 2 897.5 -7402.5 902.5 -7397.5 {name=m dir=inout pinnumber=2}
B 2 957.5 -7292.5 962.5 -7287.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 897.5 -7292.5 902.5 -7287.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1507.5 -1032.5 1512.5 -1027.5 {name=SIG_IN dir=in }
B 2 1507.5 -1012.5 1512.5 -1007.5 {name=VREF dir=in }
B 2 1507.5 -992.5 1512.5 -987.5 {name=CK dir=in }
B 2 1507.5 -972.5 1512.5 -967.5 {name=RST dir=in }
B 2 1438.75 -1031.25 1441.25 -1028.75 {name=p dir=in}
B 2 1438.75 -1011.25 1441.25 -1008.75 {name=p dir=in}
B 2 1438.75 -991.25 1441.25 -988.75 {name=p dir=in}
B 2 1438.75 -971.25 1441.25 -968.75 {name=p dir=in}
B 2 2037.5 -1032.5 2042.5 -1027.5 {name=SIG_IN dir=in }
B 2 2037.5 -1012.5 2042.5 -1007.5 {name=VREF dir=in }
B 2 2037.5 -992.5 2042.5 -987.5 {name=CK dir=in }
B 2 2037.5 -972.5 2042.5 -967.5 {name=RST dir=in }
B 2 2288.75 -1031.25 2291.25 -1028.75 {name=p dir=in}
B 2 1097.5 -1032.5 1102.5 -1027.5 {name=CODE[5:0] dir=out }
B 2 937.5 -1032.5 942.5 -1027.5 {name=SIG_IN dir=in }
B 2 937.5 -1012.5 942.5 -1007.5 {name=VREF dir=in }
B 2 937.5 -992.5 942.5 -987.5 {name=CK dir=in }
B 2 937.5 -972.5 942.5 -967.5 {name=RST dir=in }
B 2 677.5 -1032.5 682.5 -1027.5 {name=CODE[5:0] dir=out }
B 2 517.5 -1032.5 522.5 -1027.5 {name=SIG_IN dir=in }
B 2 517.5 -1012.5 522.5 -1007.5 {name=VREF dir=in }
B 2 517.5 -992.5 522.5 -987.5 {name=CK dir=in }
B 2 517.5 -972.5 522.5 -967.5 {name=RST dir=in }
B 2 968.75 -661.25 971.25 -658.75 {name=p dir=in}
B 2 1278.75 -661.25 1281.25 -658.75 {name=p dir=in}
B 2 1608.75 -661.25 1611.25 -658.75 {name=p dir=in}
B 2 1928.75 -661.25 1931.25 -658.75 {name=p dir=in}
B 2 947.5 -332.5 952.5 -327.5 {name=d dir=inout}
B 2 907.5 -362.5 912.5 -357.5 {name=g dir=in}
B 2 947.5 -392.5 952.5 -387.5 {name=s dir=inout}
B 2 947.5 -362.5 952.5 -357.5 {name=b dir=in}
B 2 1077.5 -332.5 1082.5 -327.5 {name=d dir=inout}
B 2 1037.5 -362.5 1042.5 -357.5 {name=g dir=in}
B 2 1077.5 -392.5 1082.5 -387.5 {name=s dir=inout}
B 2 1077.5 -362.5 1082.5 -357.5 {name=b dir=in}
B 2 947.5 -192.5 952.5 -187.5 {name=d dir=inout}
B 2 907.5 -162.5 912.5 -157.5 {name=g dir=in}
B 2 947.5 -132.5 952.5 -127.5 {name=s dir=inout}
B 2 947.5 -162.5 952.5 -157.5 {name=b dir=in}
B 2 947.5 -112.5 952.5 -107.5 {name=d dir=inout}
B 2 907.5 -82.5 912.5 -77.5 {name=g dir=in}
B 2 947.5 -52.5 952.5 -47.5 {name=s dir=inout}
B 2 947.5 -82.5 952.5 -77.5 {name=b dir=in}
B 2 1360 -220 2033 -75 {flags=image,unscaled
alpha=0.8
image=/home/schippes/x/1.png
image_data=iVBORw0KGgoAAAANSUhEUgAAAqEAAACRCAIAAAB8JfaNAAAABmJLR0QA/wD/AP+gvaeTAAAgAElEQVR4nO3deTxU+/848PeMPTslESIiW5bEKC1ESLYWukkllbLciqSNpLRqUwmVlNuGQly3om433YpuKW4qVxKhhcjOmPn9cX7f85k7yzFkv6/nHx4z73mf9/t13uc9533O+xxzSPPmzUMAAAAAGHZ4jYyMBjoGAAAAAPSyvLw88kDHAAAAAIA+wTvQAQAAAABDlbu7O/eZL1y40M9L9dUYHxgYKCAgwJjy6dOnmJgYxhRjY2MFBYWsrCxfX9+wsDCEkIeHx6NHj4qKijgV1dbW9vHjx1u3bn39+rWPImcMQ0JCAo8NAAAAYFVeXs5NtoiICAMDg35e6v+P8TuCgxk/Dtu1i3WZHcHBbNM5SUlJKS4uxt/SaDS22Zqbm9PS0rgsSkRExNLScsGCBadPn+Y+kh7jJjYAAACgZ8zMzDh99ODBgx8v//+P8WG7djEO86zDeXcHeIRQe3t7a2srU6KysrKlpaW0tHR1dXV1dTVCSFBQ0N7e/sWLF46OjrKysra2tiNGjPjrr7/YFtXa2vro0aOlS5fy8fGNHDnSwcEhNzd39uzZ58+fHzFixOzZs0eOHFlXV/fHH3+8evVqzJgxDg4OL168MDU1pdPpRUVFd+7coVKpY8aMsba2lpGR+f79+4MHDwoLC7GcWFEfPnzAwyguLsZiQwixLoUQmjZtmqGh4YgRIz59+pSRkfHp06duNREAAADQXdiRAeNBAGsK5n9z9QTDfA8GeLbExcVdXV2zsrIKCwuVlJScnZ3fvn2Lf5qSkiIlJcU6V/+vcHl5tbW1GxoaOjo6sALV1NSuXr3a0dHh6uqamZlZVFSkpKQ0f/78uro6Op0uLS2tqKgYExMjJCTk5OQ0Y8aMx48fu7m53blz59WrVwoKCgsWLPjy5QtjURUVFcuWLcPCEBMTw+oVFhZmXUpISMjExOT8+fN1dXWWlpaWlpYJCQk/3koAAAD+O9ierxOc32OLmJmZmZmZYctyGuAR0/V4tsN8jwd4Jycnxvn5ly9f1tfXf/z4MS8vDyH0+vXrgoICpmv2XRbFz8/f0NBw48YNLJ2fnz81NbW1tdXExKSiogI74S4uLi4oKJg0aVJ+fj6ZTM7IyGhsbGxoaMjKynJwcGhoaKisrMzPz0cIlZSUvHz5UkdH5++//8aLYhuAlpYW61L//PMPmUyWkJD49u3bb7/9RibDPykAAADoD/gwj79lm435njvGYf5HBniE0O3bt9+9e4e/bWtrMzMzq6mpwVNqa2vHjBnTraKoVGpjYyOe3traio3KYmJitbW1jCUrKioihDo6OvD8NTU1wsLCUlJSY8eO9fPzwxJ5eHhKSkoYi2JLQkKCdan379/funVr6tSp8+fPr6qqysnJYVxfAAAAoO9gwzwivHLP5r56fGjHBvseD/NNTU11dXWMKd+/f1dTU8PfSklJ9bgoDJ1Ox0seP348ni4pKdnQ0IAQ4uPjExERwYZ5aWnplpaW+vr6kpKSpKQkLKe4uDiNRhMREcGLYquhoYF1KQkJicrKyhcvXvDw8Ojo6Li4uERERLS3t3O5UgAAAECP4Sfx+KQ9KzbTy4wDPJ7Sg+r5+fkF/+3Vq1djx46dPHmyoKCgurq6lpYW26V6UFdRUZGioqKuri4/P7+qqqquri42b48QsrGxERERGTVq1OzZs1+8ePHq1avx48dramry8fHJycl5eHjIyMh0GQbbpZSUlJYsWSItLY0QolKpdDq9s7OzB8EDAAAA3YKfwTNekmfFfB6Pn7V3ead9lxwdHZlSDh48eOXKFez2tOrq6j/++ENOTo4xw/v3721tbfn5+bFr9tyrr6+/cuWKhYWFra1tXV1dWlrax48fx4wZ09LSUlVVtWbNGoRQUVHRvXv3qFQqFoO9vX1jY+P9+/dLSkqYLhngYbx584axfKalSCTSmDFjli1bJiAg8OXLl2vXrsEYDwAA/1lsB9pe+Rc4thXhJTPdgseItIth5Gb7L3OMb3vl7vp+M2bMmCVLlhw6dGigAwEAADA8ubu7479LQzzGM/6aDb5Ul/8fz3apLmFL5eXl/e88nu2Z+o+fzQMAAAD/BT04Ze+Ls3xG//r/eLY5YFAHAAAAhqLh/EyaqqoqmKgHAADQpyIiIgbtUv+6Hg8AAACA4QGeHw8AAAAMW6SPHz/2c5Xh4eH9XCMAAPTY1q1bBzoEAHrCy8trYK7HW1tbD0i9AADQLdbW1p8/fx7oKADoIZirBwAAAIYnGOMBAACA4anXxng7O7u4uLgfKSEgICA9Pb234uk7nOLcvn07/tDboWWotPxA6bf26c8NwdhdGV8Pns7g6uqKPc25u4buNxGAXve/Md7Dw0NeXl5eXn78+PGWlpY3b94kXtLR0fH06dM/HkFQUNAff/zx4+UMeO0GBgbYA237x8C22yCEN0hgYGB/7uKHwYbo567LpNcbcGBXB4BB5V/n8dbW1vfv309JSTExMVm3bl3PDqK7pbGx8e3bt/r6+n1dUT/U7uzsbGho2CtFdWlg2+3HUanU3i2QywYZqHoHue52Xe6bscucfdGA/flNBGCQ+9d99aKioqqqqgghbW3tjIyM7OxsPT29pKSk2NjYd+/eiYuLz507d8uWLYKCgr6+vnl5eXl5eWFhYZKSkoWFhQih5uZmPz+/zMxMGRmZ0NDQ2bNnd1n9s2fP1NTUREVFsbetra2HDx9+9OiRpKTkqlWrjIyMsMSYmJhHjx51dHTo6emtXbsWe5xrQECAsbFxaWnpkydPZGRk1q9fLyAgEBkZ+eHDBx0dnY0bN4qIiCCEOjs7f/nll+zs7Obm5vHjx69atQp/0jxj7Q8fPvzll1+qq6tHjBgxadKkTZs2YcteuXIlKyurvr5+9OjRy5cvNzY25hTn9u3bDQ0NnZycsNh0dHTevXv3zz//CAkJrVy5kkKhEKRzCpJtVIyR19bWent7e3h4WFpaIoTS09OvXr168uRJMTGxH18jTlFx2fJMAgICJk2aVFpaWlBQMH/+fFdXV4Ly2bYSp57A2CARERFFRUVFRUXnzp0TFRW9dOkSa72rV69etmzZ1KlTsWUXLlwYHByso6MTEBBgYGBQWlr68uVLcXFxvB0YJSQk3Lt3b8+ePbKyskN0Q7Bi7LoIoaampr179z59+lRSUpKx6zI1471791JSUiorK0VERExNTZctW4Y9kZkpp4iISHp6Oj7nR6VS3d3dvb29sfZn/A42NTVFRkbm5eVJSkp6eHjg4bFd/dTU1Fu3bp06dQrP4+7u7uXlZWZmxrg6bNu5u183AIYu9tfjSSSSoKBge3s7QohKpQYFBWVlZZ08eTInJycyMhIhFBkZaWRktGPHjo8fP2IDPELo9OnTurq6N2/etLGx8fHxaWxsRAjFxsZqaGhwqj4vL49xN3rjxg1VVdVDhw5RKJSIiIiWlhashMLCwm3bth04cKCpqWnfvn14/pSUFG1t7YiICGVl5YiIiNOnT//000/h4eFVVVWJiYlYnl9++eX58+ebNm06fvy4gYHBjh07GhoamGpvaGg4dOjQwoULY2Njd+/era2tjWVISEi4ffv2qlWrTp065enpSSaTCeJkcvPmzfnz5//yyy+rVq06ePDgp0+fCNLZBskpKsbIpaSk1qxZc+bMmc+fP1dVVcXHx/v4+IiJifXKGhE0HTctz7ZNbG1tr127hj13mKB8tq1E0BPwBvH39584caKHh8fNmzcvXbrEtl4CN2/etLe3v3LlysKFC1m37NmzZ//44499+/ZhA/zQ3RDErl+/rq2tfeLECSsrqwMHDjB2XcZmxEbryMjIgICAly9fMlbHmHPGjBmfP3/GH9P89OlTOp0+ZcoUpgZECMXGxn748GHfvn1BQUHJycltbW1YOtvVNzMzq6ioeP/+PZbn5cuX7e3teLE4tu3c3a8bAEMXmzG+vb09ISGhrKwMO7FwdXWdNWuWkpKSsbHx5s2bMzIyOJVlbm7u6empoaERFBTU0dHx6tUrhNDo0aP19PTY5qfRaH/99RfjGG9oaGhvb6+kpLR06dKOjo7S0tKmpqbs7Ow1a9Zoa2urqKhs2LDhzZs3+P7CyMjI1tZ23Lhxixcvrqqqsra2NjQ0VFNTs7W1xY482traUlNT169fr62tPWbMmEWLFsnKyubm5jLV/u3bNzqdbmhoKC0tPW7cOBsbG4RQa2trSkrK2rVrTU1NZWVlDQ0N8VBZ42RdOwqFoqurixAyNjbW1tb+7bffOKVzCpJtVKztNnPmTD09vWPHjh05csTU1BTbaj++RgRNx03Ls2Vqajp58mTsCJK4fNZWIugJrB2JoF5OeTDTp0/X0dEhkUizZ8/u7OzEtyydTo+KisrLy9u3b9+oUaOG+oYgpqOjM2/ePKwuNTU1vOsyNaOlpaWhoaGsrKyWlpabm9vDhw/ZNrioqKixsfHdu3exj+7evTt9+nQ+Pj6mBmxqavr999+9vLzU1NRUVVVXrVqFzfNzWn0pKSktLS3G52dPmTJFQECAcUXYtnN3v24ADGn/mqtPSkq6fv06jUbj4+PbsGGDubk5Qig/Pz88PLywsLC+vh4hJCwszKks/MiXl5dXWlr669evCCF7e3t7e3u2+d+8eSMkJKSkpISn4LPovLy84uLidXV1/Pz8nZ2dEydOxNJlZGSkpaU/fvyorq6OEFJWVsbSJSUlEULjxo3D32LRVlZWtre3+/j4MNaLnZcw1q6goKCtrb169erJkycbGhpOnTqVn5+/srKSSqXq6OiwRs4aJ2sexvUaN25cRUUFp3ROQZqbm7NGxbbd1q1bt2bNGgEBgZCQECzlx9eIoOkQFy2fk5Nz8OBBLDEyMhK7B4oxZuLyWVupqqqKU09gbRAmBB8xkZeXx16QSCQxMTF8yyYnJ5NIpKNHj4qLi+OZh8SG6IEJEyYwvmbbdRFCxcXF58+ff/fuHTZjx3j8xJTTwsLi8OHDq1atam1txY6TsHTGBqysrOzs7MTn/CZMmEAikRBhPzEzM0tJSVm6dCmVSn306NH69euZVoRtO3f36wbAkPavMd7KyiowMFBISEheXp6Xlxch1NHR4e7uvmTJkhMnTkhLS//555/u7u4cy+L9X2kkEolOpxPXnZubO3nyZMYUHh6ebpWA58d2B3gA+LKtra0IoUuXLuGX/NnWTiKRwsLC/v7776dPn16+fPnatWtHjhwhqJ2bODs7O/HXjHcesaYTBMkalaCgIGu7ffjwobW1tbOz8/v379hB2I+vEUFUiIuWNzQ0PHnyJJaIz2xjZ28Y4vI5tR5brA3ChLFePGYcjUbDX+Nz5hi8xbS0tHJzc58+fWphYUFQ7yDcED3A1D44xmakUqmhoaFz5swJCAgQFxd/+fIl49OtmBrcwMCAj4/v6dOntbW1o0ePxg7QEUsDkkgkxtXBXhOs/rRp02JiYkpKSmpra+l0uoGBAVMGti3Q3a8b26YAYKj41x5NTExMQ0NDSUkJ31OUlZXV1NT4+vrKyMjw8PBg0+8YPj4+xh1xDzx9+pT1+hmTMWPG8PDwFBUVYW8/f/5cU1MzduxYLqtQUFDg4eF5+vRpl7WTSCRtbe3ly5dHRkZ++vTp7du32IFOQUEBl3UxwS8oYK/xmFnTCYJkjYo18tbW1qNHjy5evNjY2Jhx/PjBNSKIihtCQkJj/w/jwR+X5bO2EkFPYGqQLnumuLg4fj27pqYGu++E2MSJE7du3RoVFZWTk4MnDokN0QOMjf/27Vu2X7fq6ur6+vqFCxdKSkqSyWS2l6twZDLZ3Nz83r179+7dw2YHMYwNKCcnRyKRysvLsbfYKTgiXH0xMTFdXd0HDx48ePDAxMSE6cACIcS2nbv7dQNgSOvi9+plZWWFhITu3bs3d+7ct2/fnjlzBv9IQUEhLy+vurpaUFBQQkKCUwnp6elXrlxJSEhgSv/y5UtVVRXb6UpGwsLCs2fPjo6O9vPzGzFiRGxsrLq6OuNcIjERERFbW9szZ86QSCQNDY36+vpHjx5Nnz5dVFSUsfbi4uIXL14YGhqKiYk9f/6cTqfLysoKCgo6ODhERUXRaLTx48djc8Xc/0/O33//nZaWNmXKlPv375eUlOD36LKmcwqys7OTNSrWdjt79qy4uPiCBQtaWlq8vb1TUlKcnJx+fI04RaWiosJlCxAjLp+1lTj1BNYGkZGRKSoqqqmp4efnZ3vuq6Wldffu3VmzZiGEzp07x+m0lYm+vn5AQMDBgwcFBASMjIyGzYZgVVBQcPPmTSMjoz/++OPt27cbN25kzSMtLS0gIPDXX39NnTq1vLw8LS2NuEwLCwtfX9/Ozs7AwEAshakBhYWFZ8yYER8fv2XLFhKJFB8fj20X4tWfPn36pUuXmpqaNm/ezFopp3bm/uv2I80IwGDQxRgvIiISGRkZFhYWEhIiKyvr7e0dGhqKfeTl5fXzzz9TKBRhYWGCu3uqqqrYHjLn5eVNmjSJmytenp6eMTExu3fvplKpenp6Xl5eXS7CtLi4uPjFixdra2slJCS0tbUlJCQeP37MWPuIESNevHhx48aN1tZWOTm5wMBAGRkZhJCbmxuZTI6Ojm5oaJCVlV22bBn39To7O798+TI+Pl5CQiIwMBDfX7BNZxtkS0sLa1S//vorY+TPnz+/e/fu0aNHeXh4REREfHx89u3bN3ny5F5ZI7ZRdavxiRGUz6mVWHsCa0dydnbGrv4KCgrit9YzWrBgQWVl5YoVK0RERNzc3PD717pkYmLi6+u7f//+4ODgioqKYbMhmDg7O7948eL8+fNMXZeRkJCQv79/XFzcmTNnpKWlFyxYcPbsWYIyx44dq6KiIigoiN+xyLrh1qxZc/z4cXd3dzExMUdHx5cvX2LpBKtPoVBOnTolJCQ0adIktvWybWfuv27dbzwABpeBebastbV1aGiosbHxQD2Arq9rDwgImDlzpp2dHZfp3BvYdusf3WqlgWqQ/8KG6EV0Ot3T03PJkiX4XP1QaUB47hwYugbs2bIIIW1tbRMTk/9m7T9i6EbeRwaqQWBDcO/79+/Z2dktLS3Tpk3DE6EBAegHAzbGz58/f6CqHvDaf8TQjbyPDFSDDIkN8fnz55UrVzIlKisrHz9+vD/DWL16NS8vr4+PD+PM/JBoQACGugGbq+/nSgEAoAdgrh4MXV5eXvD8eAAAAGB4Gpi5ejiPBwAAAPraAMzVAwAGGzk5uYEO4f+rrKxkTRw84fWWob6aQyL+IRFkr2Nc64G8rx4AMKiw3SH2s4SEBDc3N7YfDYbwestQX80hEf+QCLLXsa41XI8HAAAAhicY4wEAAIDhaWjP1bP+DD4AgBinCUwAwPAztMd4BDssALpDTk5uGF+MBAAwgbl6AAAAYHiCMR4AAAAYnvpvjLezs4uLi+M+v4uLy+nTp/suHgAA6C3DYH+loaHx4MGDgY6CyDBo5P7HZoz//Pnz+vXrDQwMVFRUKBSKr6/vt2/f+j+ywc/Hx0deXj45OXmgAwGgX5WUlHh5eWlraysrK5ubm585c4ZOp+Ofenh4rF+/Hn+7f/9+dXX13NzcfguvvLx8w4YNBgYGysrK06dPDwwMrKio6Lfa+wdTIw85Hh4e8vLy8vLyysrKU6ZMWbt2bV5e3kAHxQwPcuzYsfr6+gEBAQ0NDQMdVLexuedu5cqVHR0dERERY8aMqaysvH37dmNjo6SkZP8HN5jdvHnz48ePQkJCAx0IAP3qzZs3Dg4ORkZGsbGxUlJST548CQ8Pf/PmzcGDB1kzh4aGXr169erVq3p6ev0TXklJiYODg6KiYmhoqLKyck1NTVpaWmRk5P79+/snAMAla2vrLVu2UKnUysrKlJQUZ2fnvXv3DrZ7qLEgaTTau3fvtmzZws/PHx4ezpSHSqXy8g7eu9eZz+Pr6+ufPXu2ffv2WbNmaWhomJub79u3T0FBIS4uzszMDM/W0dGhra2dkZGBELKzs4uMjFy7du348eNnzJjx7Nmz169f29nZqampubu719fX40t9//591apV48ePp1AomZmZWGJzc3NAQICmpqaqquqKFSuqq6t7sBp2dnZ79+5dsmSJjo4OY+FcxsYphoyMjJkzZyorK+vq6q5btw6v7vPnz7t27Tp69CiJROIUEuuyvdKGAAys7du3Kyoqnj9/nkKhqKuru7u7Hz9+/NKlS48ePWLMRqfTt27dmpycnJSU1G8DPEJo69atcnJyaWlp8+bN09bWnjFjRkRExObNmxFCSUlJc+bMUVNTmzx5ckhISGtrK7aInZ1dRETEypUrNTQ0pk6dmpWVhaVTqdSDBw8aGRkpKyvPmDHj1q1bWOK+ffsMDAzU1NScnZ0LCgr6bdW6xGk/xmnFGxoaVq9ejc3XYjui/iQqKqqqqoqNMsePH1+3bl1oaCg2Zzx4GhkLcsKECdbW1vb29n///TeWbmdnt3//fnd39wkTJpw4cQJxaPxff/3VyMgIWyQxMVFeXv7u3bsIIRqNpqGhgU1usR1lerEFmMd4YWHhESNG3L9/v7OzkzHdycmpoqLi+fPn2Nvs7GwajWZpaYm9jYmJMTExycjI0NTU9PX13bp168aNGxMTE8vKyiIjI/FCoqKiKBTK3bt3Fy9e7OXl9eHDB4RQSEjIo0ePzp07l5qa+v3799WrV/dsTc6ePevt7V1QUBAaGrpu3TqscC5jYxvDt2/f1q1b5+Pj8+jRo2vXrlEoFLyujRs3ent7KykpcQqG7bK90oYADKDa2to///xz9erVPDw8eKKVlZWKikpaWhqeQqfT/f39MzMzk5OTNTU1+zO8hw8frlmzhum8SkpKCiFEpVKDgoKysrJOnjyZk5PD+LU6e/asp6dnUVGRr6+vj49PY2MjQujgwYOXL18ODQ39/fffQ0JCsDIPHTp0//79U6dOZWVlzZw5c/HixXV1df22gsQ47Us5rfiOHTuKi4uvX78eHR0dFRXV0tIycLGj1atXNzc35+TkoEHZyBUVFTk5Ofr6+njKuXPnli9f/vr161WrViEOjW9sbFxZWYldKsrNzZWUlHzy5AlCqKioqK2tTU9Pj9Mo04stwDzG8/LyHj58OCEhQUtLy83NLTo6+suXLwghCQkJKyurxMRELFtSUpKDgwM/Pz/21sLCYtmyZRoaGhs3bnz//r2bm5u5ubment6yZcseP36MF06hUDw8PJSUlPz8/PT09BISEhoaGq5du7Z7924TExMtLa1jx449f/4cHwW7xcbGxtTUFCFkZWVFoVDwn8fpMjZOMWAPjTY3N5eVldXQ0Fi6dClWYHx8fEdHx7JlywiCYbtsr7QhAAOorKwMIaSmpsaUrqqq+v79e/xtampqcnJyYmIia86+Do9Op6uqqrL91NXVddasWUpKSsbGxps3b2Y8c3V0dKRQKCQSycXFhUajvXr1qrm5OTo6Ojw83NbWVklJydzc3MLCoqWlJSYm5siRIyYmJth+TFFR8c6dO/21fkQI9qVsV/z79+83btzYs2ePnp6erq5uaGgolUodwPilpaWlpKTKy8sHVSMnJycrKytjTScpKRkUFIR/ZGtra25uTiaThYWFOTW+tLT0+PHjsR34kydPPD09sdePHz/W19fn5+dnO1L0bguwuedu3rx5+fn50dHR+vr6V69enTlz5ps3bxBCLi4uaWlpVCq1vr4+Kytr4cKF+CJaWlrYCxkZGYQQfuQuIyNTU1ODZ2M8CNLX1y8pKSktLaVSqZMnT8YSx44dO3r06JKSkh6siYaGBv564sSJeCFdxsYpBjU1NRMTk6lTp/r4+CQnJ2MTXGVlZUePHj18+DDBLD1CiO2yqDfaEIABxHhvHQE9PT0JCYlDhw4xTQcOrPz8/EWLFmlqasrLy69YsYLxt4BUVFSwFyQSSVJS8uvXr+/evevo6MBOG3ClpaVtbW0WFhby/+fFixf4lOHAItiXsl1xLL+BgQGWX09Pj0we4H+lxnrXoGpkKyurO3fuZGVlXb58uampKSAgAP9IXV0df03Q+MbGxrm5uTU1NdXV1cuXLy8sLGxtbX3y5ImxsTHiMFL0bguw36gCAgIzZszw9/e/ffu2rKxsTEwMQmjGjBn8/PxZWVmpqakKCgp450AI4TNj2MjH+JZGo+HZiMfFH8R4ENrR0dHd2FiRyeTLly+fO3duzJgxERERc+bMaW5uzs/P//LlC4VCUVRUVFRUbG5uXr9+/aJFi7hZFvVGGwIwgMaNG4cQKi4uZkovLi7GPsKzXb16NScnZ8OGDf3Ze5WUlEgkEmt4CKGOjg53d3dDQ8Pff//9w4cPV65cYdxLMF56QAjR6XS2RzNNTU0IocLCwo8M/P39e3s9ehPBipNIJHw/QyaTmRqhn339+vXbt28KCgqDqpGx6/FqamrTp0/fvn37jRs38ENDAQEBbkowNjZ+/PjxkydPDAwMJCQk1NTUnj9/npubO2XKFMRhpOjdFujiwI2Xl1dWVharkoeHZ8GCBdhNNIwnoNx79uwZ/vr58+fjx49XVlbm5eV9+vQpllhRUfHp0ydOU23E/vrrL8aKxo8fz+WCBDGQyWQKhbJt27bs7OwPHz48f/7c3Nw8Kyvr9v8RFBTcvHnzoUOHWItlXRb1RhsCMICkpKQoFEpMTAzjCfrt27dLS0vt7e0Zc2poaFy5ciUrKyswMJDLs/9eCc/U1DQ6Oppp2rm2trasrKympsbX11dGRoaHh+fVq1fERamoqPDx8f3555+MiRMmTODl5cVumxpsOO3HOK24srIymUzGj4eweYuBCR0hhFBMTMyIESPMzMwGcyMjhPBJWUYEg8iUKVNKSkp+/fVXExMThJCxsfGlS5dqamrwk37WkaJ3W4D5jv9v374tX77c1dV14sSJvLy8WVlZ9+/fP3bsGPbpokWLLCwsaDRaVFRUDyrDbkmwsLBITcVLa+MAACAASURBVE3Nz88/fvy4qKioi4vL9u3bIyIiREVFg4OD9fX1e3YXbm5u7pkzZywtLVNSUgoKCk6ePMnlgpxiyM/Pz8nJMTc3l5KSun//Po1GU1JSEhUVZbwoQCaTx4wZo6ioiL2NjY199erVkSNH2C6L5fnBNgRgYO3evdvR0XH58uXr1q2TkpLKzc0NDw9fvHgx402pGG1t7UuXLrm6urL9j6M+smfPHgcHBwcHBy8vLxUVlZqamtTUVF5e3h07dggJCd27d2/u3Llv3749c+YMcTnCwsKrVq3aunUrjUbT1tZ+//49lUo1NzdftmzZzp07SSSSoaFhTU1NZmamg4ODtrZ2/6wdo7q6Ovw2b4SQvLw82/1YY2Mj2xUXExNzcnIKDw+PjY0lk8l79+7t57n6hoaGf/75B/vfudTU1OvXr+/du1dCQgIhNHgaGQsSIVRVVRUeHj5+/HjG+SocwUCmqKgoKyublpZ29epVhBD2YwCampqioqIIIbYjhbi4eC+2APMYLywsTKFQ4uLisJtrxo0bd+DAgfnz52Ofqqqq6ujojBgxQl5evgeVrV279sGDB7t375aRkTl16hQ27O3cuTM4OHjFihUdHR1mZmY93hesXbv24cOH4eHhjIVziW0MoqKiDx8+jI6ObmpqUlFROX369NixY4nLef/+fWFhIfGyP9iGAAwsDQ2NmzdvHjx40NPTs6mpSVlZ2d/ff+XKlWwz6+np/fLLL4sXL+bn59+5c2c/hKemppaZmXnkyJHg4OC6urqxY8daWFh4e3uLiIhERkaGhYWFhITIysp6e3uHhoYSF7V582YeHp5t27bV1dUpKSlt3boVIRQSEiItLX3gwIGqqqpRo0ZRKBTsBpr+d+fOHcb7sI4cOcJ2P0aw4mFhYf7+/vr6+pKSkl5eXtg97f3mt99+++233/j4+EaNGmVoaJicnIxNX6PB1MhYkAghaWlpY2Pjbdu2cToSIhjIjI2Nf/31V+x2tClTpnR2duJrymmk6MUWIH38+JH73DQazdTUNCAgYMGCBT2rr3clJCRgv5lgZ2c3f/78FStWDHREXRtsbQj+Uzg9d26QPI8O/0YzGSTh9ZahvppDIv4hEWSvY1prLy+vbvw6T21tbWJiYkNDg52dXR/E9p8AbQgAAKDfdGOMNzU15efnP3DggKCgYN8FNLxBGwIAAOg33RjjX79+3Xdx/KD09PSBDoErg7kNAQAADDPw/HgAAABgeBq8T8vhkpyc3ECHAAAAAAxGQ3uMd3NzG8Z3SAIAAAA/AubqAQAAgOEJxngAAABgeBrac/UAgN6CP455cBrk4fWWob6aQyL+IRFkb+ne79wBAAD4Lxsq/6gMEELp6elwHg8AAKAbVq9ePdAhgK5VVVXBGA8AAAAMMW/fviXOcPXqVU9PTwT33AEAAADD1RAY4+3s7OLi4gY6ikHHxcXl9OnTAx0FGCz9U0ND48GDBwMdxX8F47evH76J+MaFbz3oLo5z9cR3HgYGBrL++IyHh8etW7eio6Pxh6oFBQV9/vz53LlzPx4ocHR0tLa29vLywt7OnDlTXV29d6vo8UZHCAkKCqqoqPj5+c2bN693owLDQA+6FkKovLz88OHD9+/f//btm4KCgomJiZ+fH/aA7eEB//rgtmzZ4uPjwyk/47eeaYfAKjk5ef369Rs2bNi4cSOeyLRUl4X8uISEhGXLlgUHB4eEhDCGISEhcf78ecacbBPBDyK6Hh8YGNjd4gQEBA4ePGhjY8PDw/MDUQ1JVCqVl7dP7m9gW/LatWv7oq4ebHRra+stW7a0tLRcu3Zt3bp1CgoKenp6jBn6qGX6rsH/U/qtGbvbtUpKShwcHBQVFUNDQ5WVlWtqatLS0iIjI/fv399HEQ4IS0vLTZs24W9Hjx5NkLlb3/rExMRVq1YlJSVt2LCBRCJ1N7Aed4zy8nIFBQX8bXx8/IYNGy5cuBAcHNyDMD5+/CgnJ9eDBQGml+fq586d++3bt+vXr7N+1NzcHBAQoKmpqaqqumLFiurqatY8VCr14MGDRkZGysrKM2bMwI9wm5ub/fz81NTUpk6dmpWVhSUmJSXNmTNHTU1t8uTJISEhra2tWLqdnV1ERMTKlSs1NDQY89fV1Xl6eqqoqFAolIyMDHz6i0ql7tu3z8DAQE1NzdnZuaCggDUwOzu7vXv3LlmyREdHh0KhZGZm4un79+93d3efMGHCiRMnCFaTUwmcamcq2dfXNy8vLywsTF5eXltbG/171o5TIRkZGTNnzlRWVtbV1V23bh2XG5EV8RdMVFRUVVVVR0dn165do0aNys7OZtsy3QqSy2aJjY2dOXMmHgmVStXR0UlLSyMogZGpqWlGRgb+Vk1N7dGjR4hzFxpU/bOhoWH16tV4frabpu/6bW91LQJbt26Vk5NLS0ubN2+etrb2jBkzIiIiNm/e3N1o4+LizMzM8GI7Ojq0tbVZW4ztxuWmF/0gCQkJLQYjR45EnDcu/q1n3SEwqaqqys/Px44ecnNzsUSmpVgLYe0Y3Kurq4uKipo8efKiRYvwxIqKitzc3F27dpFIpJycnG63DkL79u1TUVEJCwsrLy/vweKgl8d4YWFhb2/vw4cPU6lUpo9CQkIePXp07ty51NTU79+/s/3vi4MHD16+fDk0NPT3338PCQnBjyJPnz6tq6t78+ZNGxsbHx+fxsZGhBCVSg0KCsrKyjp58mROTk5kZCReztmzZz09PYuKinx9ffH827dvLy8vT0lJiY2NjY2NbWlpwTIfOnTo/v37p06dysrKmjlz5uLFi+vq6lhjO3v2rLe3d0FBQWho6Lp16z58+IClnzt3bvny5a9fv161ahXxarItgaB2xpIjIyONjIx27Njx8ePHwsJCptjYFvLt27d169b5+Pg8evTo2rVrFAqFu23IjPsjaBKJJCgo2N7ezrZluhUkl81ib29fUlKCP7H34cOHra2tlpaWxCVwg20XGlT9c8eOHcXFxdevX4+Ojo6KisLzs65Ir/fb3upaBGprax8+fLhmzRqmU0kpKanuRuvk5FRRUfH8+XMsQ3Z2No1GwzoJI7Yb9wd7UY91uXGJdwgIoaSkpNmzZwsJCTk4OCQmJrJdim0hTB0jNjZWQ0ODIFQ6nf77778vXbpUTk4uMjLSxcUlJSUF//TixYt2dnYjRoxwdXWNj4/vQVPs3bt3x44dt2/fVlZWtrGxSUpKwvcwgBu9f8/d8uXL29raLl++zJjY0NBw7dq13bt3m5iYaGlpHTt27Pnz5/i3DtPc3BwdHR0eHm5ra6ukpGRubm5hYYF9ZG5u7unpqaGhERQU1NHR8erVK4SQq6vrrFmzlJSUjI2NN2/ezHi06+joSKFQSCSSi4sLjUZ79epVfX19WlpaeHi4rq6utrb2rl27sKOQlpaWmJiYI0eOmJiYKCkp+fn5KSoq3rlzh3W9bGxsTE1NEUJWVlYUCgW/vmhra2tubk4mk4WFhYlXk7UE4toZSyZocE6FfP78GWs6WVlZDQ2NpUuXcrkFGQd17gf49vb2hISEsrIyY2Nj1vi7FST3zTJ69OgpU6akpqZiH6WlpVlaWgoJCXG/WTlh7UKDqn9+//79xo0be/bs0dPT09XVDQ0NZT2qxvRFv+1x1+JeWVkZnU5XVVVl/ai70UpISFhZWeHjXFJSkoODAz8/P2OZbDfuj/cibiQmJsozePDgAfcbl7hYBwcHhJCjo2N6ejo+jdQlpt3O6NGjmS694aqqqsLDw9XU1BwdHUeMGHH37t1Xr15t2rSJ8XJDfHy8q6srQmjx4sWJiYmcjkQJiIiIeHh4PHjwoKioSF9ff/369fLy8hs3bsS+ZaBLvX8dTkBAwM/P7+jRo4wzNqWlpVQqdfLkydjbsWPHjh49uqSkRF9fH8/z7t27jo4O7PvJBJ+M4uXllZaW/vr1K0IoPz8/PDy8sLCwvr4eIcQ4EKqoqGAvSCSSpKTk169fBQQEaDSarq4uXiB2nF5aWtrW1obvrDH4uQ4jxoPZiRMnlpSUYK8Zb3wjXk3WEohr5/KWOk6FzJ8/38TEZOrUqRYWFrNmzZo7d66goCA3BSKESCQSnU7HB3g6nU6QOSkp6fr16zQajY+Pb8OGDebm5qzxdyvIbjWLg4NDdHT05s2bqVRqZmbmkSNHCKrjcvURuy40qPon1tMMDAywFD09PTKZ/fF6X/RbNTW1HnetH9fdaBFCLi4ufn5+u3btampqysrKYr2YyHbj/ngv4gbT9fhx48b9888/XG5cTp49e/blyxfsMpa6urq8vPyvv/7q7OzMzbJM3y97e3t7e3u2Offs2XPy5ElXV9eYmBhRUVHWDI8fP/706dOcOXMQQlpaWkpKStevX1+yZEm31gWnpqYWHh4eFha2c+fOPXv2/Pnnn48fP+5ZUf8pfXKvzZIlS6Kioi5cuNCtpQgGEsb5Omz46ejocHd3X7JkyYkTJ6Slpf/88093d3c8D9Mdf3Q6nVPhTU1NCKHCwkJJSUni8BgPpTs6OvDXAgICxAsSlEBcO5clExRy+fLlJ0+e3L17NyIi4vjx45mZmSNGjOAyWi4HeISQlZVVYGCgkJCQvLw845ZijL9bQXarWezs7Hbs2FFQUPD582cajTZr1izi6hgx7To7Ozvx19x3ITQQ/fPFixckEgmvl0wmc7rLtS/6LZlM/pGuxQ0lJSUSiVRcXDxp0qRuLch2fWfMmMHPz5+VlfX582cFBQV8+MSxbX/udw4/Arsez5TI5cbl5Nq1a9+/fx8/fjz2lkajJSYmcjnGc98xAgICREVF4+Pj1dXV3dzcVqxYMXHiRMYM8fHxdXV1eMeg0Wjx8fE9HuMrKysvXrwYFxdXWVm5cuXKNWvW9Kyc/5o++f94Pj6+9evXnzhxorm5GUtRVlbm5eV9+vQp9raiouLTp09ME3EqKip8fHx//vknN1WUlZXV1NT4+vrKyMjw8PB0OW+jrKxMJpNfvnyJvS0sLMT2BRMmTODl5b17926XNf7111/462fPnuHfH6ZaCFaTtQTua0cI8fHxMQ5COIJCyGQyhULZtm1bdnb2hw8fmC6OcMK4v+tygEcIiYmJaWhoKCkpEdyF260gu9UsUlJSU6dOTUtLS0tLs7GxweZguSxBWlr627dv2Ovq6uq2tjaCzIOqf2L5i4uLsbfYaSjbkvui36Kedi3uSUlJmZqaRkdHM01T19bW9iBaHh6eBQsWJCcnJyUlLVy4kLU6thu3W/2wF3G5cTntENrb29PS0o4cOXL7/1y9ejUnJ6eqqop1KU6FcGPcuHF79+4tLy+Pjo5++/atrq6uiYlJdHQ0NnHV1tZ29erVuLi4/P+TlZWVnZ1dUVHRrVra29uTkpLmzp2rqKh48+bNzZs3V1VVxcbG4hM5gFhf/c/MwoULT548mZ6ejs0XiYqKuri4bN++PSIiQlRUNDg4WF9fn+kyj7Cw8KpVq7Zu3Uqj0bS1td+/f0+lUvGJXyaysrJCQkL37t2bO3fu27dvz5w5QxyPuLi4vb391q1bDx06RCaTsXtqSCSSuLj4smXLdu7cSSKRDA0Na2pqMjMzHRwcWG9Vzc3NPXPmjKWlZUpKSkFBwcmTJ1lrIV5N1hK4rx0hpKCgkJeXV11dLSgoKCEhwbhqbAuhUqk5OTnm5uZSUlL379+n0WhKSkrErYTDJuq5GeC51K0gu9UsCCEHB4eIiIjv37/j/2jAZQkmJiZJSUnz589HCIWFhRHPiA62/unk5BQeHh4bG0smk/fu3csp+L7ot/n5+T3uWtzbs2ePg4ODg4ODl5eXiopKTU1NamoqLy/v/v37uxUtlr5o0SILCwsajRYVFcVaF6eN261+2DN1dXV///03/lZKSmrMmDHcbFxOO4Tbt2/TaDRnZ2fGY251dfXk5GQfHx+mpTgVgktPT79y5QrBzxvw8PDMmzdv3rx5nz59io+PP3LkyIULFx4+fJiWlkaj0ZYsWcLHx4dn1tbWTkhICAoKQgjV1tbm5+fjHykqKrJNDA0NvXr1qru7++HDh3v9F0GGOrYN8ubNG8a3fTXG8/Ly+vv7M/6Yw86dO4ODg1esWNHR0WFmZhYeHs661ObNm3l4eLZt21ZXV6ekpLR161ZO5YuIiERGRoaFhYWEhMjKynp7e4eGhhKHtHv3bn9/fwcHBxkZmR07dvj6+mLnfCEhIdLS0gcOHKiqqho1ahSFQpGRkWFdfO3atQ8fPgwPD5eRkTl16hSnnRrBarItgcvaEUJeXl4///wzhUIRFhZmupOWbSENDQ0PHz6Mjo5uampSUVE5ffp0t348pBcH+B4EyX2zIIRsbW2DgoJERESmTZtGXB3Tgt7e3u/evTMyMhIXF9+0adPt27eJV2FQ9c+wsDB/f399fX1JSUkvLy9O/5jUF/2WSqX+SNfikpqaGnaDRXBwcF1d3dixYy0sLLy9vbsbLZaO/XvniBEj5OXl2VbHduN2qx/2zJ07dxjv41u6dOm+ffu42bicdgjXrl0zNzdnmlSzsbFJTEz08fFhWopgr4KpqqrCp0yIjR49OjAwMDAwEPsp9fj4eBsbG8YBHiHk5OQUHx+PjfE3b968efMm/hH2Y5GsiT///HNERAT8EgZbb968YRrmmQZ4RPBsWTk5OeLS2f4u1VDxzz//zJgx49mzZ8S/OIGzs7ObP3/+ihUrelzjj5fQD4b3Rh9Cuts/ORk8/bZ/uhZBtDQazdTUNCAgYMGCBT9e0X9Zeno6PHduwDE+kwYf5hkHeOyZNGvWrOF4cDT89ubPnj2rq6vT0tKqrq4ODg6eOnXqD+5Ah5/ht9GHkOHdPwe2a9XW1iYmJjY0NOA/sw3AsIGdzbOewWP+QxMg7e3tu3bt+vDhg7i4+PTp03fu3DnQEQHwP9A/+46pqSk/P/+BAwf683/8AOg3nAZ4RDBXDwAAADCBufrBgMvnxxPN1QMAAABgELp69SqXOWGMBwAA0A3Yv9qDAeTp6cllTtIwe1AjAAAAABBCOTk5vAghNze3gY4EAAAAAF2Tk5M7cOCApqYmY+KrV6+YUuzs7P7/GA9AH3n37t1Ah/Av+MNgAABg2LCzs+P0g9l98nv1AAAAAOg3bm5ubId5GOMRQujixYs2NjbEedTU1LAHPL9+/bp/ohoeLC0tzczMzMzMBts5PQAADAP4Lzuxvew+eMf4U6dOWVhYqKqqGhsbHz58uMcPR+otxcXF/6lRat++fVOnTlVRUTEyMtqzZw/T47+4d+fOnezsbO7z02i0EydO2Nra2tjYHD16lEajEeePiYlZvHixhYXF/Pnzo6Kiehxnd+Xn5y9btkxLS0teXh5uMwYADCD8dyRZT+UH7/X4zMzMJUuWaGlplZWVbd++nYeH5+effx7ooP5DJCQktmzZIicnV1FRsWPHDn5+/k2bNvVDvYmJienp6Tt37uTh4cGeCLJ06VKC/KKioqtXr5aRkamurj527Bg/P//KlSv7Ic7GxkZNTc1p06bBD9IBAAYK088zu7m5PXv2jDHlf+fxLi4uwcHBLi4u6urqDg4O1dXVWHpGRsbcuXPV1NQ0NTU3bNjQ2NiIELp3756ZmZmdnZ2pqWlcXJy+vv6iRYuwhxx3dnYeOHBAX19fQ0Nj+fLlnz59IoiPoJybN296eHgYGxsvWrRo4cKFjI9m6lY5LS0t/v7+Ghoa6urqP//8c1NTE7ZIbW3t0qVLlZWVra2tS0tL8aK6FT+x/Pz8BQsWqKio6Ovr79q1q2dxUqnUoKAgXV1dNTU1W1tb/BHjjo6OQUFB1tbWGhoaP/3009evXwkiMTAwuHfvHmPK48ePNTU1CR4u5+XlZWdnZ2BgYG9v7+zsjD9a28XF5cSJE9jr1NRUU1PTHrYOB+np6S4uLiYmJkZGRj/99FNaWhpx/sWLF8+aNUtLS8vCwsLKygrv3+vXr8cfiJmdne3q6kpQCMF24WTatGmbN2/u9dUHAIBuYXoYBNOp/L/m6lNSUkJDQwsKCgQFBY8ePYolfvv2beXKlbdu3bp27VpxcfGePXvwcg8dOiQvL3/hwoXk5OTS0tLc3FyEUGRk5K1bt06fPp2ZmSklJbV27VqEUFxcnDwLbKjgVA6j79+/S0pKdrmebMs5fPjww4cPExISrly58vz5c/z3AHbu3Pn169eMjAxfX9+LFy/i5bCNnxOC9aqpqXF1dVVVVc3MzIyLi2tvb+9ZnJcvX/7jjz8SEhLu3bu3du1axmsWKSkpx48fLywsFBcX37FjB0Gc+vr6BQUFjCkFBQX6+vrnz5/nFD+GTqf/888/d+/e1dHRIW7/bklOTjZjkZCQ0N7eXlZWpqWlhWXDHtDS0NDQZYF0Or2srOzx48cTJkzoWUhstwvB9gUAgIHF9hlLTFfl/zVXb2trq6GhgRCyt7e/dOkS6wKenp6HDh3CXispKWloaBgYGHz69ElFRUVdXb2qqqqzs/PUqVMXL140NjZGCIWFhamrq1dWVjo4OEyZMoUplNGjRxcUFLAthzFbaWlpZmbm+fPnideWUzlXrlzZsmXL5MmTEUL+/v4BAQGhoaHt7e2pqanx8fGampqampq3b9/Gfv6XU/ycnozJab0QQvHx8fLy8nv37iWRSAghPT29HsRJIpHKy8uVlZV1dXURQkxP6ba1tcWGtLVr19rZ2TU2NoqIiLCNU19f/8WLF1gtVCrVzc0NG+MJ4sdWYfv27TQabcGCBcTHEN01e/ZsbI0YjRw5sr6+nk6ni4uL79mzp7GxcdWqVQihuro6UVFRgtJu3LiBXbmfM2fOunXrehYS2+1C3D4AADCw2D7RkfF/5f81xuMjmYiISF1dHfb69evXu3btys/Pr6+vRwjJyMhg6QICAgghfn5+7FFO/Pz8ra2tFRUVTU1Nzs7OjMVWVFQYGRmJiYkxxcHDw8OpHDxPfX39ypUrvby8pk2bRryqbMtpbGysra2dOHEilkddXb25ufnLly9NTU1UKhV/7K66ujo2xnOKn9MYLykpyWm93rx5Y2RkhA3wPY5TRkZm3rx5Fy5csLKyMjU1xf7iRSkpKeEvOjs7KyoqsEM0Vvr6+tjEdUJCQmdnp5ub28uXLx0dHQniRwg5ODgYGRm9efNm9+7dV65cIb4u3i1iYmKshyNkMhm74tDZ2SkpKSkoKIhNWrC2IRMLCwsdHZ3S0tKoqKiMjAxHR8cehMR2uxC3DwAADBSCByUzXpX/1xhPJv9v6h6/Uuvh4TFz5szjx4+PHDkyIyNj27ZtnMrFF8nNzZWXl2f8KC4ubvv27Uz5t2zZgs/Ksi2nubl56dKlRkZGAQEBnColQHCxGYPvrPn4+BjTWePn5Pz582zXy8fHh+swu4hTR0fnyZMnd+/evXv3rqur68GDB11cXLCP8HvIu7yZfNKkSZWVlR8+fODl5RUUFCwvL3/37p2enh5x/BISEhISEpqamlQqddeuXdgYzzjidnnTOyfXr1/HLwbh1qxZs2jRIhKJVF9fj52O//XXXwghcXFx4tLExMTExMRUVVWpVOrJkyexMf7H46TT6b2yfQEAoC8cOHCA4FPsIKCL++pra2vLysr8/PxGjhyJEOryX8PHjh0rLCycl5fHNEYSzNVzKqq9vd3Dw0NOTm7v3r3ElRIQERGRlJQsKirS19dHCL1580ZISGjUqFHi4uK8vLzl5eXYtERZWRlx/Bg+Pj5eXl7GaQaCuVx1dfWMjAw6nd7laShBnNin4uLiTk5OTk5OoqKi2dnZ+BiPPzP47du3PDw8BMclIiIi48ePP3v2LIVCERQUPHPmzNixY6WkpLici6bRaK2trdi6iImJ4fcDsp0mYsXLy8vLy9vW1oancJqr5+fnV1JSKiwspFAoCKGCggJZWVnGiXrsRB/rjazodHpbWxsWp7CwcEtLC5b++fNnbuJkBXP1AIDBKT09nenHa9nqYoyXkJCQlJR8+PDh/Pnz37x5g9+ozAkPD8/atWtDQ0MFBAQ0NTVLSkouXbp05swZKSkpKSmpboSP0OrVqz99+hQUFFRUVIQQ4uXlxafWu8XFxSUyMnLChAm8vLwRERGurq4kEklAQMDJySk6OvrUqVMfP35MTU3FLnVzih8rikwm6+joXL16VVZWVlBQUEJCgmC93N3dY2Jitm3btnz58ra2ths3bgQHB3c3ToRQQkKCuLj4pEmTvn///vjxY8b5mezs7JSUFA0Njf3799vY2BBftNbX1798+fL58+eFhIRcXFysrKwQQpzi//Lly969e62srEaPHl1SUrJ//35LS0ssHm1t7fT0dD8/v6ampmvXrhE3PoZMJqupqf36668jR44UEBAQExMTFxfndHZuZ2cXFxenq6vLw8OTmJjIdD/8pk2bOjs7L1y4gL2tra2Njo6eNm2atLT0hw8fYmNjp06disWprq5+7969pUuXtrS0ZGZmchMnK4Lt29zcXFpaWlJSghB6+/ZtbW3thAkTmCaEAACgjxDM1TPqYownk8lRUVHbt28PDw+Xk5Pz9PSMjY0lXsTPz6+zs3PHjh1fv35VUFCYM2cOtyEzoFKp2D/LzZ07F0sZNWpUfn5+D4ry9/evra1dsmQJnU63srIKCgrC0kNCQvz8/PT09JSUlOzt7fGrF8Txh4eH//zzzxcvXjQxMUlKSiKod+TIkVeuXAkLC7O2thYTE3NycupZnIKCgseOHSstLRUREbG1tWWcJV68eHFMTExRUZGxsXFYWBhx+QYGBqmpqZMnT+bh4eHh4cHvAWRLUFCwpaVl27ZtNTU1I0eOtLGxweNZvnz5kydPDA0NVVRU5s2bd/36deJ68bXbvXt3amrqpEmTIiMjCXIuXLjwy5cvO3fupNPp1tbWS5YsIcgsICDQ1tZ25MiRuro6CQmJ6dOnr169GvvIyckpPz/f2dlZQUFh1qxZ54d75QAAAZVJREFUxP972QOFhYX4Nv3pp58QQg8fPhw3blzv1gIAAJwQzKQmJCQEBgYi7Nmy8Ny5ocjR0dHa2trLy2ugAyEy2H4ZEJ5JAwAY6rDnzgUGBnY5xtvb2w/e37IFAAAAwI+AMR4AAAAYngbv79UDYikpKQMdAgAAgEENxnjQh+D6NwAADCCYqwcAAACGJxjjAQAAgOEJxngAAABgeIIxHgAAABieYIwHAAAAhicY4wEAAIDhCcZ4AAAAYHiCMR4AAAAYnmCMBwAAAIYnGOMBAACA4QnGeAAAAGB4gjEeAAAAGJ5gjAcAAACGJxjjAQAAgOEJxngAAABgeIIxHgAAABieYIwHAAAAhicY4wEAAIDhCcZ4AAAAYHiCMR4AAAAYnmCMBwAAAIYnGOMBAACA4QnGeAAAAGB4gjEeAAAAGJ5gjAcAAACGJxjjAQAAgOEJxngAAABgeIIxHgAAABieYIwHAAAAhicY4wEAAIDhCcZ4AAAAYHiCMR4AAAAYnmCMBwAAAIYnGOMBAACA4QnGeAAAAGB4+n8oLlwBJTnCdAAAAABJRU5ErkJggg==}
B 4 2140 -12040 2650 -11700 {fill=0}
B 5 1027.5 -11002.5 1032.5 -10997.5 {name=p dir=inout}
B 5 1027.5 -10942.5 1032.5 -10937.5 {name=m dir=inout}
B 5 1108.75 -11031.25 1111.25 -11028.75 {name=p dir=out}
B 5 1137.5 -10922.5 1142.5 -10917.5 {name=p dir=inout goto=0}
B 5 1137.5 -11182.5 1142.5 -11177.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -11061.25 1411.25 -11058.75 {name=p dir=in}
B 5 1567.5 -11002.5 1572.5 -10997.5 {name=p dir=inout}
B 5 1567.5 -10942.5 1572.5 -10937.5 {name=m dir=inout}
B 5 1648.75 -11031.25 1651.25 -11028.75 {name=p dir=out}
B 5 1677.5 -10922.5 1682.5 -10917.5 {name=p dir=inout goto=0}
B 5 1677.5 -11182.5 1682.5 -11177.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1948.75 -11061.25 1951.25 -11058.75 {name=p dir=in}
B 5 697.5 -11032.5 702.5 -11027.5 {name=g dir=in}
B 5 497.5 -11002.5 502.5 -10997.5 {name=p dir=inout}
B 5 497.5 -10942.5 502.5 -10937.5 {name=m dir=inout}
B 5 578.75 -11031.25 581.25 -11028.75 {name=p dir=out}
B 5 607.5 -10922.5 612.5 -10917.5 {name=p dir=inout goto=0}
B 5 607.5 -11182.5 612.5 -11177.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -11061.25 881.25 -11058.75 {name=p dir=in}
B 5 737.5 -10602.5 742.5 -10597.5 {name=d dir=inout}
B 5 697.5 -10572.5 702.5 -10567.5 {name=g dir=in}
B 5 737.5 -10542.5 742.5 -10537.5 {name=s dir=inout}
B 5 737.5 -10572.5 742.5 -10567.5 {name=b dir=in}
B 5 737.5 -10692.5 742.5 -10687.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -10632.5 742.5 -10627.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -10602.5 832.5 -10597.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -10542.5 832.5 -10537.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -10542.5 502.5 -10537.5 {name=p dir=inout}
B 5 497.5 -10482.5 502.5 -10477.5 {name=m dir=inout}
B 5 578.75 -10571.25 581.25 -10568.75 {name=p dir=out}
B 5 607.5 -10462.5 612.5 -10457.5 {name=p dir=inout goto=0}
B 5 607.5 -10722.5 612.5 -10717.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -10601.25 881.25 -10598.75 {name=p dir=in}
B 5 1277.5 -10602.5 1282.5 -10597.5 {name=d dir=inout}
B 5 1237.5 -10572.5 1242.5 -10567.5 {name=g dir=in}
B 5 1277.5 -10542.5 1282.5 -10537.5 {name=s dir=inout}
B 5 1277.5 -10572.5 1282.5 -10567.5 {name=b dir=in}
B 5 1367.5 -10602.5 1372.5 -10597.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -10542.5 1372.5 -10537.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -10542.5 1042.5 -10537.5 {name=p dir=inout}
B 5 1037.5 -10482.5 1042.5 -10477.5 {name=m dir=inout}
B 5 1118.75 -10571.25 1121.25 -10568.75 {name=p dir=out}
B 5 1147.5 -10462.5 1152.5 -10457.5 {name=p dir=inout goto=0}
B 5 1147.5 -10722.5 1152.5 -10717.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -10601.25 1421.25 -10598.75 {name=p dir=in}
B 5 737.5 -7012.5 742.5 -7007.5 {name=d dir=inout}
B 5 697.5 -6982.5 702.5 -6977.5 {name=g dir=in}
B 5 737.5 -6952.5 742.5 -6947.5 {name=s dir=inout}
B 5 737.5 -6982.5 742.5 -6977.5 {name=b dir=in}
B 5 737.5 -7102.5 742.5 -7097.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -7042.5 742.5 -7037.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -7012.5 832.5 -7007.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -6952.5 832.5 -6947.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -6952.5 502.5 -6947.5 {name=p dir=inout}
B 5 497.5 -6892.5 502.5 -6887.5 {name=m dir=inout}
B 5 578.75 -6981.25 581.25 -6978.75 {name=p dir=out}
B 5 607.5 -6872.5 612.5 -6867.5 {name=p dir=inout goto=0}
B 5 607.5 -7132.5 612.5 -7127.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -7011.25 881.25 -7008.75 {name=p dir=in}
B 5 1277.5 -7012.5 1282.5 -7007.5 {name=d dir=inout}
B 5 1237.5 -6982.5 1242.5 -6977.5 {name=g dir=in}
B 5 1277.5 -6952.5 1282.5 -6947.5 {name=s dir=inout}
B 5 1277.5 -6982.5 1282.5 -6977.5 {name=b dir=in}
B 5 1367.5 -7012.5 1372.5 -7007.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -6952.5 1372.5 -6947.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -6952.5 1042.5 -6947.5 {name=p dir=inout}
B 5 1037.5 -6892.5 1042.5 -6887.5 {name=m dir=inout}
B 5 1118.75 -6981.25 1121.25 -6978.75 {name=p dir=out}
B 5 1147.5 -6872.5 1152.5 -6867.5 {name=p dir=inout goto=0}
B 5 1147.5 -7132.5 1152.5 -7127.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -7011.25 1421.25 -7008.75 {name=p dir=in}
B 5 737.5 -6612.5 742.5 -6607.5 {name=d dir=inout}
B 5 697.5 -6582.5 702.5 -6577.5 {name=g dir=in}
B 5 737.5 -6552.5 742.5 -6547.5 {name=s dir=inout}
B 5 737.5 -6582.5 742.5 -6577.5 {name=b dir=in}
B 5 737.5 -6702.5 742.5 -6697.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -6642.5 742.5 -6637.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -6612.5 832.5 -6607.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -6552.5 832.5 -6547.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -6552.5 502.5 -6547.5 {name=p dir=inout}
B 5 497.5 -6492.5 502.5 -6487.5 {name=m dir=inout}
B 5 578.75 -6581.25 581.25 -6578.75 {name=p dir=out}
B 5 607.5 -6472.5 612.5 -6467.5 {name=p dir=inout goto=0}
B 5 607.5 -6732.5 612.5 -6727.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -6611.25 881.25 -6608.75 {name=p dir=in}
B 5 1277.5 -6612.5 1282.5 -6607.5 {name=d dir=inout}
B 5 1237.5 -6582.5 1242.5 -6577.5 {name=g dir=in}
B 5 1277.5 -6552.5 1282.5 -6547.5 {name=s dir=inout}
B 5 1277.5 -6582.5 1282.5 -6577.5 {name=b dir=in}
B 5 1367.5 -6612.5 1372.5 -6607.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -6552.5 1372.5 -6547.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -6552.5 1042.5 -6547.5 {name=p dir=inout}
B 5 1037.5 -6492.5 1042.5 -6487.5 {name=m dir=inout}
B 5 1118.75 -6581.25 1121.25 -6578.75 {name=p dir=out}
B 5 1147.5 -6472.5 1152.5 -6467.5 {name=p dir=inout goto=0}
B 5 1147.5 -6732.5 1152.5 -6727.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -6611.25 1421.25 -6608.75 {name=p dir=in}
B 5 697.5 -6142.5 702.5 -6137.5 {name=g dir=in}
B 5 497.5 -6112.5 502.5 -6107.5 {name=p dir=inout}
B 5 497.5 -6052.5 502.5 -6047.5 {name=m dir=inout}
B 5 578.75 -6141.25 581.25 -6138.75 {name=p dir=out}
B 5 607.5 -6032.5 612.5 -6027.5 {name=p dir=inout goto=0}
B 5 607.5 -6292.5 612.5 -6287.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1687.5 -6112.5 1692.5 -6107.5 {name=p dir=inout}
B 5 1687.5 -6052.5 1692.5 -6047.5 {name=m dir=inout}
B 5 1768.75 -6141.25 1771.25 -6138.75 {name=p dir=out}
B 5 1797.5 -6032.5 1802.5 -6027.5 {name=p dir=inout goto=0}
B 5 1797.5 -6292.5 1802.5 -6287.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1057.5 -6112.5 1062.5 -6107.5 {name=p dir=inout}
B 5 1057.5 -6052.5 1062.5 -6047.5 {name=m dir=inout}
B 5 1138.75 -6141.25 1141.25 -6138.75 {name=p dir=out}
B 5 1167.5 -6032.5 1172.5 -6027.5 {name=p dir=inout goto=0}
B 5 1167.5 -6292.5 1172.5 -6287.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1027.5 -10172.5 1032.5 -10167.5 {name=p dir=inout}
B 5 1027.5 -10112.5 1032.5 -10107.5 {name=m dir=inout}
B 5 1108.75 -10201.25 1111.25 -10198.75 {name=p dir=out}
B 5 1137.5 -10092.5 1142.5 -10087.5 {name=p dir=inout goto=0}
B 5 1137.5 -10352.5 1142.5 -10347.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -10231.25 1411.25 -10228.75 {name=p dir=in}
B 5 697.5 -10202.5 702.5 -10197.5 {name=g dir=in}
B 5 497.5 -10172.5 502.5 -10167.5 {name=p dir=inout}
B 5 497.5 -10112.5 502.5 -10107.5 {name=m dir=inout}
B 5 578.75 -10201.25 581.25 -10198.75 {name=p dir=out}
B 5 607.5 -10092.5 612.5 -10087.5 {name=p dir=inout goto=0}
B 5 607.5 -10352.5 612.5 -10347.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -10231.25 881.25 -10228.75 {name=p dir=in}
B 5 1767.5 -10232.5 1772.5 -10227.5 {name=d dir=inout}
B 5 1727.5 -10202.5 1732.5 -10197.5 {name=g dir=in}
B 5 1767.5 -10172.5 1772.5 -10167.5 {name=s dir=inout}
B 5 1767.5 -10202.5 1772.5 -10197.5 {name=b dir=in}
B 5 1767.5 -10322.5 1772.5 -10317.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1767.5 -10262.5 1772.5 -10257.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1857.5 -10232.5 1862.5 -10227.5 {name=p dir=inout pinnumber=1}
B 5 1857.5 -10172.5 1862.5 -10167.5 {name=m dir=inout pinnumber=2}
B 5 1527.5 -10172.5 1532.5 -10167.5 {name=p dir=inout}
B 5 1527.5 -10112.5 1532.5 -10107.5 {name=m dir=inout}
B 5 1608.75 -10201.25 1611.25 -10198.75 {name=p dir=out}
B 5 1637.5 -10092.5 1642.5 -10087.5 {name=p dir=inout goto=0}
B 5 1637.5 -10352.5 1642.5 -10347.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1908.75 -10231.25 1911.25 -10228.75 {name=p dir=in}
B 5 1648.75 -11501.25 1651.25 -11498.75 {name=p dir=out}
B 5 1677.5 -11392.5 1682.5 -11387.5 {name=p dir=inout goto=0}
B 5 1677.5 -11652.5 1682.5 -11647.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1948.75 -11531.25 1951.25 -11528.75 {name=p dir=in}
B 5 642.5 -11502.5 647.5 -11497.5 {name=g dir=in}
B 5 442.5 -11472.5 447.5 -11467.5 {name=p dir=inout}
B 5 442.5 -11412.5 447.5 -11407.5 {name=m dir=inout}
B 5 523.75 -11501.25 526.25 -11498.75 {name=p dir=out}
B 5 552.5 -11392.5 557.5 -11387.5 {name=p dir=inout goto=0}
B 5 552.5 -11652.5 557.5 -11647.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 823.75 -11531.25 826.25 -11528.75 {name=p dir=in}
B 5 2108.75 -11501.25 2111.25 -11498.75 {name=p dir=out}
B 5 2137.5 -11392.5 2142.5 -11387.5 {name=p dir=inout goto=0}
B 5 2137.5 -11652.5 2142.5 -11647.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2408.75 -11531.25 2411.25 -11528.75 {name=p dir=in}
B 5 2357.5 -11532.5 2362.5 -11527.5 {name=p dir=inout pinnumber=1}
B 5 2357.5 -11472.5 2362.5 -11467.5 {name=m dir=inout pinnumber=2}
B 5 757.5 -9392.5 762.5 -9387.5 {name=d dir=inout}
B 5 717.5 -9362.5 722.5 -9357.5 {name=g dir=in}
B 5 757.5 -9332.5 762.5 -9327.5 {name=s dir=inout}
B 5 757.5 -9362.5 762.5 -9357.5 {name=b dir=in}
B 5 757.5 -9482.5 762.5 -9477.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -9422.5 762.5 -9417.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 847.5 -9392.5 852.5 -9387.5 {name=p dir=inout pinnumber=1}
B 5 847.5 -9332.5 852.5 -9327.5 {name=m dir=inout pinnumber=2}
B 5 517.5 -9332.5 522.5 -9327.5 {name=p dir=inout}
B 5 517.5 -9272.5 522.5 -9267.5 {name=m dir=inout}
B 5 598.75 -9361.25 601.25 -9358.75 {name=p dir=out}
B 5 627.5 -9252.5 632.5 -9247.5 {name=p dir=inout goto=0}
B 5 627.5 -9512.5 632.5 -9507.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 898.75 -9391.25 901.25 -9388.75 {name=p dir=in}
B 5 1297.5 -9392.5 1302.5 -9387.5 {name=d dir=inout}
B 5 1257.5 -9362.5 1262.5 -9357.5 {name=g dir=in}
B 5 1297.5 -9332.5 1302.5 -9327.5 {name=s dir=inout}
B 5 1297.5 -9362.5 1302.5 -9357.5 {name=b dir=in}
B 5 1297.5 -9482.5 1302.5 -9477.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1297.5 -9422.5 1302.5 -9417.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1387.5 -9392.5 1392.5 -9387.5 {name=p dir=inout pinnumber=1}
B 5 1387.5 -9332.5 1392.5 -9327.5 {name=m dir=inout pinnumber=2}
B 5 1057.5 -9332.5 1062.5 -9327.5 {name=p dir=inout}
B 5 1057.5 -9272.5 1062.5 -9267.5 {name=m dir=inout}
B 5 1138.75 -9361.25 1141.25 -9358.75 {name=p dir=out}
B 5 1167.5 -9252.5 1172.5 -9247.5 {name=p dir=inout goto=0}
B 5 1167.5 -9512.5 1172.5 -9507.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1438.75 -9391.25 1441.25 -9388.75 {name=p dir=in}
B 5 2427.5 -9392.5 2432.5 -9387.5 {name=d dir=inout}
B 5 2387.5 -9362.5 2392.5 -9357.5 {name=g dir=in}
B 5 2427.5 -9332.5 2432.5 -9327.5 {name=s dir=inout}
B 5 2427.5 -9362.5 2432.5 -9357.5 {name=b dir=in}
B 5 2427.5 -9482.5 2432.5 -9477.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -9422.5 2432.5 -9417.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2517.5 -9392.5 2522.5 -9387.5 {name=p dir=inout pinnumber=1}
B 5 2517.5 -9332.5 2522.5 -9327.5 {name=m dir=inout pinnumber=2}
B 5 2187.5 -9332.5 2192.5 -9327.5 {name=p dir=inout}
B 5 2187.5 -9272.5 2192.5 -9267.5 {name=m dir=inout}
B 5 2268.75 -9361.25 2271.25 -9358.75 {name=p dir=out}
B 5 2297.5 -9252.5 2302.5 -9247.5 {name=p dir=inout goto=0}
B 5 2297.5 -9512.5 2302.5 -9507.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2568.75 -9391.25 2571.25 -9388.75 {name=p dir=in}
B 5 817.5 -5302.5 822.5 -5297.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -5242.5 822.5 -5237.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -5242.5 822.5 -5237.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -5182.5 822.5 -5177.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -5182.5 1362.5 -5177.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -5342.5 1902.5 -5337.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -5282.5 1902.5 -5277.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -5242.5 1902.5 -5237.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -5182.5 1902.5 -5177.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -4472.5 712.5 -4467.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -4412.5 712.5 -4407.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -4472.5 822.5 -4467.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -4412.5 822.5 -4407.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -4472.5 932.5 -4467.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -4412.5 932.5 -4407.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -4472.5 1252.5 -4467.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -4412.5 1252.5 -4407.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -4472.5 1362.5 -4467.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -4412.5 1362.5 -4407.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -4472.5 1472.5 -4467.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -4412.5 1472.5 -4407.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -4472.5 1792.5 -4467.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -4412.5 1792.5 -4407.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -4472.5 1902.5 -4467.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -4412.5 1902.5 -4407.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -4472.5 2012.5 -4467.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -4412.5 2012.5 -4407.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2317.5 -4472.5 2322.5 -4467.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2317.5 -4412.5 2322.5 -4407.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2427.5 -4472.5 2432.5 -4467.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -4412.5 2432.5 -4407.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2537.5 -4472.5 2542.5 -4467.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2537.5 -4412.5 2542.5 -4407.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -2542.5 712.5 -2537.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -2482.5 712.5 -2477.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -2542.5 822.5 -2537.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -2482.5 822.5 -2477.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -2542.5 932.5 -2537.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -2482.5 932.5 -2477.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -2452.5 712.5 -2447.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -2392.5 712.5 -2387.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -2452.5 822.5 -2447.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -2392.5 822.5 -2387.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -2452.5 932.5 -2447.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -2392.5 932.5 -2387.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -2452.5 1252.5 -2447.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -2392.5 1252.5 -2387.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -2452.5 1362.5 -2447.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -2392.5 1362.5 -2387.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -2452.5 1472.5 -2447.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -2392.5 1472.5 -2387.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -2452.5 1792.5 -2447.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -2392.5 1792.5 -2387.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -2452.5 1902.5 -2447.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -2392.5 1902.5 -2387.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -2452.5 2012.5 -2447.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -2392.5 2012.5 -2387.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1877.5 -4212.5 1882.5 -4207.5 {name=d dir=inout}
B 5 1837.5 -4182.5 1842.5 -4177.5 {name=g dir=in}
B 5 1877.5 -4152.5 1882.5 -4147.5 {name=s dir=inout}
B 5 1877.5 -4182.5 1882.5 -4177.5 {name=b dir=in}
B 5 1108.75 -11501.25 1111.25 -11498.75 {name=p dir=out}
B 5 1137.5 -11392.5 1142.5 -11387.5 {name=p dir=inout goto=0}
B 5 1137.5 -11652.5 1142.5 -11647.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -11531.25 1411.25 -11528.75 {name=p dir=in}
B 5 1027.5 -11472.5 1032.5 -11467.5 {name=p dir=inout}
B 5 1027.5 -11412.5 1032.5 -11407.5 {name=m dir=inout}
B 5 707.5 -2162.5 712.5 -2157.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -2102.5 712.5 -2097.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -2162.5 822.5 -2157.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -2102.5 822.5 -2097.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -2162.5 932.5 -2157.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -2102.5 932.5 -2097.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -2102.5 712.5 -2097.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -2042.5 712.5 -2037.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -2102.5 822.5 -2097.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -2042.5 822.5 -2037.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -2102.5 932.5 -2097.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -2042.5 932.5 -2037.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -2102.5 1252.5 -2097.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -2042.5 1252.5 -2037.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -2102.5 1362.5 -2097.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -2042.5 1362.5 -2037.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -2102.5 1472.5 -2097.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -2042.5 1472.5 -2037.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -2072.5 1792.5 -2067.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -2012.5 1792.5 -2007.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -2072.5 1902.5 -2067.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -2012.5 1902.5 -2007.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -2072.5 2012.5 -2067.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -2012.5 2012.5 -2007.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1757.5 -2852.5 1762.5 -2847.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1757.5 -2792.5 1762.5 -2787.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1877.5 -2852.5 1882.5 -2847.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1877.5 -2792.5 1882.5 -2787.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 797.5 -2922.5 802.5 -2917.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -1702.5 822.5 -1697.5 {name=d dir=inout}
B 5 777.5 -1672.5 782.5 -1667.5 {name=g dir=in}
B 5 817.5 -1642.5 822.5 -1637.5 {name=s dir=inout}
B 5 817.5 -1672.5 822.5 -1667.5 {name=b dir=in}
B 5 817.5 -1792.5 822.5 -1787.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -1732.5 822.5 -1727.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 907.5 -1702.5 912.5 -1697.5 {name=p dir=inout pinnumber=1}
B 5 907.5 -1642.5 912.5 -1637.5 {name=m dir=inout pinnumber=2}
B 5 577.5 -1642.5 582.5 -1637.5 {name=p dir=inout}
B 5 577.5 -1582.5 582.5 -1577.5 {name=m dir=inout}
B 5 658.75 -1671.25 661.25 -1668.75 {name=p dir=out}
B 5 687.5 -1562.5 692.5 -1557.5 {name=p dir=inout goto=0}
B 5 687.5 -1822.5 692.5 -1817.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 958.75 -1701.25 961.25 -1698.75 {name=p dir=in}
B 5 1417.5 -1702.5 1422.5 -1697.5 {name=d dir=inout}
B 5 1377.5 -1672.5 1382.5 -1667.5 {name=g dir=in}
B 5 1417.5 -1642.5 1422.5 -1637.5 {name=s dir=inout}
B 5 1417.5 -1672.5 1422.5 -1667.5 {name=b dir=in}
B 5 1417.5 -1792.5 1422.5 -1787.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1417.5 -1732.5 1422.5 -1727.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1177.5 -1642.5 1182.5 -1637.5 {name=p dir=inout}
B 5 1177.5 -1582.5 1182.5 -1577.5 {name=m dir=inout}
B 5 1258.75 -1671.25 1261.25 -1668.75 {name=p dir=out}
B 5 1287.5 -1562.5 1292.5 -1557.5 {name=p dir=inout goto=0}
B 5 1287.5 -1822.5 1292.5 -1817.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1558.75 -1701.25 1561.25 -1698.75 {name=p dir=in}
B 5 2027.5 -1702.5 2032.5 -1697.5 {name=d dir=inout}
B 5 1987.5 -1672.5 1992.5 -1667.5 {name=g dir=in}
B 5 2027.5 -1642.5 2032.5 -1637.5 {name=s dir=inout}
B 5 2027.5 -1672.5 2032.5 -1667.5 {name=b dir=in}
B 5 2027.5 -1792.5 2032.5 -1787.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2027.5 -1732.5 2032.5 -1727.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -1642.5 1792.5 -1637.5 {name=p dir=inout}
B 5 1787.5 -1582.5 1792.5 -1577.5 {name=m dir=inout}
B 5 1868.75 -1671.25 1871.25 -1668.75 {name=p dir=out}
B 5 1897.5 -1562.5 1902.5 -1557.5 {name=p dir=inout goto=0}
B 5 1897.5 -1822.5 1902.5 -1817.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2168.75 -1701.25 2171.25 -1698.75 {name=p dir=in}
B 5 357.5 -9002.5 362.5 -8997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 557.5 -9002.5 562.5 -8997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 797.5 -9002.5 802.5 -8997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1087.5 -9002.5 1092.5 -8997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1317.5 -9002.5 1322.5 -8997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 357.5 -8942.5 362.5 -8937.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 557.5 -8942.5 562.5 -8937.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 797.5 -8942.5 802.5 -8937.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1087.5 -8942.5 1092.5 -8937.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1317.5 -8942.5 1322.5 -8937.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1607.5 -9002.5 1612.5 -8997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1607.5 -8942.5 1612.5 -8937.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1847.5 -9002.5 1852.5 -8997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1847.5 -8942.5 1852.5 -8937.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2147.5 -9002.5 2152.5 -8997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2147.5 -8942.5 2152.5 -8937.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -5762.5 762.5 -5757.5 {name=d dir=inout}
B 5 717.5 -5732.5 722.5 -5727.5 {name=g dir=in}
B 5 757.5 -5702.5 762.5 -5697.5 {name=s dir=inout}
B 5 757.5 -5732.5 762.5 -5727.5 {name=b dir=in}
B 5 757.5 -5852.5 762.5 -5847.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -5792.5 762.5 -5787.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 517.5 -5702.5 522.5 -5697.5 {name=p dir=inout}
B 5 517.5 -5642.5 522.5 -5637.5 {name=m dir=inout}
B 5 598.75 -5731.25 601.25 -5728.75 {name=p dir=out}
B 5 627.5 -5622.5 632.5 -5617.5 {name=p dir=inout goto=0}
B 5 627.5 -5882.5 632.5 -5877.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 898.75 -5761.25 901.25 -5758.75 {name=p dir=in}
B 5 1317.5 -5762.5 1322.5 -5757.5 {name=d dir=inout}
B 5 1277.5 -5732.5 1282.5 -5727.5 {name=g dir=in}
B 5 1317.5 -5702.5 1322.5 -5697.5 {name=s dir=inout}
B 5 1317.5 -5732.5 1322.5 -5727.5 {name=b dir=in}
B 5 1317.5 -5852.5 1322.5 -5847.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1317.5 -5792.5 1322.5 -5787.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1077.5 -5702.5 1082.5 -5697.5 {name=p dir=inout}
B 5 1077.5 -5642.5 1082.5 -5637.5 {name=m dir=inout}
B 5 1158.75 -5731.25 1161.25 -5728.75 {name=p dir=out}
B 5 1187.5 -5622.5 1192.5 -5617.5 {name=p dir=inout goto=0}
B 5 1187.5 -5882.5 1192.5 -5877.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1458.75 -5761.25 1461.25 -5758.75 {name=p dir=in}
B 5 702.5 -9812.5 707.5 -9807.5 {name=d dir=inout}
B 5 662.5 -9782.5 667.5 -9777.5 {name=g dir=in}
B 5 702.5 -9752.5 707.5 -9747.5 {name=s dir=inout}
B 5 702.5 -9782.5 707.5 -9777.5 {name=b dir=in}
B 5 702.5 -9902.5 707.5 -9897.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 702.5 -9842.5 707.5 -9837.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 792.5 -9812.5 797.5 -9807.5 {name=p dir=inout pinnumber=1}
B 5 792.5 -9752.5 797.5 -9747.5 {name=m dir=inout pinnumber=2}
B 5 462.5 -9752.5 467.5 -9747.5 {name=p dir=inout}
B 5 462.5 -9692.5 467.5 -9687.5 {name=m dir=inout}
B 5 543.75 -9781.25 546.25 -9778.75 {name=p dir=out}
B 5 572.5 -9672.5 577.5 -9667.5 {name=p dir=inout goto=0}
B 5 572.5 -9932.5 577.5 -9927.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 843.75 -9811.25 846.25 -9808.75 {name=p dir=in}
B 5 1267.5 -9812.5 1272.5 -9807.5 {name=d dir=inout}
B 5 1227.5 -9782.5 1232.5 -9777.5 {name=g dir=in}
B 5 1267.5 -9752.5 1272.5 -9747.5 {name=s dir=inout}
B 5 1267.5 -9782.5 1272.5 -9777.5 {name=b dir=in}
B 5 1267.5 -9902.5 1272.5 -9897.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1267.5 -9842.5 1272.5 -9837.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -9812.5 1362.5 -9807.5 {name=p dir=inout pinnumber=1}
B 5 1357.5 -9752.5 1362.5 -9747.5 {name=m dir=inout pinnumber=2}
B 5 1027.5 -9752.5 1032.5 -9747.5 {name=p dir=inout}
B 5 1027.5 -9692.5 1032.5 -9687.5 {name=m dir=inout}
B 5 1108.75 -9781.25 1111.25 -9778.75 {name=p dir=out}
B 5 1137.5 -9672.5 1142.5 -9667.5 {name=p dir=inout goto=0}
B 5 1137.5 -9932.5 1142.5 -9927.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -9811.25 1411.25 -9808.75 {name=p dir=in}
B 5 1767.5 -9812.5 1772.5 -9807.5 {name=d dir=inout}
B 5 1727.5 -9782.5 1732.5 -9777.5 {name=g dir=in}
B 5 1767.5 -9752.5 1772.5 -9747.5 {name=s dir=inout}
B 5 1767.5 -9782.5 1772.5 -9777.5 {name=b dir=in}
B 5 1767.5 -9902.5 1772.5 -9897.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1767.5 -9842.5 1772.5 -9837.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1857.5 -9812.5 1862.5 -9807.5 {name=p dir=inout pinnumber=1}
B 5 1857.5 -9752.5 1862.5 -9747.5 {name=m dir=inout pinnumber=2}
B 5 1527.5 -9752.5 1532.5 -9747.5 {name=p dir=inout}
B 5 1527.5 -9692.5 1532.5 -9687.5 {name=m dir=inout}
B 5 1608.75 -9781.25 1611.25 -9778.75 {name=p dir=out}
B 5 1637.5 -9672.5 1642.5 -9667.5 {name=p dir=inout goto=0}
B 5 1637.5 -9932.5 1642.5 -9927.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1908.75 -9811.25 1911.25 -9808.75 {name=p dir=in}
B 5 2257.5 -9812.5 2262.5 -9807.5 {name=d dir=inout}
B 5 2217.5 -9782.5 2222.5 -9777.5 {name=g dir=in}
B 5 2257.5 -9752.5 2262.5 -9747.5 {name=s dir=inout}
B 5 2257.5 -9782.5 2262.5 -9777.5 {name=b dir=in}
B 5 2257.5 -9902.5 2262.5 -9897.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2257.5 -9842.5 2262.5 -9837.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2347.5 -9812.5 2352.5 -9807.5 {name=p dir=inout pinnumber=1}
B 5 2347.5 -9752.5 2352.5 -9747.5 {name=m dir=inout pinnumber=2}
B 5 2017.5 -9752.5 2022.5 -9747.5 {name=p dir=inout}
B 5 2017.5 -9692.5 2022.5 -9687.5 {name=m dir=inout}
B 5 2098.75 -9781.25 2101.25 -9778.75 {name=p dir=out}
B 5 2127.5 -9672.5 2132.5 -9667.5 {name=p dir=inout goto=0}
B 5 2127.5 -9932.5 2132.5 -9927.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2398.75 -9811.25 2401.25 -9808.75 {name=p dir=in}
B 5 417.5 -9002.5 422.5 -8997.5 {name=p dir=inout pinnumber=1}
B 5 417.5 -8942.5 422.5 -8937.5 {name=m dir=inout pinnumber=2}
B 5 617.5 -9002.5 622.5 -8997.5 {name=p dir=inout pinnumber=1}
B 5 617.5 -8942.5 622.5 -8937.5 {name=m dir=inout pinnumber=2}
B 5 857.5 -9002.5 862.5 -8997.5 {name=p dir=inout pinnumber=1}
B 5 857.5 -8942.5 862.5 -8937.5 {name=m dir=inout pinnumber=2}
B 5 1147.5 -9002.5 1152.5 -8997.5 {name=p dir=inout pinnumber=1}
B 5 1147.5 -8942.5 1152.5 -8937.5 {name=m dir=inout pinnumber=2}
B 5 1377.5 -9002.5 1382.5 -8997.5 {name=p dir=inout pinnumber=1}
B 5 1377.5 -8942.5 1382.5 -8937.5 {name=m dir=inout pinnumber=2}
B 5 1667.5 -9002.5 1672.5 -8997.5 {name=p dir=inout pinnumber=1}
B 5 1667.5 -8942.5 1672.5 -8937.5 {name=m dir=inout pinnumber=2}
B 5 1907.5 -9002.5 1912.5 -8997.5 {name=p dir=inout pinnumber=1}
B 5 1907.5 -8942.5 1912.5 -8937.5 {name=m dir=inout pinnumber=2}
B 5 2207.5 -9002.5 2212.5 -8997.5 {name=p dir=inout pinnumber=1}
B 5 2207.5 -8942.5 2212.5 -8937.5 {name=m dir=inout pinnumber=2}
B 5 2357.5 -9002.5 2362.5 -8997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2357.5 -8942.5 2362.5 -8937.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2417.5 -9002.5 2422.5 -8997.5 {name=p dir=inout pinnumber=1}
B 5 2417.5 -8942.5 2422.5 -8937.5 {name=m dir=inout pinnumber=2}
B 5 1667.5 -1032.5 1672.5 -1027.5 {name=CODE[5:0] dir=out }
B 5 2197.5 -1032.5 2202.5 -1027.5 {name=CODE[5:0] dir=out }
B 5 1968.75 -1031.25 1971.25 -1028.75 {name=p dir=in}
B 5 1968.75 -1011.25 1971.25 -1008.75 {name=p dir=in}
B 5 1968.75 -991.25 1971.25 -988.75 {name=p dir=in}
B 5 1968.75 -971.25 1971.25 -968.75 {name=p dir=in}
B 5 578.75 -661.25 581.25 -658.75 {name=p dir=in}
B 5 577.5 -332.5 582.5 -327.5 {name=d dir=inout}
B 5 537.5 -362.5 542.5 -357.5 {name=g dir=in}
B 5 577.5 -392.5 582.5 -387.5 {name=s dir=inout}
B 5 577.5 -362.5 582.5 -357.5 {name=b dir=in}
B 5 707.5 -332.5 712.5 -327.5 {name=d dir=inout}
B 5 667.5 -362.5 672.5 -357.5 {name=g dir=in}
B 5 707.5 -392.5 712.5 -387.5 {name=s dir=inout}
B 5 707.5 -362.5 712.5 -357.5 {name=b dir=in}
B 5 577.5 -192.5 582.5 -187.5 {name=d dir=inout}
B 5 537.5 -162.5 542.5 -157.5 {name=g dir=in}
B 5 577.5 -132.5 582.5 -127.5 {name=s dir=inout}
B 5 577.5 -162.5 582.5 -157.5 {name=b dir=in}
B 5 577.5 -112.5 582.5 -107.5 {name=d dir=inout}
B 5 537.5 -82.5 542.5 -77.5 {name=g dir=in}
B 5 577.5 -52.5 582.5 -47.5 {name=s dir=inout}
B 5 577.5 -82.5 582.5 -77.5 {name=b dir=in}
B 5 2237.5 -332.5 2242.5 -327.5 {name=d dir=inout}
B 5 2197.5 -362.5 2202.5 -357.5 {name=g dir=in}
B 5 2237.5 -392.5 2242.5 -387.5 {name=s dir=inout}
B 5 2237.5 -362.5 2242.5 -357.5 {name=b dir=in}
B 5 2367.5 -332.5 2372.5 -327.5 {name=d dir=inout}
B 5 2327.5 -362.5 2332.5 -357.5 {name=g dir=in}
B 5 2367.5 -392.5 2372.5 -387.5 {name=s dir=inout}
B 5 2367.5 -362.5 2372.5 -357.5 {name=b dir=in}
B 5 2237.5 -192.5 2242.5 -187.5 {name=d dir=inout}
B 5 2197.5 -162.5 2202.5 -157.5 {name=g dir=in}
B 5 2237.5 -132.5 2242.5 -127.5 {name=s dir=inout}
B 5 2237.5 -162.5 2242.5 -157.5 {name=b dir=in}
B 5 2237.5 -112.5 2242.5 -107.5 {name=d dir=inout}
B 5 2197.5 -82.5 2202.5 -77.5 {name=g dir=in}
B 5 2237.5 -52.5 2242.5 -47.5 {name=s dir=inout}
B 5 2237.5 -82.5 2242.5 -77.5 {name=b dir=in}
A 1 1220 -3840 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1340 -3840 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1850 -3840 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1970 -3840 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1280 -3560 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1910 -3560 5.590169943749475 333.434948822922 360 {fill=1}
A 1 740 -3160 5.590169943749475 333.434948822922 360 {fill=1}
A 2 1570 -11440 15 270 360 {}
A 2 2030 -11440 15 270 360 {}
A 2 530 -8160 15 270 360 {}
A 2 1005 -8160 15 270 360 {}
A 2 1640 -8370 15 180 360 {}
A 2 530 -7730 15 270 360 {}
A 2 980 -7730 15 270 360 {}
A 2 1840 -7730 15 270 360 {}
A 4 1030 -10970 15 270 360 {}
A 4 1570 -10970 15 270 360 {}
A 4 500 -10970 15 270 360 {}
A 4 500 -10510 15 270 360 {}
A 4 1040 -10510 15 270 360 {}
A 4 500 -6920 15 270 360 {}
A 4 1040 -6920 15 270 360 {}
A 4 500 -6520 15 270 360 {}
A 4 1040 -6520 15 270 360 {}
A 4 500 -6080 15 270 360 {}
A 4 1690 -6080 15 270 360 {}
A 4 1060 -6080 15 270 360 {}
A 4 1030 -10140 15 270 360 {}
A 4 500 -10140 15 270 360 {}
A 4 1530 -10140 15 270 360 {}
A 4 445 -11440 15 270 360 {}
A 4 520 -9300 15 270 360 {}
A 4 1060 -9300 15 270 360 {}
A 4 2190 -9300 15 270 360 {}
A 4 1030 -11440 15 270 360 {}
A 4 580 -1610 15 270 360 {}
A 4 1180 -1610 15 270 360 {}
A 4 1790 -1610 15 270 360 {}
A 4 520 -5670 15 270 360 {}
A 4 1080 -5670 15 270 360 {}
A 4 465 -9720 15 270 360 {}
A 4 1030 -9720 15 270 360 {}
A 4 1530 -9720 15 270 360 {}
A 4 2020 -9720 15 270 360 {}
A 5 1360 -4920 5.590169943749475 333.434948822922 360 {fill=1}
P 1 14 920 -10890 942.5 -10890 947.5 -10890 947.5 -10885 947.5 -10842.5 940 -10817.5 935 -10817.5 905 -10817.5 900 -10817.5 892.5 -10842.5 892.5 -10885 892.5 -10890 897.5 -10890 920 -10890 {bezier=1}
P 1 14 935 -10887.5 940 -10887.5 945 -10887.5 945 -10882.5 945 -10862.5 945 -10857.5 940 -10857.5 930 -10857.5 925 -10857.5 925 -10862.5 925 -10882.5 925 -10887.5 930 -10887.5 935 -10887.5 {bezier=1}
P 1 5 917.5 -10885 922.5 -10885 922.5 -10860 917.5 -10860 917.5 -10885 {}
P 1 14 1350 -10890 1372.5 -10890 1377.5 -10890 1377.5 -10885 1377.5 -10842.5 1370 -10817.5 1365 -10817.5 1335 -10817.5 1330 -10817.5 1322.5 -10842.5 1322.5 -10885 1322.5 -10890 1327.5 -10890 1350 -10890 {bezier=1}
P 1 14 1365 -10887.5 1370 -10887.5 1375 -10887.5 1375 -10882.5 1375 -10862.5 1375 -10857.5 1370 -10857.5 1360 -10857.5 1355 -10857.5 1355 -10862.5 1355 -10882.5 1355 -10887.5 1360 -10887.5 1365 -10887.5 {bezier=1}
P 1 5 1347.5 -10885 1352.5 -10885 1352.5 -10860 1347.5 -10860 1347.5 -10885 {}
P 1 14 2120 -10890 2142.5 -10890 2147.5 -10890 2147.5 -10885 2147.5 -10842.5 2140 -10817.5 2135 -10817.5 2105 -10817.5 2100 -10817.5 2092.5 -10842.5 2092.5 -10885 2092.5 -10890 2097.5 -10890 2120 -10890 {bezier=1}
P 1 14 2135 -10887.5 2140 -10887.5 2145 -10887.5 2145 -10882.5 2145 -10862.5 2145 -10857.5 2140 -10857.5 2130 -10857.5 2125 -10857.5 2125 -10862.5 2125 -10882.5 2125 -10887.5 2130 -10887.5 2135 -10887.5 {bezier=1}
P 1 5 2117.5 -10885 2122.5 -10885 2122.5 -10860 2117.5 -10860 2117.5 -10885 {}
P 1 14 1420 -10700 1442.5 -10700 1447.5 -10700 1447.5 -10695 1447.5 -10652.5 1440 -10627.5 1435 -10627.5 1405 -10627.5 1400 -10627.5 1392.5 -10652.5 1392.5 -10695 1392.5 -10700 1397.5 -10700 1420 -10700 {bezier=1}
P 1 14 1435 -10697.5 1440 -10697.5 1445 -10697.5 1445 -10692.5 1445 -10672.5 1445 -10667.5 1440 -10667.5 1430 -10667.5 1425 -10667.5 1425 -10672.5 1425 -10692.5 1425 -10697.5 1430 -10697.5 1435 -10697.5 {bezier=1}
P 1 5 1417.5 -10695 1422.5 -10695 1422.5 -10670 1417.5 -10670 1417.5 -10695 {}
P 1 14 1440 -7120 1462.5 -7120 1467.5 -7120 1467.5 -7115 1467.5 -7072.5 1460 -7047.5 1455 -7047.5 1425 -7047.5 1420 -7047.5 1412.5 -7072.5 1412.5 -7115 1412.5 -7120 1417.5 -7120 1440 -7120 {bezier=1}
P 1 14 1455 -7117.5 1460 -7117.5 1465 -7117.5 1465 -7112.5 1465 -7092.5 1465 -7087.5 1460 -7087.5 1450 -7087.5 1445 -7087.5 1445 -7092.5 1445 -7112.5 1445 -7117.5 1450 -7117.5 1455 -7117.5 {bezier=1}
P 1 5 1437.5 -7115 1442.5 -7115 1442.5 -7090 1437.5 -7090 1437.5 -7115 {}
P 1 10 1520 -7075 1545 -7075 1555 -7065 1555 -7035 1545 -7025 1495 -7025 1485 -7035 1485 -7065 1495 -7075 1520 -7075 {bezier=1}
P 1 10 1520 -7080 1550 -7080 1560 -7070 1560 -7030 1550 -7020 1490 -7020 1480 -7030 1480 -7070 1490 -7080 1520 -7080 {bezier=1}
P 1 14 1440 -6720 1462.5 -6720 1467.5 -6720 1467.5 -6715 1467.5 -6672.5 1460 -6647.5 1455 -6647.5 1425 -6647.5 1420 -6647.5 1412.5 -6672.5 1412.5 -6715 1412.5 -6720 1417.5 -6720 1440 -6720 {bezier=1}
P 1 14 1455 -6717.5 1460 -6717.5 1465 -6717.5 1465 -6712.5 1465 -6692.5 1465 -6687.5 1460 -6687.5 1450 -6687.5 1445 -6687.5 1445 -6692.5 1445 -6712.5 1445 -6717.5 1450 -6717.5 1455 -6717.5 {bezier=1}
P 1 5 1437.5 -6715 1442.5 -6715 1442.5 -6690 1437.5 -6690 1437.5 -6715 {}
P 1 10 1520 -7145 1545 -7145 1555 -7135 1555 -7105 1545 -7095 1495 -7095 1485 -7105 1485 -7135 1495 -7145 1520 -7145 {bezier=1}
P 1 10 1520 -7150 1550 -7150 1560 -7140 1560 -7100 1550 -7090 1490 -7090 1480 -7100 1480 -7140 1490 -7150 1520 -7150 {bezier=1}
P 1 14 950 -6040 972.5 -6040 977.5 -6040 977.5 -6035 977.5 -5992.5 970 -5967.5 965 -5967.5 935 -5967.5 930 -5967.5 922.5 -5992.5 922.5 -6035 922.5 -6040 927.5 -6040 950 -6040 {bezier=1}
P 1 14 965 -6037.5 970 -6037.5 975 -6037.5 975 -6032.5 975 -6012.5 975 -6007.5 970 -6007.5 960 -6007.5 955 -6007.5 955 -6012.5 955 -6032.5 955 -6037.5 960 -6037.5 965 -6037.5 {bezier=1}
P 1 5 947.5 -6035 952.5 -6035 952.5 -6010 947.5 -6010 947.5 -6035 {}
P 1 14 1450 -6050 1472.5 -6050 1477.5 -6050 1477.5 -6045 1477.5 -6002.5 1470 -5977.5 1465 -5977.5 1435 -5977.5 1430 -5977.5 1422.5 -6002.5 1422.5 -6045 1422.5 -6050 1427.5 -6050 1450 -6050 {bezier=1}
P 1 14 1465 -6047.5 1470 -6047.5 1475 -6047.5 1475 -6042.5 1475 -6022.5 1475 -6017.5 1470 -6017.5 1460 -6017.5 1455 -6017.5 1455 -6022.5 1455 -6042.5 1455 -6047.5 1460 -6047.5 1465 -6047.5 {bezier=1}
P 1 5 1447.5 -6045 1452.5 -6045 1452.5 -6020 1447.5 -6020 1447.5 -6045 {}
P 1 10 1540 -6035 1565 -6035 1575 -6025 1575 -5995 1565 -5985 1515 -5985 1505 -5995 1505 -6025 1515 -6035 1540 -6035 {bezier=1}
P 1 10 1540 -6040 1570 -6040 1580 -6030 1580 -5990 1570 -5980 1510 -5980 1500 -5990 1500 -6030 1510 -6040 1540 -6040 {bezier=1}
P 1 14 920 -10060 942.5 -10060 947.5 -10060 947.5 -10055 947.5 -10012.5 940 -9987.5 935 -9987.5 905 -9987.5 900 -9987.5 892.5 -10012.5 892.5 -10055 892.5 -10060 897.5 -10060 920 -10060 {bezier=1}
P 1 14 935 -10057.5 940 -10057.5 945 -10057.5 945 -10052.5 945 -10032.5 945 -10027.5 940 -10027.5 930 -10027.5 925 -10027.5 925 -10032.5 925 -10052.5 925 -10057.5 930 -10057.5 935 -10057.5 {bezier=1}
P 1 5 917.5 -10055 922.5 -10055 922.5 -10030 917.5 -10030 917.5 -10055 {}
P 1 14 1350 -10060 1372.5 -10060 1377.5 -10060 1377.5 -10055 1377.5 -10012.5 1370 -9987.5 1365 -9987.5 1335 -9987.5 1330 -9987.5 1322.5 -10012.5 1322.5 -10055 1322.5 -10060 1327.5 -10060 1350 -10060 {bezier=1}
P 1 14 1365 -10057.5 1370 -10057.5 1375 -10057.5 1375 -10052.5 1375 -10032.5 1375 -10027.5 1370 -10027.5 1360 -10027.5 1355 -10027.5 1355 -10032.5 1355 -10052.5 1355 -10057.5 1360 -10057.5 1365 -10057.5 {bezier=1}
P 1 5 1347.5 -10055 1352.5 -10055 1352.5 -10030 1347.5 -10030 1347.5 -10055 {}
P 1 14 2120 -10060 2142.5 -10060 2147.5 -10060 2147.5 -10055 2147.5 -10012.5 2140 -9987.5 2135 -9987.5 2105 -9987.5 2100 -9987.5 2092.5 -10012.5 2092.5 -10055 2092.5 -10060 2097.5 -10060 2120 -10060 {bezier=1}
P 1 14 2135 -10057.5 2140 -10057.5 2145 -10057.5 2145 -10052.5 2145 -10032.5 2145 -10027.5 2140 -10027.5 2130 -10027.5 2125 -10027.5 2125 -10032.5 2125 -10052.5 2125 -10057.5 2130 -10057.5 2135 -10057.5 {bezier=1}
P 1 5 2117.5 -10055 2122.5 -10055 2122.5 -10030 2117.5 -10030 2117.5 -10055 {}
P 1 10 1270 -10055 1295 -10055 1305 -10045 1305 -10015 1295 -10005 1245 -10005 1235 -10015 1235 -10045 1245 -10055 1270 -10055 {bezier=1}
P 1 10 1270 -10060 1300 -10060 1310 -10050 1310 -10010 1300 -10000 1240 -10000 1230 -10010 1230 -10050 1240 -10060 1270 -10060 {bezier=1}
P 1 14 865 -11360 887.5 -11360 892.5 -11360 892.5 -11355 892.5 -11312.5 885 -11287.5 880 -11287.5 850 -11287.5 845 -11287.5 837.5 -11312.5 837.5 -11355 837.5 -11360 842.5 -11360 865 -11360 {bezier=1}
P 1 14 880 -11357.5 885 -11357.5 890 -11357.5 890 -11352.5 890 -11332.5 890 -11327.5 885 -11327.5 875 -11327.5 870 -11327.5 870 -11332.5 870 -11352.5 870 -11357.5 875 -11357.5 880 -11357.5 {bezier=1}
P 1 5 862.5 -11355 867.5 -11355 867.5 -11330 862.5 -11330 862.5 -11355 {}
P 1 14 1630 -11350 1652.5 -11350 1657.5 -11350 1657.5 -11345 1657.5 -11302.5 1650 -11277.5 1645 -11277.5 1615 -11277.5 1610 -11277.5 1602.5 -11302.5 1602.5 -11345 1602.5 -11350 1607.5 -11350 1630 -11350 {bezier=1}
P 1 14 1645 -11347.5 1650 -11347.5 1655 -11347.5 1655 -11342.5 1655 -11322.5 1655 -11317.5 1650 -11317.5 1640 -11317.5 1635 -11317.5 1635 -11322.5 1635 -11342.5 1635 -11347.5 1640 -11347.5 1645 -11347.5 {bezier=1}
P 1 5 1627.5 -11345 1632.5 -11345 1632.5 -11320 1627.5 -11320 1627.5 -11345 {}
P 1 10 1710 -11335 1735 -11335 1745 -11325 1745 -11295 1735 -11285 1685 -11285 1675 -11295 1675 -11325 1685 -11335 1710 -11335 {bezier=1}
P 1 10 1710 -11340 1740 -11340 1750 -11330 1750 -11290 1740 -11280 1680 -11280 1670 -11290 1670 -11330 1680 -11340 1710 -11340 {bezier=1}
P 1 14 2410 -11340 2432.5 -11340 2437.5 -11340 2437.5 -11335 2437.5 -11292.5 2430 -11267.5 2425 -11267.5 2395 -11267.5 2390 -11267.5 2382.5 -11292.5 2382.5 -11335 2382.5 -11340 2387.5 -11340 2410 -11340 {bezier=1}
P 1 14 2425 -11337.5 2430 -11337.5 2435 -11337.5 2435 -11332.5 2435 -11312.5 2435 -11307.5 2430 -11307.5 2420 -11307.5 2415 -11307.5 2415 -11312.5 2415 -11332.5 2415 -11337.5 2420 -11337.5 2425 -11337.5 {bezier=1}
P 1 5 2407.5 -11335 2412.5 -11335 2412.5 -11310 2407.5 -11310 2407.5 -11335 {}
P 1 10 2490 -11325 2515 -11325 2525 -11315 2525 -11285 2515 -11275 2465 -11275 2455 -11285 2455 -11315 2465 -11325 2490 -11325 {bezier=1}
P 1 10 2490 -11330 2520 -11330 2530 -11320 2530 -11280 2520 -11270 2460 -11270 2450 -11280 2450 -11320 2460 -11330 2490 -11330 {bezier=1}
P 1 14 690 -9480 712.5 -9480 717.5 -9480 717.5 -9475 717.5 -9432.5 710 -9407.5 705 -9407.5 675 -9407.5 670 -9407.5 662.5 -9432.5 662.5 -9475 662.5 -9480 667.5 -9480 690 -9480 {bezier=1}
P 1 14 705 -9477.5 710 -9477.5 715 -9477.5 715 -9472.5 715 -9452.5 715 -9447.5 710 -9447.5 700 -9447.5 695 -9447.5 695 -9452.5 695 -9472.5 695 -9477.5 700 -9477.5 705 -9477.5 {bezier=1}
P 1 5 687.5 -9475 692.5 -9475 692.5 -9450 687.5 -9450 687.5 -9475 {}
P 1 14 1350 -9500 1372.5 -9500 1377.5 -9500 1377.5 -9495 1377.5 -9452.5 1370 -9427.5 1365 -9427.5 1335 -9427.5 1330 -9427.5 1322.5 -9452.5 1322.5 -9495 1322.5 -9500 1327.5 -9500 1350 -9500 {bezier=1}
P 1 14 1365 -9497.5 1370 -9497.5 1375 -9497.5 1375 -9492.5 1375 -9472.5 1375 -9467.5 1370 -9467.5 1360 -9467.5 1355 -9467.5 1355 -9472.5 1355 -9492.5 1355 -9497.5 1360 -9497.5 1365 -9497.5 {bezier=1}
P 1 5 1347.5 -9495 1352.5 -9495 1352.5 -9470 1347.5 -9470 1347.5 -9495 {}
P 1 14 2540 -9550 2562.5 -9550 2567.5 -9550 2567.5 -9545 2567.5 -9502.5 2560 -9477.5 2555 -9477.5 2525 -9477.5 2520 -9477.5 2512.5 -9502.5 2512.5 -9545 2512.5 -9550 2517.5 -9550 2540 -9550 {bezier=1}
P 1 14 2555 -9547.5 2560 -9547.5 2565 -9547.5 2565 -9542.5 2565 -9522.5 2565 -9517.5 2560 -9517.5 2550 -9517.5 2545 -9517.5 2545 -9522.5 2545 -9542.5 2545 -9547.5 2550 -9547.5 2555 -9547.5 {bezier=1}
P 1 5 2537.5 -9545 2542.5 -9545 2542.5 -9520 2537.5 -9520 2537.5 -9545 {}
P 1 14 1430 -5260 1452.5 -5260 1457.5 -5260 1457.5 -5255 1457.5 -5212.5 1450 -5187.5 1445 -5187.5 1415 -5187.5 1410 -5187.5 1402.5 -5212.5 1402.5 -5255 1402.5 -5260 1407.5 -5260 1430 -5260 {bezier=1}
P 1 14 1445 -5257.5 1450 -5257.5 1455 -5257.5 1455 -5252.5 1455 -5232.5 1455 -5227.5 1450 -5227.5 1440 -5227.5 1435 -5227.5 1435 -5232.5 1435 -5252.5 1435 -5257.5 1440 -5257.5 1445 -5257.5 {bezier=1}
P 1 5 1427.5 -5255 1432.5 -5255 1432.5 -5230 1427.5 -5230 1427.5 -5255 {}
P 1 10 1430 -5415 1455 -5415 1465 -5405 1465 -5375 1455 -5365 1405 -5365 1395 -5375 1395 -5405 1405 -5415 1430 -5415 {bezier=1}
P 1 10 1430 -5420 1460 -5420 1470 -5410 1470 -5370 1460 -5360 1400 -5360 1390 -5370 1390 -5410 1400 -5420 1430 -5420 {bezier=1}
P 1 10 1430 -5335 1455 -5335 1465 -5325 1465 -5295 1455 -5285 1405 -5285 1395 -5295 1395 -5325 1405 -5335 1430 -5335 {bezier=1}
P 1 10 1430 -5340 1460 -5340 1470 -5330 1470 -5290 1460 -5280 1400 -5280 1390 -5290 1390 -5330 1400 -5340 1430 -5340 {bezier=1}
P 1 14 2080 -2530 2102.5 -2530 2107.5 -2530 2107.5 -2525 2107.5 -2482.5 2100 -2457.5 2095 -2457.5 2065 -2457.5 2060 -2457.5 2052.5 -2482.5 2052.5 -2525 2052.5 -2530 2057.5 -2530 2080 -2530 {bezier=1}
P 1 14 2095 -2527.5 2100 -2527.5 2105 -2527.5 2105 -2522.5 2105 -2502.5 2105 -2497.5 2100 -2497.5 2090 -2497.5 2085 -2497.5 2085 -2502.5 2085 -2522.5 2085 -2527.5 2090 -2527.5 2095 -2527.5 {bezier=1}
P 1 5 2077.5 -2525 2082.5 -2525 2082.5 -2500 2077.5 -2500 2077.5 -2525 {}
P 1 10 2080 -2595 2105 -2595 2115 -2585 2115 -2555 2105 -2545 2055 -2545 2045 -2555 2045 -2585 2055 -2595 2080 -2595 {bezier=1}
P 1 10 2080 -2600 2110 -2600 2120 -2590 2120 -2550 2110 -2540 2050 -2540 2040 -2550 2040 -2590 2050 -2600 2080 -2600 {bezier=1}
P 1 14 1570 -2500 1592.5 -2500 1597.5 -2500 1597.5 -2495 1597.5 -2452.5 1590 -2427.5 1585 -2427.5 1555 -2427.5 1550 -2427.5 1542.5 -2452.5 1542.5 -2495 1542.5 -2500 1547.5 -2500 1570 -2500 {bezier=1}
P 1 14 1585 -2497.5 1590 -2497.5 1595 -2497.5 1595 -2492.5 1595 -2472.5 1595 -2467.5 1590 -2467.5 1580 -2467.5 1575 -2467.5 1575 -2472.5 1575 -2492.5 1575 -2497.5 1580 -2497.5 1585 -2497.5 {bezier=1}
P 1 5 1567.5 -2495 1572.5 -2495 1572.5 -2470 1567.5 -2470 1567.5 -2495 {}
P 1 14 1430 -4900 1452.5 -4900 1457.5 -4900 1457.5 -4895 1457.5 -4852.5 1450 -4827.5 1445 -4827.5 1415 -4827.5 1410 -4827.5 1402.5 -4852.5 1402.5 -4895 1402.5 -4900 1407.5 -4900 1430 -4900 {bezier=1}
P 1 14 1415 -4897.5 1410 -4897.5 1405 -4897.5 1405 -4892.5 1405 -4872.5 1405 -4867.5 1410 -4867.5 1420 -4867.5 1425 -4867.5 1425 -4872.5 1425 -4892.5 1425 -4897.5 1420 -4897.5 1415 -4897.5 {bezier=1}
P 1 5 1427.5 -4895 1432.5 -4895 1432.5 -4870 1427.5 -4870 1427.5 -4895 {}
P 1 10 1430 -4965 1455 -4965 1465 -4955 1465 -4925 1455 -4915 1405 -4915 1395 -4925 1395 -4955 1405 -4965 1430 -4965 {bezier=1}
P 1 10 1430 -4970 1460 -4970 1470 -4960 1470 -4920 1460 -4910 1400 -4910 1390 -4920 1390 -4960 1400 -4970 1430 -4970 {bezier=1}
P 1 14 1960 -5010 1982.5 -5010 1987.5 -5010 1987.5 -5005 1987.5 -4962.5 1980 -4937.5 1975 -4937.5 1945 -4937.5 1940 -4937.5 1932.5 -4962.5 1932.5 -5005 1932.5 -5010 1937.5 -5010 1960 -5010 {bezier=1}
P 1 14 1975 -5007.5 1980 -5007.5 1985 -5007.5 1985 -5002.5 1985 -4982.5 1985 -4977.5 1980 -4977.5 1970 -4977.5 1965 -4977.5 1965 -4982.5 1965 -5002.5 1965 -5007.5 1970 -5007.5 1975 -5007.5 {bezier=1}
P 1 5 1957.5 -5005 1962.5 -5005 1962.5 -4980 1957.5 -4980 1957.5 -5005 {}
P 1 14 1580 -4490 1602.5 -4490 1607.5 -4490 1607.5 -4485 1607.5 -4442.5 1600 -4417.5 1595 -4417.5 1565 -4417.5 1560 -4417.5 1552.5 -4442.5 1552.5 -4485 1552.5 -4490 1557.5 -4490 1580 -4490 {bezier=1}
P 1 14 1595 -4487.5 1600 -4487.5 1605 -4487.5 1605 -4482.5 1605 -4462.5 1605 -4457.5 1600 -4457.5 1590 -4457.5 1585 -4457.5 1585 -4462.5 1585 -4482.5 1585 -4487.5 1590 -4487.5 1595 -4487.5 {bezier=1}
P 1 5 1577.5 -4485 1582.5 -4485 1582.5 -4460 1577.5 -4460 1577.5 -4485 {}
P 1 10 1580 -4555 1605 -4555 1615 -4545 1615 -4515 1605 -4505 1555 -4505 1545 -4515 1545 -4545 1555 -4555 1580 -4555 {bezier=1}
P 1 10 1580 -4560 1610 -4560 1620 -4550 1620 -4510 1610 -4500 1550 -4500 1540 -4510 1540 -4550 1550 -4560 1580 -4560 {bezier=1}
P 1 14 2070 -4550 2092.5 -4550 2097.5 -4550 2097.5 -4545 2097.5 -4502.5 2090 -4477.5 2085 -4477.5 2055 -4477.5 2050 -4477.5 2042.5 -4502.5 2042.5 -4545 2042.5 -4550 2047.5 -4550 2070 -4550 {bezier=1}
P 1 14 2085 -4547.5 2090 -4547.5 2095 -4547.5 2095 -4542.5 2095 -4522.5 2095 -4517.5 2090 -4517.5 2080 -4517.5 2075 -4517.5 2075 -4522.5 2075 -4542.5 2075 -4547.5 2080 -4547.5 2085 -4547.5 {bezier=1}
P 1 5 2067.5 -4545 2072.5 -4545 2072.5 -4520 2067.5 -4520 2067.5 -4545 {}
P 1 14 2600 -4680 2622.5 -4680 2627.5 -4680 2627.5 -4675 2627.5 -4632.5 2620 -4607.5 2615 -4607.5 2585 -4607.5 2580 -4607.5 2572.5 -4632.5 2572.5 -4675 2572.5 -4680 2577.5 -4680 2600 -4680 {bezier=1}
P 1 14 2615 -4677.5 2620 -4677.5 2625 -4677.5 2625 -4672.5 2625 -4652.5 2625 -4647.5 2620 -4647.5 2610 -4647.5 2605 -4647.5 2605 -4652.5 2605 -4672.5 2605 -4677.5 2610 -4677.5 2615 -4677.5 {bezier=1}
P 1 5 2597.5 -4675 2602.5 -4675 2602.5 -4650 2597.5 -4650 2597.5 -4675 {}
P 1 10 1960 -4255 1985 -4255 1995 -4245 1995 -4215 1985 -4205 1935 -4205 1925 -4215 1925 -4245 1935 -4255 1960 -4255 {bezier=1}
P 1 10 1960 -4260 1990 -4260 2000 -4250 2000 -4210 1990 -4200 1930 -4200 1920 -4210 1920 -4250 1930 -4260 1960 -4260 {bezier=1}
P 1 10 1960 -4175 1985 -4175 1995 -4165 1995 -4135 1985 -4125 1935 -4125 1925 -4135 1925 -4165 1935 -4175 1960 -4175 {bezier=1}
P 1 10 1960 -4180 1990 -4180 2000 -4170 2000 -4130 1990 -4120 1930 -4120 1920 -4130 1920 -4170 1930 -4180 1960 -4180 {bezier=1}
P 1 14 990 -11630 1012.5 -11630 1017.5 -11630 1017.5 -11625 1017.5 -11582.5 1010 -11557.5 1005 -11557.5 975 -11557.5 970 -11557.5 962.5 -11582.5 962.5 -11625 962.5 -11630 967.5 -11630 990 -11630 {bezier=1}
P 1 14 1005 -11627.5 1010 -11627.5 1015 -11627.5 1015 -11622.5 1015 -11602.5 1015 -11597.5 1010 -11597.5 1000 -11597.5 995 -11597.5 995 -11602.5 995 -11622.5 995 -11627.5 1000 -11627.5 1005 -11627.5 {bezier=1}
P 1 5 987.5 -11625 992.5 -11625 992.5 -11600 987.5 -11600 987.5 -11625 {}
P 1 10 1080 -11615 1105 -11615 1115 -11605 1115 -11575 1105 -11565 1055 -11565 1045 -11575 1045 -11605 1055 -11615 1080 -11615 {bezier=1}
P 1 10 1080 -11620 1110 -11620 1120 -11610 1120 -11570 1110 -11560 1050 -11560 1040 -11570 1040 -11610 1050 -11620 1080 -11620 {bezier=1}
P 1 14 1570 -2120 1592.5 -2120 1597.5 -2120 1597.5 -2115 1597.5 -2072.5 1590 -2047.5 1585 -2047.5 1555 -2047.5 1550 -2047.5 1542.5 -2072.5 1542.5 -2115 1542.5 -2120 1547.5 -2120 1570 -2120 {bezier=1}
P 1 14 1585 -2117.5 1590 -2117.5 1595 -2117.5 1595 -2112.5 1595 -2092.5 1595 -2087.5 1590 -2087.5 1580 -2087.5 1575 -2087.5 1575 -2092.5 1575 -2112.5 1575 -2117.5 1580 -2117.5 1585 -2117.5 {bezier=1}
P 1 5 1567.5 -2115 1572.5 -2115 1572.5 -2090 1567.5 -2090 1567.5 -2115 {}
P 1 14 2080 -2070 2102.5 -2070 2107.5 -2070 2107.5 -2065 2107.5 -2022.5 2100 -1997.5 2095 -1997.5 2065 -1997.5 2060 -1997.5 2052.5 -2022.5 2052.5 -2065 2052.5 -2070 2057.5 -2070 2080 -2070 {bezier=1}
P 1 14 2095 -2067.5 2100 -2067.5 2105 -2067.5 2105 -2062.5 2105 -2042.5 2105 -2037.5 2100 -2037.5 2090 -2037.5 2085 -2037.5 2085 -2042.5 2085 -2062.5 2085 -2067.5 2090 -2067.5 2095 -2067.5 {bezier=1}
P 1 5 2077.5 -2065 2082.5 -2065 2082.5 -2040 2077.5 -2040 2077.5 -2065 {}
P 1 10 2080 -2215 2105 -2215 2115 -2205 2115 -2175 2105 -2165 2055 -2165 2045 -2175 2045 -2205 2055 -2215 2080 -2215 {bezier=1}
P 1 10 2080 -2220 2110 -2220 2120 -2210 2120 -2170 2110 -2160 2050 -2160 2040 -2170 2040 -2210 2050 -2220 2080 -2220 {bezier=1}
P 1 10 2080 -2145 2105 -2145 2115 -2135 2115 -2105 2105 -2095 2055 -2095 2045 -2105 2045 -2135 2055 -2145 2080 -2145 {bezier=1}
P 1 10 2080 -2150 2110 -2150 2120 -2140 2120 -2100 2110 -2090 2050 -2090 2040 -2100 2040 -2140 2050 -2150 2080 -2150 {bezier=1}
P 1 10 1920 -3955 1945 -3955 1955 -3945 1955 -3915 1945 -3905 1895 -3905 1885 -3915 1885 -3945 1895 -3955 1920 -3955 {bezier=1}
P 1 10 1920 -3960 1950 -3960 1960 -3950 1960 -3910 1950 -3900 1890 -3900 1880 -3910 1880 -3950 1890 -3960 1920 -3960 {bezier=1}
P 1 10 1830 -3525 1855 -3525 1865 -3515 1865 -3485 1855 -3475 1805 -3475 1795 -3485 1795 -3515 1805 -3525 1830 -3525 {bezier=1}
P 1 10 1830 -3530 1860 -3530 1870 -3520 1870 -3480 1860 -3470 1800 -3470 1790 -3480 1790 -3520 1800 -3530 1830 -3530 {bezier=1}
P 1 14 2500 -4930 2522.5 -4930 2527.5 -4930 2527.5 -4925 2527.5 -4882.5 2520 -4857.5 2515 -4857.5 2485 -4857.5 2480 -4857.5 2472.5 -4882.5 2472.5 -4925 2472.5 -4930 2477.5 -4930 2500 -4930 {bezier=1}
P 1 14 2515 -4927.5 2520 -4927.5 2525 -4927.5 2525 -4922.5 2525 -4902.5 2525 -4897.5 2520 -4897.5 2510 -4897.5 2505 -4897.5 2505 -4902.5 2505 -4922.5 2505 -4927.5 2510 -4927.5 2515 -4927.5 {bezier=1}
P 1 5 2497.5 -4925 2502.5 -4925 2502.5 -4900 2497.5 -4900 2497.5 -4925 {}
P 1 10 1290 -2875 1315 -2875 1325 -2865 1325 -2835 1315 -2825 1265 -2825 1255 -2835 1255 -2865 1265 -2875 1290 -2875 {bezier=1}
P 1 10 1290 -2880 1320 -2880 1330 -2870 1330 -2830 1320 -2820 1260 -2820 1250 -2830 1250 -2870 1260 -2880 1290 -2880 {bezier=1}
P 1 14 1820 -2970 1842.5 -2970 1847.5 -2970 1847.5 -2965 1847.5 -2922.5 1840 -2897.5 1835 -2897.5 1805 -2897.5 1800 -2897.5 1792.5 -2922.5 1792.5 -2965 1792.5 -2970 1797.5 -2970 1820 -2970 {bezier=1}
P 1 14 1835 -2967.5 1840 -2967.5 1845 -2967.5 1845 -2962.5 1845 -2942.5 1845 -2937.5 1840 -2937.5 1830 -2937.5 1825 -2937.5 1825 -2942.5 1825 -2962.5 1825 -2967.5 1830 -2967.5 1835 -2967.5 {bezier=1}
P 1 5 1817.5 -2965 1822.5 -2965 1822.5 -2940 1817.5 -2940 1817.5 -2965 {}
P 1 14 670 -2900 692.5 -2900 697.5 -2900 697.5 -2895 697.5 -2852.5 690 -2827.5 685 -2827.5 655 -2827.5 650 -2827.5 642.5 -2852.5 642.5 -2895 642.5 -2900 647.5 -2900 670 -2900 {bezier=1}
P 1 14 685 -2897.5 690 -2897.5 695 -2897.5 695 -2892.5 695 -2872.5 695 -2867.5 690 -2867.5 680 -2867.5 675 -2867.5 675 -2872.5 675 -2892.5 675 -2897.5 680 -2897.5 685 -2897.5 {bezier=1}
P 1 5 667.5 -2895 672.5 -2895 672.5 -2870 667.5 -2870 667.5 -2895 {}
P 1 14 790 -2900 812.5 -2900 817.5 -2900 817.5 -2895 817.5 -2852.5 810 -2827.5 805 -2827.5 775 -2827.5 770 -2827.5 762.5 -2852.5 762.5 -2895 762.5 -2900 767.5 -2900 790 -2900 {bezier=1}
P 1 14 805 -2897.5 810 -2897.5 815 -2897.5 815 -2892.5 815 -2872.5 815 -2867.5 810 -2867.5 800 -2867.5 795 -2867.5 795 -2872.5 795 -2892.5 795 -2897.5 800 -2897.5 805 -2897.5 {bezier=1}
P 1 5 787.5 -2895 792.5 -2895 792.5 -2870 787.5 -2870 787.5 -2895 {}
P 1 10 790 -2805 815 -2805 825 -2795 825 -2765 815 -2755 765 -2755 755 -2765 755 -2795 765 -2805 790 -2805 {bezier=1}
P 1 10 790 -2810 820 -2810 830 -2800 830 -2760 820 -2750 760 -2750 750 -2760 750 -2800 760 -2810 790 -2810 {bezier=1}
P 1 14 1600 -1570 1622.5 -1570 1627.5 -1570 1627.5 -1565 1627.5 -1522.5 1620 -1497.5 1615 -1497.5 1585 -1497.5 1580 -1497.5 1572.5 -1522.5 1572.5 -1565 1572.5 -1570 1577.5 -1570 1600 -1570 {bezier=1}
P 1 14 1585 -1567.5 1580 -1567.5 1575 -1567.5 1575 -1562.5 1575 -1542.5 1575 -1537.5 1580 -1537.5 1590 -1537.5 1595 -1537.5 1595 -1542.5 1595 -1562.5 1595 -1567.5 1590 -1567.5 1585 -1567.5 {bezier=1}
P 1 5 1597.5 -1565 1602.5 -1565 1602.5 -1540 1597.5 -1540 1597.5 -1565 {}
P 1 10 1600 -1645 1625 -1645 1635 -1635 1635 -1605 1625 -1595 1575 -1595 1565 -1605 1565 -1635 1575 -1645 1600 -1645 {bezier=1}
P 1 10 1600 -1650 1630 -1650 1640 -1640 1640 -1600 1630 -1590 1570 -1590 1560 -1600 1560 -1640 1570 -1650 1600 -1650 {bezier=1}
P 1 10 1920 -3385 1945 -3385 1955 -3375 1955 -3345 1945 -3335 1895 -3335 1885 -3345 1885 -3375 1895 -3385 1920 -3385 {bezier=1}
P 1 10 1920 -3390 1950 -3390 1960 -3380 1960 -3340 1950 -3330 1890 -3330 1880 -3340 1880 -3380 1890 -3390 1920 -3390 {bezier=1}
P 1 14 2280 -6050 2302.5 -6050 2307.5 -6050 2307.5 -6045 2307.5 -6002.5 2300 -5977.5 2295 -5977.5 2265 -5977.5 2260 -5977.5 2252.5 -6002.5 2252.5 -6045 2252.5 -6050 2257.5 -6050 2280 -6050 {bezier=1}
P 1 14 2295 -6047.5 2300 -6047.5 2305 -6047.5 2305 -6042.5 2305 -6022.5 2305 -6017.5 2300 -6017.5 2290 -6017.5 2285 -6017.5 2285 -6022.5 2285 -6042.5 2285 -6047.5 2290 -6047.5 2295 -6047.5 {bezier=1}
P 1 5 2277.5 -6045 2282.5 -6045 2282.5 -6020 2277.5 -6020 2277.5 -6045 {}
P 1 10 2370 -6035 2395 -6035 2405 -6025 2405 -5995 2395 -5985 2345 -5985 2335 -5995 2335 -6025 2345 -6035 2370 -6035 {bezier=1}
P 1 10 2370 -6040 2400 -6040 2410 -6030 2410 -5990 2400 -5980 2340 -5980 2330 -5990 2330 -6030 2340 -6040 2370 -6040 {bezier=1}
P 1 14 1980 -5260 2002.5 -5260 2007.5 -5260 2007.5 -5255 2007.5 -5212.5 2000 -5187.5 1995 -5187.5 1965 -5187.5 1960 -5187.5 1952.5 -5212.5 1952.5 -5255 1952.5 -5260 1957.5 -5260 1980 -5260 {bezier=1}
P 1 14 1995 -5257.5 2000 -5257.5 2005 -5257.5 2005 -5252.5 2005 -5232.5 2005 -5227.5 2000 -5227.5 1990 -5227.5 1985 -5227.5 1985 -5232.5 1985 -5252.5 1985 -5257.5 1990 -5257.5 1995 -5257.5 {bezier=1}
P 1 5 1977.5 -5255 1982.5 -5255 1982.5 -5230 1977.5 -5230 1977.5 -5255 {}
P 1 10 1980 -5415 2005 -5415 2015 -5405 2015 -5375 2005 -5365 1955 -5365 1945 -5375 1945 -5405 1955 -5415 1980 -5415 {bezier=1}
P 1 10 1980 -5420 2010 -5420 2020 -5410 2020 -5370 2010 -5360 1950 -5360 1940 -5370 1940 -5410 1950 -5420 1980 -5420 {bezier=1}
P 1 10 1980 -5335 2005 -5335 2015 -5325 2015 -5295 2005 -5285 1955 -5285 1945 -5295 1945 -5325 1955 -5335 1980 -5335 {bezier=1}
P 1 10 1980 -5340 2010 -5340 2020 -5330 2020 -5290 2010 -5280 1950 -5280 1940 -5290 1940 -5330 1950 -5340 1980 -5340 {bezier=1}
P 1 14 2340 -3560 2362.5 -3560 2367.5 -3560 2367.5 -3555 2367.5 -3512.5 2360 -3487.5 2355 -3487.5 2325 -3487.5 2320 -3487.5 2312.5 -3512.5 2312.5 -3555 2312.5 -3560 2317.5 -3560 2340 -3560 {bezier=1}
P 1 14 2355 -3557.5 2360 -3557.5 2365 -3557.5 2365 -3552.5 2365 -3532.5 2365 -3527.5 2360 -3527.5 2350 -3527.5 2345 -3527.5 2345 -3532.5 2345 -3552.5 2345 -3557.5 2350 -3557.5 2355 -3557.5 {bezier=1}
P 1 5 2337.5 -3555 2342.5 -3555 2342.5 -3530 2337.5 -3530 2337.5 -3555 {}
P 1 14 810 -3680 832.5 -3680 837.5 -3680 837.5 -3675 837.5 -3632.5 830 -3607.5 825 -3607.5 795 -3607.5 790 -3607.5 782.5 -3632.5 782.5 -3675 782.5 -3680 787.5 -3680 810 -3680 {bezier=1}
P 1 14 825 -3677.5 830 -3677.5 835 -3677.5 835 -3672.5 835 -3652.5 835 -3647.5 830 -3647.5 820 -3647.5 815 -3647.5 815 -3652.5 815 -3672.5 815 -3677.5 820 -3677.5 825 -3677.5 {bezier=1}
P 1 5 807.5 -3675 812.5 -3675 812.5 -3650 807.5 -3650 807.5 -3675 {}
P 1 14 1350 -3660 1372.5 -3660 1377.5 -3660 1377.5 -3655 1377.5 -3612.5 1370 -3587.5 1365 -3587.5 1335 -3587.5 1330 -3587.5 1322.5 -3612.5 1322.5 -3655 1322.5 -3660 1327.5 -3660 1350 -3660 {bezier=1}
P 1 14 1365 -3657.5 1370 -3657.5 1375 -3657.5 1375 -3652.5 1375 -3632.5 1375 -3627.5 1370 -3627.5 1360 -3627.5 1355 -3627.5 1355 -3632.5 1355 -3652.5 1355 -3657.5 1360 -3657.5 1365 -3657.5 {bezier=1}
P 1 5 1347.5 -3655 1352.5 -3655 1352.5 -3630 1347.5 -3630 1347.5 -3655 {}
P 1 14 1260 -3280 1282.5 -3280 1287.5 -3280 1287.5 -3275 1287.5 -3232.5 1280 -3207.5 1275 -3207.5 1245 -3207.5 1240 -3207.5 1232.5 -3232.5 1232.5 -3275 1232.5 -3280 1237.5 -3280 1260 -3280 {bezier=1}
P 1 14 1275 -3277.5 1280 -3277.5 1285 -3277.5 1285 -3272.5 1285 -3252.5 1285 -3247.5 1280 -3247.5 1270 -3247.5 1265 -3247.5 1265 -3252.5 1265 -3272.5 1265 -3277.5 1270 -3277.5 1275 -3277.5 {bezier=1}
P 1 5 1257.5 -3275 1262.5 -3275 1262.5 -3250 1257.5 -3250 1257.5 -3275 {}
P 1 14 2520 -3230 2542.5 -3230 2547.5 -3230 2547.5 -3225 2547.5 -3182.5 2540 -3157.5 2535 -3157.5 2505 -3157.5 2500 -3157.5 2492.5 -3182.5 2492.5 -3225 2492.5 -3230 2497.5 -3230 2520 -3230 {bezier=1}
P 1 14 2535 -3227.5 2540 -3227.5 2545 -3227.5 2545 -3222.5 2545 -3202.5 2545 -3197.5 2540 -3197.5 2530 -3197.5 2525 -3197.5 2525 -3202.5 2525 -3222.5 2525 -3227.5 2530 -3227.5 2535 -3227.5 {bezier=1}
P 1 5 2517.5 -3225 2522.5 -3225 2522.5 -3200 2517.5 -3200 2517.5 -3225 {}
P 1 14 2480 -1820 2502.5 -1820 2507.5 -1820 2507.5 -1815 2507.5 -1772.5 2500 -1747.5 2495 -1747.5 2465 -1747.5 2460 -1747.5 2452.5 -1772.5 2452.5 -1815 2452.5 -1820 2457.5 -1820 2480 -1820 {bezier=1}
P 1 14 2495 -1817.5 2490 -1817.5 2485 -1817.5 2485 -1812.5 2485 -1792.5 2485 -1787.5 2490 -1787.5 2500 -1787.5 2505 -1787.5 2505 -1792.5 2505 -1812.5 2505 -1817.5 2500 -1817.5 2495 -1817.5 {bezier=1}
P 1 5 2477.5 -1815 2482.5 -1815 2482.5 -1790 2477.5 -1790 2477.5 -1815 {}
P 1 14 370 -8910 392.5 -8910 397.5 -8910 397.5 -8905 397.5 -8862.5 390 -8837.5 385 -8837.5 355 -8837.5 350 -8837.5 342.5 -8862.5 342.5 -8905 342.5 -8910 347.5 -8910 370 -8910 {bezier=1}
P 1 14 385 -8907.5 390 -8907.5 395 -8907.5 395 -8902.5 395 -8882.5 395 -8877.5 390 -8877.5 380 -8877.5 375 -8877.5 375 -8882.5 375 -8902.5 375 -8907.5 380 -8907.5 385 -8907.5 {bezier=1}
P 1 5 367.5 -8905 372.5 -8905 372.5 -8880 367.5 -8880 367.5 -8905 {}
P 1 14 900 -9080 922.5 -9080 927.5 -9080 927.5 -9075 927.5 -9032.5 920 -9007.5 915 -9007.5 885 -9007.5 880 -9007.5 872.5 -9032.5 872.5 -9075 872.5 -9080 877.5 -9080 900 -9080 {bezier=1}
P 1 14 915 -9077.5 920 -9077.5 925 -9077.5 925 -9072.5 925 -9052.5 925 -9047.5 920 -9047.5 910 -9047.5 905 -9047.5 905 -9052.5 905 -9072.5 905 -9077.5 910 -9077.5 915 -9077.5 {bezier=1}
P 1 5 897.5 -9075 902.5 -9075 902.5 -9050 897.5 -9050 897.5 -9075 {}
P 1 14 1150 -9120 1172.5 -9120 1177.5 -9120 1177.5 -9115 1177.5 -9072.5 1170 -9047.5 1165 -9047.5 1135 -9047.5 1130 -9047.5 1122.5 -9072.5 1122.5 -9115 1122.5 -9120 1127.5 -9120 1150 -9120 {bezier=1}
P 1 14 1165 -9117.5 1170 -9117.5 1175 -9117.5 1175 -9112.5 1175 -9092.5 1175 -9087.5 1170 -9087.5 1160 -9087.5 1155 -9087.5 1155 -9092.5 1155 -9112.5 1155 -9117.5 1160 -9117.5 1165 -9117.5 {bezier=1}
P 1 5 1147.5 -9115 1152.5 -9115 1152.5 -9090 1147.5 -9090 1147.5 -9115 {}
P 1 14 1440 -9120 1462.5 -9120 1467.5 -9120 1467.5 -9115 1467.5 -9072.5 1460 -9047.5 1455 -9047.5 1425 -9047.5 1420 -9047.5 1412.5 -9072.5 1412.5 -9115 1412.5 -9120 1417.5 -9120 1440 -9120 {bezier=1}
P 1 14 1455 -9117.5 1460 -9117.5 1465 -9117.5 1465 -9112.5 1465 -9092.5 1465 -9087.5 1460 -9087.5 1450 -9087.5 1445 -9087.5 1445 -9092.5 1445 -9112.5 1445 -9117.5 1450 -9117.5 1455 -9117.5 {bezier=1}
P 1 5 1437.5 -9115 1442.5 -9115 1442.5 -9090 1437.5 -9090 1437.5 -9115 {}
P 1 14 1900 -9080 1922.5 -9080 1927.5 -9080 1927.5 -9075 1927.5 -9032.5 1920 -9007.5 1915 -9007.5 1885 -9007.5 1880 -9007.5 1872.5 -9032.5 1872.5 -9075 1872.5 -9080 1877.5 -9080 1900 -9080 {bezier=1}
P 1 14 1915 -9077.5 1920 -9077.5 1925 -9077.5 1925 -9072.5 1925 -9052.5 1925 -9047.5 1920 -9047.5 1910 -9047.5 1905 -9047.5 1905 -9052.5 1905 -9072.5 1905 -9077.5 1910 -9077.5 1915 -9077.5 {bezier=1}
P 1 5 1897.5 -9075 1902.5 -9075 1902.5 -9050 1897.5 -9050 1897.5 -9075 {}
P 1 14 930 -5630 952.5 -5630 957.5 -5630 957.5 -5625 957.5 -5582.5 950 -5557.5 945 -5557.5 915 -5557.5 910 -5557.5 902.5 -5582.5 902.5 -5625 902.5 -5630 907.5 -5630 930 -5630 {bezier=1}
P 1 14 945 -5627.5 950 -5627.5 955 -5627.5 955 -5622.5 955 -5602.5 955 -5597.5 950 -5597.5 940 -5597.5 935 -5597.5 935 -5602.5 935 -5622.5 935 -5627.5 940 -5627.5 945 -5627.5 {bezier=1}
P 1 5 927.5 -5625 932.5 -5625 932.5 -5600 927.5 -5600 927.5 -5625 {}
P 1 14 1770 -5680 1792.5 -5680 1797.5 -5680 1797.5 -5675 1797.5 -5632.5 1790 -5607.5 1785 -5607.5 1755 -5607.5 1750 -5607.5 1742.5 -5632.5 1742.5 -5675 1742.5 -5680 1747.5 -5680 1770 -5680 {bezier=1}
P 1 14 1785 -5677.5 1790 -5677.5 1795 -5677.5 1795 -5672.5 1795 -5652.5 1795 -5647.5 1790 -5647.5 1780 -5647.5 1775 -5647.5 1775 -5652.5 1775 -5672.5 1775 -5677.5 1780 -5677.5 1785 -5677.5 {bezier=1}
P 1 5 1767.5 -5675 1772.5 -5675 1772.5 -5650 1767.5 -5650 1767.5 -5675 {}
P 1 14 2530 -5680 2552.5 -5680 2557.5 -5680 2557.5 -5675 2557.5 -5632.5 2550 -5607.5 2545 -5607.5 2515 -5607.5 2510 -5607.5 2502.5 -5632.5 2502.5 -5675 2502.5 -5680 2507.5 -5680 2530 -5680 {bezier=1}
P 1 14 2545 -5677.5 2550 -5677.5 2555 -5677.5 2555 -5672.5 2555 -5652.5 2555 -5647.5 2550 -5647.5 2540 -5647.5 2535 -5647.5 2535 -5652.5 2535 -5672.5 2535 -5677.5 2540 -5677.5 2545 -5677.5 {bezier=1}
P 1 5 2527.5 -5675 2532.5 -5675 2532.5 -5650 2527.5 -5650 2527.5 -5675 {}
P 1 14 905 -9900 927.5 -9900 932.5 -9900 932.5 -9895 932.5 -9852.5 925 -9827.5 920 -9827.5 890 -9827.5 885 -9827.5 877.5 -9852.5 877.5 -9895 877.5 -9900 882.5 -9900 905 -9900 {bezier=1}
P 1 14 920 -9897.5 925 -9897.5 930 -9897.5 930 -9892.5 930 -9872.5 930 -9867.5 925 -9867.5 915 -9867.5 910 -9867.5 910 -9872.5 910 -9892.5 910 -9897.5 915 -9897.5 920 -9897.5 {bezier=1}
P 1 5 902.5 -9895 907.5 -9895 907.5 -9870 902.5 -9870 902.5 -9895 {}
P 1 14 1440 -9780 1462.5 -9780 1467.5 -9780 1467.5 -9775 1467.5 -9732.5 1460 -9707.5 1455 -9707.5 1425 -9707.5 1420 -9707.5 1412.5 -9732.5 1412.5 -9775 1412.5 -9780 1417.5 -9780 1440 -9780 {bezier=1}
P 1 14 1455 -9777.5 1460 -9777.5 1465 -9777.5 1465 -9772.5 1465 -9752.5 1465 -9747.5 1460 -9747.5 1450 -9747.5 1445 -9747.5 1445 -9752.5 1445 -9772.5 1445 -9777.5 1450 -9777.5 1455 -9777.5 {bezier=1}
P 1 5 1437.5 -9775 1442.5 -9775 1442.5 -9750 1437.5 -9750 1437.5 -9775 {}
P 1 14 1810 -9780 1832.5 -9780 1837.5 -9780 1837.5 -9775 1837.5 -9732.5 1830 -9707.5 1825 -9707.5 1795 -9707.5 1790 -9707.5 1782.5 -9732.5 1782.5 -9775 1782.5 -9780 1787.5 -9780 1810 -9780 {bezier=1}
P 1 14 1825 -9777.5 1830 -9777.5 1835 -9777.5 1835 -9772.5 1835 -9752.5 1835 -9747.5 1830 -9747.5 1820 -9747.5 1815 -9747.5 1815 -9752.5 1815 -9772.5 1815 -9777.5 1820 -9777.5 1825 -9777.5 {bezier=1}
P 1 5 1807.5 -9775 1812.5 -9775 1812.5 -9750 1807.5 -9750 1807.5 -9775 {}
P 1 14 2300 -9780 2322.5 -9780 2327.5 -9780 2327.5 -9775 2327.5 -9732.5 2320 -9707.5 2315 -9707.5 2285 -9707.5 2280 -9707.5 2272.5 -9732.5 2272.5 -9775 2272.5 -9780 2277.5 -9780 2300 -9780 {bezier=1}
P 1 14 2315 -9777.5 2320 -9777.5 2325 -9777.5 2325 -9772.5 2325 -9752.5 2325 -9747.5 2320 -9747.5 2310 -9747.5 2305 -9747.5 2305 -9752.5 2305 -9772.5 2305 -9777.5 2310 -9777.5 2315 -9777.5 {bezier=1}
P 1 5 2297.5 -9775 2302.5 -9775 2302.5 -9750 2297.5 -9750 2297.5 -9775 {}
P 1 14 2250 -8930 2272.5 -8930 2277.5 -8930 2277.5 -8925 2277.5 -8882.5 2270 -8857.5 2265 -8857.5 2235 -8857.5 2230 -8857.5 2222.5 -8882.5 2222.5 -8925 2222.5 -8930 2227.5 -8930 2250 -8930 {bezier=1}
P 1 14 2265 -8927.5 2270 -8927.5 2275 -8927.5 2275 -8922.5 2275 -8902.5 2275 -8897.5 2270 -8897.5 2260 -8897.5 2255 -8897.5 2255 -8902.5 2255 -8922.5 2255 -8927.5 2260 -8927.5 2265 -8927.5 {bezier=1}
P 1 5 2247.5 -8925 2252.5 -8925 2252.5 -8900 2247.5 -8900 2247.5 -8925 {}
P 1 10 1980 -9075 2005 -9075 2015 -9065 2015 -9035 2005 -9025 1955 -9025 1945 -9035 1945 -9065 1955 -9075 1980 -9075 {bezier=1}
P 1 10 1980 -9080 2010 -9080 2020 -9070 2020 -9030 2010 -9020 1950 -9020 1940 -9030 1940 -9070 1950 -9080 1980 -9080 {bezier=1}
P 1 10 510 -8585 535 -8585 545 -8575 545 -8545 535 -8535 485 -8535 475 -8545 475 -8575 485 -8585 510 -8585 {bezier=1}
P 1 10 510 -8590 540 -8590 550 -8580 550 -8540 540 -8530 480 -8530 470 -8540 470 -8580 480 -8590 510 -8590 {bezier=1}
P 1 10 510 -8515 535 -8515 545 -8505 545 -8475 535 -8465 485 -8465 475 -8475 475 -8505 485 -8515 510 -8515 {bezier=1}
P 1 10 510 -8520 540 -8520 550 -8510 550 -8470 540 -8460 480 -8460 470 -8470 470 -8510 480 -8520 510 -8520 {bezier=1}
P 1 10 820 -8585 845 -8585 855 -8575 855 -8545 845 -8535 795 -8535 785 -8545 785 -8575 795 -8585 820 -8585 {bezier=1}
P 1 10 820 -8590 850 -8590 860 -8580 860 -8540 850 -8530 790 -8530 780 -8540 780 -8580 790 -8590 820 -8590 {bezier=1}
P 1 10 820 -8515 845 -8515 855 -8505 855 -8475 845 -8465 795 -8465 785 -8475 785 -8505 795 -8515 820 -8515 {bezier=1}
P 1 10 820 -8520 850 -8520 860 -8510 860 -8470 850 -8460 790 -8460 780 -8470 780 -8510 790 -8520 820 -8520 {bezier=1}
P 1 10 1120 -8585 1145 -8585 1155 -8575 1155 -8545 1145 -8535 1095 -8535 1085 -8545 1085 -8575 1095 -8585 1120 -8585 {bezier=1}
P 1 10 1120 -8590 1150 -8590 1160 -8580 1160 -8540 1150 -8530 1090 -8530 1080 -8540 1080 -8580 1090 -8590 1120 -8590 {bezier=1}
P 1 10 1120 -8515 1145 -8515 1155 -8505 1155 -8475 1145 -8465 1095 -8465 1085 -8475 1085 -8505 1095 -8515 1120 -8515 {bezier=1}
P 1 10 1120 -8520 1150 -8520 1160 -8510 1160 -8470 1150 -8460 1090 -8460 1080 -8470 1080 -8510 1090 -8520 1120 -8520 {bezier=1}
P 1 10 1430 -8585 1455 -8585 1465 -8575 1465 -8545 1455 -8535 1405 -8535 1395 -8545 1395 -8575 1405 -8585 1430 -8585 {bezier=1}
P 1 10 1430 -8590 1460 -8590 1470 -8580 1470 -8540 1460 -8530 1400 -8530 1390 -8540 1390 -8580 1400 -8590 1430 -8590 {bezier=1}
P 1 10 1430 -8515 1455 -8515 1465 -8505 1465 -8475 1455 -8465 1405 -8465 1395 -8475 1395 -8505 1405 -8515 1430 -8515 {bezier=1}
P 1 10 1430 -8520 1460 -8520 1470 -8510 1470 -8470 1460 -8460 1400 -8460 1390 -8470 1390 -8510 1400 -8520 1430 -8520 {bezier=1}
P 1 10 1750 -8585 1775 -8585 1785 -8575 1785 -8545 1775 -8535 1725 -8535 1715 -8545 1715 -8575 1725 -8585 1750 -8585 {bezier=1}
P 1 10 1750 -8590 1780 -8590 1790 -8580 1790 -8540 1780 -8530 1720 -8530 1710 -8540 1710 -8580 1720 -8590 1750 -8590 {bezier=1}
P 1 10 1750 -8515 1775 -8515 1785 -8505 1785 -8475 1775 -8465 1725 -8465 1715 -8475 1715 -8505 1725 -8515 1750 -8515 {bezier=1}
P 1 10 1750 -8520 1780 -8520 1790 -8510 1790 -8470 1780 -8460 1720 -8460 1710 -8470 1710 -8510 1720 -8520 1750 -8520 {bezier=1}
P 1 10 2080 -8585 2105 -8585 2115 -8575 2115 -8545 2105 -8535 2055 -8535 2045 -8545 2045 -8575 2055 -8585 2080 -8585 {bezier=1}
P 1 10 2080 -8590 2110 -8590 2120 -8580 2120 -8540 2110 -8530 2050 -8530 2040 -8540 2040 -8580 2050 -8590 2080 -8590 {bezier=1}
P 1 10 2080 -8515 2105 -8515 2115 -8505 2115 -8475 2105 -8465 2055 -8465 2045 -8475 2045 -8505 2055 -8515 2080 -8515 {bezier=1}
P 1 10 2080 -8520 2110 -8520 2120 -8510 2120 -8470 2110 -8460 2050 -8460 2040 -8470 2040 -8510 2050 -8520 2080 -8520 {bezier=1}
P 1 10 1940 -8395 1965 -8395 1975 -8385 1975 -8355 1965 -8345 1915 -8345 1905 -8355 1905 -8385 1915 -8395 1940 -8395 {bezier=1}
P 1 10 1940 -8400 1970 -8400 1980 -8390 1980 -8350 1970 -8340 1910 -8340 1900 -8350 1900 -8390 1910 -8400 1940 -8400 {bezier=1}
P 1 10 1940 -8325 1965 -8325 1975 -8315 1975 -8285 1965 -8275 1915 -8275 1905 -8285 1905 -8315 1915 -8325 1940 -8325 {bezier=1}
P 1 10 1940 -8330 1970 -8330 1980 -8320 1980 -8280 1970 -8270 1910 -8270 1900 -8280 1900 -8320 1910 -8330 1940 -8330 {bezier=1}
P 1 14 2050 -8380 2072.5 -8380 2077.5 -8380 2077.5 -8375 2077.5 -8332.5 2070 -8307.5 2065 -8307.5 2035 -8307.5 2030 -8307.5 2022.5 -8332.5 2022.5 -8375 2022.5 -8380 2027.5 -8380 2050 -8380 {bezier=1}
P 1 14 2065 -8377.5 2070 -8377.5 2075 -8377.5 2075 -8372.5 2075 -8352.5 2075 -8347.5 2070 -8347.5 2060 -8347.5 2055 -8347.5 2055 -8352.5 2055 -8372.5 2055 -8377.5 2060 -8377.5 2065 -8377.5 {bezier=1}
P 1 5 2047.5 -8375 2052.5 -8375 2052.5 -8350 2047.5 -8350 2047.5 -8375 {}
P 1 14 2035 -8377.5 2040 -8377.5 2045 -8377.5 2045 -8372.5 2045 -8352.5 2045 -8347.5 2040 -8347.5 2030 -8347.5 2025 -8347.5 2025 -8352.5 2025 -8372.5 2025 -8377.5 2030 -8377.5 2035 -8377.5 {bezier=1}
P 1 10 1940 -7965 1965 -7965 1975 -7955 1975 -7925 1965 -7915 1915 -7915 1905 -7925 1905 -7955 1915 -7965 1940 -7965 {bezier=1}
P 1 10 1940 -7970 1970 -7970 1980 -7960 1980 -7920 1970 -7910 1910 -7910 1900 -7920 1900 -7960 1910 -7970 1940 -7970 {bezier=1}
P 1 10 1940 -7895 1965 -7895 1975 -7885 1975 -7855 1965 -7845 1915 -7845 1905 -7855 1905 -7885 1915 -7895 1940 -7895 {bezier=1}
P 1 10 1940 -7900 1970 -7900 1980 -7890 1980 -7850 1970 -7840 1910 -7840 1900 -7850 1900 -7890 1910 -7900 1940 -7900 {bezier=1}
P 1 14 2050 -7950 2072.5 -7950 2077.5 -7950 2077.5 -7945 2077.5 -7902.5 2070 -7877.5 2065 -7877.5 2035 -7877.5 2030 -7877.5 2022.5 -7902.5 2022.5 -7945 2022.5 -7950 2027.5 -7950 2050 -7950 {bezier=1}
P 1 14 2065 -7947.5 2070 -7947.5 2075 -7947.5 2075 -7942.5 2075 -7922.5 2075 -7917.5 2070 -7917.5 2060 -7917.5 2055 -7917.5 2055 -7922.5 2055 -7942.5 2055 -7947.5 2060 -7947.5 2065 -7947.5 {bezier=1}
P 1 5 2047.5 -7945 2052.5 -7945 2052.5 -7920 2047.5 -7920 2047.5 -7945 {}
P 1 14 2035 -7947.5 2040 -7947.5 2045 -7947.5 2045 -7942.5 2045 -7922.5 2045 -7917.5 2040 -7917.5 2030 -7917.5 2025 -7917.5 2025 -7922.5 2025 -7942.5 2025 -7947.5 2030 -7947.5 2035 -7947.5 {bezier=1}
P 1 10 1050 -7485 1075 -7485 1085 -7475 1085 -7445 1075 -7435 1025 -7435 1015 -7445 1015 -7475 1025 -7485 1050 -7485 {bezier=1}
P 1 10 1050 -7490 1080 -7490 1090 -7480 1090 -7440 1080 -7430 1020 -7430 1010 -7440 1010 -7480 1020 -7490 1050 -7490 {bezier=1}
P 1 10 1050 -7415 1075 -7415 1085 -7405 1085 -7375 1075 -7365 1025 -7365 1015 -7375 1015 -7405 1025 -7415 1050 -7415 {bezier=1}
P 1 10 1050 -7420 1080 -7420 1090 -7410 1090 -7370 1080 -7360 1020 -7360 1010 -7370 1010 -7410 1020 -7420 1050 -7420 {bezier=1}
P 1 14 1160 -7470 1182.5 -7470 1187.5 -7470 1187.5 -7465 1187.5 -7422.5 1180 -7397.5 1175 -7397.5 1145 -7397.5 1140 -7397.5 1132.5 -7422.5 1132.5 -7465 1132.5 -7470 1137.5 -7470 1160 -7470 {bezier=1}
P 1 14 1175 -7467.5 1180 -7467.5 1185 -7467.5 1185 -7462.5 1185 -7442.5 1185 -7437.5 1180 -7437.5 1170 -7437.5 1165 -7437.5 1165 -7442.5 1165 -7462.5 1165 -7467.5 1170 -7467.5 1175 -7467.5 {bezier=1}
P 1 5 1157.5 -7465 1162.5 -7465 1162.5 -7440 1157.5 -7440 1157.5 -7465 {}
P 1 14 1145 -7467.5 1150 -7467.5 1155 -7467.5 1155 -7462.5 1155 -7442.5 1155 -7437.5 1150 -7437.5 1140 -7437.5 1135 -7437.5 1135 -7442.5 1135 -7462.5 1135 -7467.5 1140 -7467.5 1145 -7467.5 {bezier=1}
P 1 14 2480 -8990 2502.5 -8990 2507.5 -8990 2507.5 -8985 2507.5 -8942.5 2500 -8917.5 2495 -8917.5 2465 -8917.5 2460 -8917.5 2452.5 -8942.5 2452.5 -8985 2452.5 -8990 2457.5 -8990 2480 -8990 {bezier=1}
P 1 14 2495 -8987.5 2500 -8987.5 2505 -8987.5 2505 -8982.5 2505 -8962.5 2505 -8957.5 2500 -8957.5 2490 -8957.5 2485 -8957.5 2485 -8962.5 2485 -8982.5 2485 -8987.5 2490 -8987.5 2495 -8987.5 {bezier=1}
P 1 5 2477.5 -8985 2482.5 -8985 2482.5 -8960 2477.5 -8960 2477.5 -8985 {}
P 1 10 1520 -6715 1545 -6715 1555 -6705 1555 -6675 1545 -6665 1495 -6665 1485 -6675 1485 -6705 1495 -6715 1520 -6715 {bezier=1}
P 1 10 1520 -6720 1550 -6720 1560 -6710 1560 -6670 1550 -6660 1490 -6660 1480 -6670 1480 -6710 1490 -6720 1520 -6720 {bezier=1}
P 1 14 620 -9120 642.5 -9120 647.5 -9120 647.5 -9115 647.5 -9072.5 640 -9047.5 635 -9047.5 605 -9047.5 600 -9047.5 592.5 -9072.5 592.5 -9115 592.5 -9120 597.5 -9120 620 -9120 {bezier=1}
P 1 14 635 -9117.5 640 -9117.5 645 -9117.5 645 -9112.5 645 -9092.5 645 -9087.5 640 -9087.5 630 -9087.5 625 -9087.5 625 -9092.5 625 -9112.5 625 -9117.5 630 -9117.5 635 -9117.5 {bezier=1}
P 1 5 617.5 -9115 622.5 -9115 622.5 -9090 617.5 -9090 617.5 -9115 {}
P 1 10 1430 -1235 1455 -1235 1465 -1225 1465 -1195 1455 -1185 1405 -1185 1395 -1195 1395 -1225 1405 -1235 1430 -1235 {bezier=1}
P 1 10 1430 -1240 1460 -1240 1470 -1230 1470 -1190 1460 -1180 1400 -1180 1390 -1190 1390 -1230 1400 -1240 1430 -1240 {bezier=1}
P 1 10 1430 -1165 1455 -1165 1465 -1155 1465 -1125 1455 -1115 1405 -1115 1395 -1125 1395 -1155 1405 -1165 1430 -1165 {bezier=1}
P 1 10 1430 -1170 1460 -1170 1470 -1160 1470 -1120 1460 -1110 1400 -1110 1390 -1120 1390 -1160 1400 -1170 1430 -1170 {bezier=1}
P 1 10 2310 -1235 2335 -1235 2345 -1225 2345 -1195 2335 -1185 2285 -1185 2275 -1195 2275 -1225 2285 -1235 2310 -1235 {bezier=1}
P 1 10 2310 -1240 2340 -1240 2350 -1230 2350 -1190 2340 -1180 2280 -1180 2270 -1190 2270 -1230 2280 -1240 2310 -1240 {bezier=1}
P 1 10 2310 -1165 2335 -1165 2345 -1155 2345 -1125 2335 -1115 2285 -1115 2275 -1125 2275 -1155 2285 -1165 2310 -1165 {bezier=1}
P 1 10 2310 -1170 2340 -1170 2350 -1160 2350 -1120 2340 -1110 2280 -1110 2270 -1120 2270 -1160 2280 -1170 2310 -1170 {bezier=1}
P 1 10 1010 -925 1035 -925 1045 -915 1045 -885 1035 -875 985 -875 975 -885 975 -915 985 -925 1010 -925 {bezier=1}
P 1 10 1010 -930 1040 -930 1050 -920 1050 -880 1040 -870 980 -870 970 -880 970 -920 980 -930 1010 -930 {bezier=1}
P 1 10 1010 -855 1035 -855 1045 -845 1045 -815 1035 -805 985 -805 975 -815 975 -845 985 -855 1010 -855 {bezier=1}
P 1 10 1010 -860 1040 -860 1050 -850 1050 -810 1040 -800 980 -800 970 -810 970 -850 980 -860 1010 -860 {bezier=1}
P 1 10 1440 -925 1465 -925 1475 -915 1475 -885 1465 -875 1415 -875 1405 -885 1405 -915 1415 -925 1440 -925 {bezier=1}
P 1 10 1440 -930 1470 -930 1480 -920 1480 -880 1470 -870 1410 -870 1400 -880 1400 -920 1410 -930 1440 -930 {bezier=1}
P 1 10 1440 -855 1465 -855 1475 -845 1475 -815 1465 -805 1415 -805 1405 -815 1405 -845 1415 -855 1440 -855 {bezier=1}
P 1 10 1440 -860 1470 -860 1480 -850 1480 -810 1470 -800 1410 -800 1400 -810 1400 -850 1410 -860 1440 -860 {bezier=1}
P 1 10 2370 -985 2395 -985 2405 -975 2405 -945 2395 -935 2345 -935 2335 -945 2335 -975 2345 -985 2370 -985 {bezier=1}
P 1 10 2370 -990 2400 -990 2410 -980 2410 -940 2400 -930 2340 -930 2330 -940 2330 -980 2340 -990 2370 -990 {bezier=1}
P 1 10 2370 -915 2395 -915 2405 -905 2405 -875 2395 -865 2345 -865 2335 -875 2335 -905 2345 -915 2370 -915 {bezier=1}
P 1 10 2370 -920 2400 -920 2410 -910 2410 -870 2400 -860 2340 -860 2330 -870 2330 -910 2340 -920 2370 -920 {bezier=1}
P 1 14 650 -940 672.5 -940 677.5 -940 677.5 -935 677.5 -892.5 670 -867.5 665 -867.5 635 -867.5 630 -867.5 622.5 -892.5 622.5 -935 622.5 -940 627.5 -940 650 -940 {bezier=1}
P 1 14 665 -937.5 670 -937.5 675 -937.5 675 -932.5 675 -912.5 675 -907.5 670 -907.5 660 -907.5 655 -907.5 655 -912.5 655 -932.5 655 -937.5 660 -937.5 665 -937.5 {bezier=1}
P 1 5 647.5 -935 652.5 -935 652.5 -910 647.5 -910 647.5 -935 {}
P 1 14 1100 -940 1122.5 -940 1127.5 -940 1127.5 -935 1127.5 -892.5 1120 -867.5 1115 -867.5 1085 -867.5 1080 -867.5 1072.5 -892.5 1072.5 -935 1072.5 -940 1077.5 -940 1100 -940 {bezier=1}
P 1 14 1115 -937.5 1120 -937.5 1125 -937.5 1125 -932.5 1125 -912.5 1125 -907.5 1120 -907.5 1110 -907.5 1105 -907.5 1105 -912.5 1105 -932.5 1105 -937.5 1110 -937.5 1115 -937.5 {bezier=1}
P 1 5 1097.5 -935 1102.5 -935 1102.5 -910 1097.5 -910 1097.5 -935 {}
P 1 14 1085 -937.5 1090 -937.5 1095 -937.5 1095 -932.5 1095 -912.5 1095 -907.5 1090 -907.5 1080 -907.5 1075 -907.5 1075 -912.5 1075 -932.5 1075 -937.5 1080 -937.5 1085 -937.5 {bezier=1}
P 1 14 1520 -910 1542.5 -910 1547.5 -910 1547.5 -905 1547.5 -862.5 1540 -837.5 1535 -837.5 1505 -837.5 1500 -837.5 1492.5 -862.5 1492.5 -905 1492.5 -910 1497.5 -910 1520 -910 {bezier=1}
P 1 14 1535 -907.5 1540 -907.5 1545 -907.5 1545 -902.5 1545 -882.5 1545 -877.5 1540 -877.5 1530 -877.5 1525 -877.5 1525 -882.5 1525 -902.5 1525 -907.5 1530 -907.5 1535 -907.5 {bezier=1}
P 1 5 1517.5 -905 1522.5 -905 1522.5 -880 1517.5 -880 1517.5 -905 {}
P 1 14 2450 -970 2472.5 -970 2477.5 -970 2477.5 -965 2477.5 -922.5 2470 -897.5 2465 -897.5 2435 -897.5 2430 -897.5 2422.5 -922.5 2422.5 -965 2422.5 -970 2427.5 -970 2450 -970 {bezier=1}
P 1 14 2465 -967.5 2470 -967.5 2475 -967.5 2475 -962.5 2475 -942.5 2475 -937.5 2470 -937.5 2460 -937.5 2455 -937.5 2455 -942.5 2455 -962.5 2455 -967.5 2460 -967.5 2465 -967.5 {bezier=1}
P 1 5 2447.5 -965 2452.5 -965 2452.5 -940 2447.5 -940 2447.5 -965 {}
P 1 14 2210 -12020 2232.5 -12020 2237.5 -12020 2237.5 -12015 2237.5 -11972.5 2230 -11947.5 2225 -11947.5 2195 -11947.5 2190 -11947.5 2182.5 -11972.5 2182.5 -12015 2182.5 -12020 2187.5 -12020 2210 -12020 {bezier=1}
P 1 14 2225 -12017.5 2230 -12017.5 2235 -12017.5 2235 -12012.5 2235 -11992.5 2235 -11987.5 2230 -11987.5 2220 -11987.5 2215 -11987.5 2215 -11992.5 2215 -12012.5 2215 -12017.5 2220 -12017.5 2225 -12017.5 {bezier=1}
P 1 5 2207.5 -12015 2212.5 -12015 2212.5 -11990 2207.5 -11990 2207.5 -12015 {}
P 1 10 2210 -11915 2235 -11915 2245 -11905 2245 -11875 2235 -11865 2185 -11865 2175 -11875 2175 -11905 2185 -11915 2210 -11915 {bezier=1}
P 1 10 2210 -11920 2240 -11920 2250 -11910 2250 -11870 2240 -11860 2180 -11860 2170 -11870 2170 -11910 2180 -11920 2210 -11920 {bezier=1}
P 1 10 2210 -11835 2235 -11835 2245 -11825 2245 -11795 2235 -11785 2185 -11785 2175 -11795 2175 -11825 2185 -11835 2210 -11835 {bezier=1}
P 1 10 2210 -11840 2240 -11840 2250 -11830 2250 -11790 2240 -11780 2180 -11780 2170 -11790 2170 -11830 2180 -11840 2210 -11840 {bezier=1}
P 1 14 960 -610 982.5 -610 987.5 -610 987.5 -605 987.5 -562.5 980 -537.5 975 -537.5 945 -537.5 940 -537.5 932.5 -562.5 932.5 -605 932.5 -610 937.5 -610 960 -610 {bezier=1}
P 1 14 975 -607.5 980 -607.5 985 -607.5 985 -602.5 985 -582.5 985 -577.5 980 -577.5 970 -577.5 965 -577.5 965 -582.5 965 -602.5 965 -607.5 970 -607.5 975 -607.5 {bezier=1}
P 1 5 957.5 -605 962.5 -605 962.5 -580 957.5 -580 957.5 -605 {}
P 1 10 1300 -595 1325 -595 1335 -585 1335 -555 1325 -545 1275 -545 1265 -555 1265 -585 1275 -595 1300 -595 {bezier=1}
P 1 10 1300 -600 1330 -600 1340 -590 1340 -550 1330 -540 1270 -540 1260 -550 1260 -590 1270 -600 1300 -600 {bezier=1}
P 1 10 1300 -525 1325 -525 1335 -515 1335 -485 1325 -475 1275 -475 1265 -485 1265 -515 1275 -525 1300 -525 {bezier=1}
P 1 10 1300 -530 1330 -530 1340 -520 1340 -480 1330 -470 1270 -470 1260 -480 1260 -520 1270 -530 1300 -530 {bezier=1}
P 1 14 1390 -570 1412.5 -570 1417.5 -570 1417.5 -565 1417.5 -522.5 1410 -497.5 1405 -497.5 1375 -497.5 1370 -497.5 1362.5 -522.5 1362.5 -565 1362.5 -570 1367.5 -570 1390 -570 {bezier=1}
P 1 14 1405 -567.5 1410 -567.5 1415 -567.5 1415 -562.5 1415 -542.5 1415 -537.5 1410 -537.5 1400 -537.5 1395 -537.5 1395 -542.5 1395 -562.5 1395 -567.5 1400 -567.5 1405 -567.5 {bezier=1}
P 1 5 1387.5 -565 1392.5 -565 1392.5 -540 1387.5 -540 1387.5 -565 {}
P 1 14 1375 -567.5 1380 -567.5 1385 -567.5 1385 -562.5 1385 -542.5 1385 -537.5 1380 -537.5 1370 -537.5 1365 -537.5 1365 -542.5 1365 -562.5 1365 -567.5 1370 -567.5 1375 -567.5 {bezier=1}
P 1 10 1630 -595 1655 -595 1665 -585 1665 -555 1655 -545 1605 -545 1595 -555 1595 -585 1605 -595 1630 -595 {bezier=1}
P 1 10 1630 -600 1660 -600 1670 -590 1670 -550 1660 -540 1600 -540 1590 -550 1590 -590 1600 -600 1630 -600 {bezier=1}
P 1 10 1630 -525 1655 -525 1665 -515 1665 -485 1655 -475 1605 -475 1595 -485 1595 -515 1605 -525 1630 -525 {bezier=1}
P 1 10 1630 -530 1660 -530 1670 -520 1670 -480 1660 -470 1600 -470 1590 -480 1590 -520 1600 -530 1630 -530 {bezier=1}
P 1 14 1720 -570 1742.5 -570 1747.5 -570 1747.5 -565 1747.5 -522.5 1740 -497.5 1735 -497.5 1705 -497.5 1700 -497.5 1692.5 -522.5 1692.5 -565 1692.5 -570 1697.5 -570 1720 -570 {bezier=1}
P 1 14 1735 -567.5 1740 -567.5 1745 -567.5 1745 -562.5 1745 -542.5 1745 -537.5 1740 -537.5 1730 -537.5 1725 -537.5 1725 -542.5 1725 -562.5 1725 -567.5 1730 -567.5 1735 -567.5 {bezier=1}
P 1 5 1717.5 -565 1722.5 -565 1722.5 -540 1717.5 -540 1717.5 -565 {}
P 1 14 1705 -567.5 1710 -567.5 1715 -567.5 1715 -562.5 1715 -542.5 1715 -537.5 1710 -537.5 1700 -537.5 1695 -537.5 1695 -542.5 1695 -562.5 1695 -567.5 1700 -567.5 1705 -567.5 {bezier=1}
P 1 10 1950 -595 1975 -595 1985 -585 1985 -555 1975 -545 1925 -545 1915 -555 1915 -585 1925 -595 1950 -595 {bezier=1}
P 1 10 1950 -600 1980 -600 1990 -590 1990 -550 1980 -540 1920 -540 1910 -550 1910 -590 1920 -600 1950 -600 {bezier=1}
P 1 10 1950 -525 1975 -525 1985 -515 1985 -485 1975 -475 1925 -475 1915 -485 1915 -515 1925 -525 1950 -525 {bezier=1}
P 1 10 1950 -530 1980 -530 1990 -520 1990 -480 1980 -470 1920 -470 1910 -480 1910 -520 1920 -530 1950 -530 {bezier=1}
P 1 14 2040 -570 2062.5 -570 2067.5 -570 2067.5 -565 2067.5 -522.5 2060 -497.5 2055 -497.5 2025 -497.5 2020 -497.5 2012.5 -522.5 2012.5 -565 2012.5 -570 2017.5 -570 2040 -570 {bezier=1}
P 1 14 2055 -567.5 2060 -567.5 2065 -567.5 2065 -562.5 2065 -542.5 2065 -537.5 2060 -537.5 2050 -537.5 2045 -537.5 2045 -542.5 2045 -562.5 2045 -567.5 2050 -567.5 2055 -567.5 {bezier=1}
P 1 5 2037.5 -565 2042.5 -565 2042.5 -540 2037.5 -540 2037.5 -565 {}
P 1 14 2025 -567.5 2030 -567.5 2035 -567.5 2035 -562.5 2035 -542.5 2035 -537.5 2030 -537.5 2020 -537.5 2015 -537.5 2015 -542.5 2015 -562.5 2015 -567.5 2020 -567.5 2025 -567.5 {bezier=1}
P 1 14 1130 -330 1152.5 -330 1157.5 -330 1157.5 -325 1157.5 -282.5 1150 -257.5 1145 -257.5 1115 -257.5 1110 -257.5 1102.5 -282.5 1102.5 -325 1102.5 -330 1107.5 -330 1130 -330 {bezier=1}
P 1 14 1145 -327.5 1150 -327.5 1155 -327.5 1155 -322.5 1155 -302.5 1155 -297.5 1150 -297.5 1140 -297.5 1135 -297.5 1135 -302.5 1135 -322.5 1135 -327.5 1140 -327.5 1145 -327.5 {bezier=1}
P 1 5 1127.5 -325 1132.5 -325 1132.5 -300 1127.5 -300 1127.5 -325 {}
P 1 10 1220 -315 1245 -315 1255 -305 1255 -275 1245 -265 1195 -265 1185 -275 1185 -305 1195 -315 1220 -315 {bezier=1}
P 1 10 1220 -320 1250 -320 1260 -310 1260 -270 1250 -260 1190 -260 1180 -270 1180 -310 1190 -320 1220 -320 {bezier=1}
P 1 10 1600 -315 1625 -315 1635 -305 1635 -275 1625 -265 1575 -265 1565 -275 1565 -305 1575 -315 1600 -315 {bezier=1}
P 1 10 1600 -320 1630 -320 1640 -310 1640 -270 1630 -260 1570 -260 1560 -270 1560 -310 1570 -320 1600 -320 {bezier=1}
P 2 7 897.5 -6170 893.75 -6175 885 -6175 888.75 -6170 885 -6165 893.75 -6165 897.5 -6170 {fill=true}
P 2 7 1457.5 -6170 1453.75 -6175 1445 -6175 1448.75 -6170 1445 -6165 1453.75 -6165 1457.5 -6170 {fill=true}
P 2 7 2277.5 -6170 2273.75 -6175 2265 -6175 2268.75 -6170 2265 -6165 2273.75 -6165 2277.5 -6170 {fill=true}
P 2 7 2030 -2550 2020 -2560 2030 -2560 2030 -2560 2010 -2570 2020 -2550 2020 -2560 {}
P 2 7 1520 -2450 1510 -2460 1520 -2460 1520 -2460 1500 -2470 1510 -2450 1510 -2460 {}
P 2 7 2030 -2170 2020 -2180 2030 -2180 2030 -2180 2010 -2190 2020 -2170 2020 -2180 {}
P 2 7 1520 -2070 1510 -2080 1520 -2080 1520 -2080 1500 -2090 1510 -2070 1510 -2080 {}
P 2 7 455 -8720 451.25 -8725 442.5 -8725 446.25 -8720 442.5 -8715 451.25 -8715 455 -8720 {fill=true}
P 2 7 820 -8725 825 -8728.75 825 -8737.5 820 -8733.75 815 -8737.5 815 -8728.75 820 -8725 {fill=true}
P 2 7 1175 -8650 1178.75 -8645 1187.5 -8645 1183.75 -8650 1187.5 -8655 1178.75 -8655 1175 -8650 {fill=true}
P 2 7 1410 -8655 1405 -8651.25 1405 -8642.5 1410 -8646.25 1415 -8642.5 1415 -8651.25 1410 -8655 {fill=true}
P 2 7 1750 -8655 1755 -8651.25 1755 -8642.5 1750 -8646.25 1745 -8642.5 1745 -8651.25 1750 -8655 {fill=true}
P 2 7 2080 -8735 2085 -8738.75 2085 -8747.5 2080 -8743.75 2075 -8747.5 2075 -8738.75 2080 -8735 {fill=true}
P 2 7 605 -8220 601.25 -8225 592.5 -8225 596.25 -8220 592.5 -8215 601.25 -8215 605 -8220 {fill=true}
P 2 7 1080 -8220 1076.25 -8225 1067.5 -8225 1071.25 -8220 1067.5 -8215 1076.25 -8215 1080 -8220 {fill=true}
P 2 7 1700 -8295 1705 -8298.75 1705 -8307.5 1700 -8303.75 1695 -8307.5 1695 -8298.75 1700 -8295 {fill=true}
P 2 7 605 -7790 601.25 -7795 592.5 -7795 596.25 -7790 592.5 -7785 601.25 -7785 605 -7790 {fill=true}
P 2 7 1055 -7790 1051.25 -7795 1042.5 -7795 1046.25 -7790 1042.5 -7785 1051.25 -7785 1055 -7790 {fill=true}
P 2 7 1765 -7790 1768.75 -7795 1777.5 -7795 1773.75 -7790 1777.5 -7785 1768.75 -7785 1765 -7790 {fill=true}
P 3 6 1280 -3130 1280 -3140 1270 -3140 1280 -3160 1290 -3140 1280 -3140 {}
P 3 6 740 -3130 740 -3140 730 -3140 740 -3160 750 -3140 740 -3140 {}
P 3 6 1750 -5730 1860 -5730 1860 -5740 1900 -5730 1860 -5720 1860 -5730 {}
P 3 6 1680 -5730 1570 -5730 1570 -5740 1530 -5730 1570 -5720 1570 -5730 {}
P 3 6 2420 -5730 2420 -5620 2430 -5620 2420 -5580 2410 -5620 2420 -5620 {}
P 3 6 2420 -5750 2420 -5860 2430 -5860 2420 -5900 2410 -5860 2420 -5860 {}
P 4 4 1115 -8350 1185 -8320 1185 -8210 1125 -8180 {bezier=1}
P 4 4 1122.5 -8185 1127.5 -8175 1105 -8172.5 1122.5 -8185 {fill=1}
P 4 7 1120 -7860 1170 -7860 1170 -7865 1190 -7860 1170 -7855 1170 -7860 1120 -7860 {fill=1}
P 4 7 1120 -7860 1070 -7860 1070 -7865 1050 -7860 1070 -7855 1070 -7860 1120 -7860 {fill=1}
P 5 7 1105 -11030 1101.25 -11035 1092.5 -11035 1096.25 -11030 1092.5 -11025 1101.25 -11025 1105 -11030 {fill=true}
P 5 7 1427.5 -11060 1423.75 -11065 1415 -11065 1418.75 -11060 1415 -11055 1423.75 -11055 1427.5 -11060 {fill=true}
P 5 7 1645 -11030 1641.25 -11035 1632.5 -11035 1636.25 -11030 1632.5 -11025 1641.25 -11025 1645 -11030 {fill=true}
P 5 7 1967.5 -11060 1963.75 -11065 1955 -11065 1958.75 -11060 1955 -11055 1963.75 -11055 1967.5 -11060 {fill=true}
P 5 7 575 -11030 571.25 -11035 562.5 -11035 566.25 -11030 562.5 -11025 571.25 -11025 575 -11030 {fill=true}
P 5 7 897.5 -11060 893.75 -11065 885 -11065 888.75 -11060 885 -11055 893.75 -11055 897.5 -11060 {fill=true}
P 5 7 575 -10570 571.25 -10575 562.5 -10575 566.25 -10570 562.5 -10565 571.25 -10565 575 -10570 {fill=true}
P 5 7 897.5 -10600 893.75 -10605 885 -10605 888.75 -10600 885 -10595 893.75 -10595 897.5 -10600 {fill=true}
P 5 7 1115 -10570 1111.25 -10575 1102.5 -10575 1106.25 -10570 1102.5 -10565 1111.25 -10565 1115 -10570 {fill=true}
P 5 7 1437.5 -10600 1433.75 -10605 1425 -10605 1428.75 -10600 1425 -10595 1433.75 -10595 1437.5 -10600 {fill=true}
P 5 7 575 -6980 571.25 -6985 562.5 -6985 566.25 -6980 562.5 -6975 571.25 -6975 575 -6980 {fill=true}
P 5 7 897.5 -7010 893.75 -7015 885 -7015 888.75 -7010 885 -7005 893.75 -7005 897.5 -7010 {fill=true}
P 5 7 1115 -6980 1111.25 -6985 1102.5 -6985 1106.25 -6980 1102.5 -6975 1111.25 -6975 1115 -6980 {fill=true}
P 5 7 1437.5 -7010 1433.75 -7015 1425 -7015 1428.75 -7010 1425 -7005 1433.75 -7005 1437.5 -7010 {fill=true}
P 5 7 575 -6580 571.25 -6585 562.5 -6585 566.25 -6580 562.5 -6575 571.25 -6575 575 -6580 {fill=true}
P 5 7 897.5 -6610 893.75 -6615 885 -6615 888.75 -6610 885 -6605 893.75 -6605 897.5 -6610 {fill=true}
P 5 7 1115 -6580 1111.25 -6585 1102.5 -6585 1106.25 -6580 1102.5 -6575 1111.25 -6575 1115 -6580 {fill=true}
P 5 7 1437.5 -6610 1433.75 -6615 1425 -6615 1428.75 -6610 1425 -6605 1433.75 -6605 1437.5 -6610 {fill=true}
P 5 7 575 -6140 571.25 -6145 562.5 -6145 566.25 -6140 562.5 -6135 571.25 -6135 575 -6140 {fill=true}
P 5 7 1765 -6140 1761.25 -6145 1752.5 -6145 1756.25 -6140 1752.5 -6135 1761.25 -6135 1765 -6140 {fill=true}
P 5 7 1135 -6140 1131.25 -6145 1122.5 -6145 1126.25 -6140 1122.5 -6135 1131.25 -6135 1135 -6140 {fill=true}
P 5 7 1105 -10200 1101.25 -10205 1092.5 -10205 1096.25 -10200 1092.5 -10195 1101.25 -10195 1105 -10200 {fill=true}
P 5 7 1427.5 -10230 1423.75 -10235 1415 -10235 1418.75 -10230 1415 -10225 1423.75 -10225 1427.5 -10230 {fill=true}
P 5 7 575 -10200 571.25 -10205 562.5 -10205 566.25 -10200 562.5 -10195 571.25 -10195 575 -10200 {fill=true}
P 5 7 897.5 -10230 893.75 -10235 885 -10235 888.75 -10230 885 -10225 893.75 -10225 897.5 -10230 {fill=true}
P 5 7 1605 -10200 1601.25 -10205 1592.5 -10205 1596.25 -10200 1592.5 -10195 1601.25 -10195 1605 -10200 {fill=true}
P 5 7 1927.5 -10230 1923.75 -10235 1915 -10235 1918.75 -10230 1915 -10225 1923.75 -10225 1927.5 -10230 {fill=true}
P 5 7 1645 -11500 1641.25 -11505 1632.5 -11505 1636.25 -11500 1632.5 -11495 1641.25 -11495 1645 -11500 {fill=true}
P 5 7 1967.5 -11530 1963.75 -11535 1955 -11535 1958.75 -11530 1955 -11525 1963.75 -11525 1967.5 -11530 {fill=true}
P 5 7 520 -11500 516.25 -11505 507.5 -11505 511.25 -11500 507.5 -11495 516.25 -11495 520 -11500 {fill=true}
P 5 7 842.5 -11530 838.75 -11535 830 -11535 833.75 -11530 830 -11525 838.75 -11525 842.5 -11530 {fill=true}
P 5 7 2105 -11500 2101.25 -11505 2092.5 -11505 2096.25 -11500 2092.5 -11495 2101.25 -11495 2105 -11500 {fill=true}
P 5 7 2427.5 -11530 2423.75 -11535 2415 -11535 2418.75 -11530 2415 -11525 2423.75 -11525 2427.5 -11530 {fill=true}
P 5 7 595 -9360 591.25 -9365 582.5 -9365 586.25 -9360 582.5 -9355 591.25 -9355 595 -9360 {fill=true}
P 5 7 917.5 -9390 913.75 -9395 905 -9395 908.75 -9390 905 -9385 913.75 -9385 917.5 -9390 {fill=true}
P 5 7 1135 -9360 1131.25 -9365 1122.5 -9365 1126.25 -9360 1122.5 -9355 1131.25 -9355 1135 -9360 {fill=true}
P 5 7 1457.5 -9390 1453.75 -9395 1445 -9395 1448.75 -9390 1445 -9385 1453.75 -9385 1457.5 -9390 {fill=true}
P 5 7 2265 -9360 2261.25 -9365 2252.5 -9365 2256.25 -9360 2252.5 -9355 2261.25 -9355 2265 -9360 {fill=true}
P 5 7 2587.5 -9390 2583.75 -9395 2575 -9395 2578.75 -9390 2575 -9385 2583.75 -9385 2587.5 -9390 {fill=true}
P 5 7 1105 -11500 1101.25 -11505 1092.5 -11505 1096.25 -11500 1092.5 -11495 1101.25 -11495 1105 -11500 {fill=true}
P 5 7 1427.5 -11530 1423.75 -11535 1415 -11535 1418.75 -11530 1415 -11525 1423.75 -11525 1427.5 -11530 {fill=true}
P 5 7 655 -1670 651.25 -1675 642.5 -1675 646.25 -1670 642.5 -1665 651.25 -1665 655 -1670 {fill=true}
P 5 7 977.5 -1700 973.75 -1705 965 -1705 968.75 -1700 965 -1695 973.75 -1695 977.5 -1700 {fill=true}
P 5 7 1255 -1670 1251.25 -1675 1242.5 -1675 1246.25 -1670 1242.5 -1665 1251.25 -1665 1255 -1670 {fill=true}
P 5 7 1577.5 -1700 1573.75 -1705 1565 -1705 1568.75 -1700 1565 -1695 1573.75 -1695 1577.5 -1700 {fill=true}
P 5 7 1865 -1670 1861.25 -1675 1852.5 -1675 1856.25 -1670 1852.5 -1665 1861.25 -1665 1865 -1670 {fill=true}
P 5 7 2187.5 -1700 2183.75 -1705 2175 -1705 2178.75 -1700 2175 -1695 2183.75 -1695 2187.5 -1700 {fill=true}
P 5 7 595 -5730 591.25 -5735 582.5 -5735 586.25 -5730 582.5 -5725 591.25 -5725 595 -5730 {fill=true}
P 5 7 917.5 -5760 913.75 -5765 905 -5765 908.75 -5760 905 -5755 913.75 -5755 917.5 -5760 {fill=true}
P 5 7 1155 -5730 1151.25 -5735 1142.5 -5735 1146.25 -5730 1142.5 -5725 1151.25 -5725 1155 -5730 {fill=true}
P 5 7 1477.5 -5760 1473.75 -5765 1465 -5765 1468.75 -5760 1465 -5755 1473.75 -5755 1477.5 -5760 {fill=true}
P 5 7 540 -9780 536.25 -9785 527.5 -9785 531.25 -9780 527.5 -9775 536.25 -9775 540 -9780 {fill=true}
P 5 7 862.5 -9810 858.75 -9815 850 -9815 853.75 -9810 850 -9805 858.75 -9805 862.5 -9810 {fill=true}
P 5 7 1105 -9780 1101.25 -9785 1092.5 -9785 1096.25 -9780 1092.5 -9775 1101.25 -9775 1105 -9780 {fill=true}
P 5 7 1427.5 -9810 1423.75 -9815 1415 -9815 1418.75 -9810 1415 -9805 1423.75 -9805 1427.5 -9810 {fill=true}
P 5 7 1605 -9780 1601.25 -9785 1592.5 -9785 1596.25 -9780 1592.5 -9775 1601.25 -9775 1605 -9780 {fill=true}
P 5 7 1927.5 -9810 1923.75 -9815 1915 -9815 1918.75 -9810 1915 -9805 1923.75 -9805 1927.5 -9810 {fill=true}
P 5 7 2095 -9780 2091.25 -9785 2082.5 -9785 2086.25 -9780 2082.5 -9775 2091.25 -9775 2095 -9780 {fill=true}
P 5 7 2417.5 -9810 2413.75 -9815 2405 -9815 2408.75 -9810 2405 -9805 2413.75 -9805 2417.5 -9810 {fill=true}
P 7 14 905 -10887.5 910 -10887.5 915 -10887.5 915 -10882.5 915 -10862.5 915 -10857.5 910 -10857.5 900 -10857.5 895 -10857.5 895 -10862.5 895 -10882.5 895 -10887.5 900 -10887.5 905 -10887.5 {fill=1
bezier=1}
P 7 14 1335 -10887.5 1340 -10887.5 1345 -10887.5 1345 -10882.5 1345 -10862.5 1345 -10857.5 1340 -10857.5 1330 -10857.5 1325 -10857.5 1325 -10862.5 1325 -10882.5 1325 -10887.5 1330 -10887.5 1335 -10887.5 {fill=1
bezier=1}
P 7 14 1405 -10697.5 1410 -10697.5 1415 -10697.5 1415 -10692.5 1415 -10672.5 1415 -10667.5 1410 -10667.5 1400 -10667.5 1395 -10667.5 1395 -10672.5 1395 -10692.5 1395 -10697.5 1400 -10697.5 1405 -10697.5 {fill=1
bezier=1}
P 7 14 1425 -7117.5 1430 -7117.5 1435 -7117.5 1435 -7112.5 1435 -7092.5 1435 -7087.5 1430 -7087.5 1420 -7087.5 1415 -7087.5 1415 -7092.5 1415 -7112.5 1415 -7117.5 1420 -7117.5 1425 -7117.5 {fill=1
bezier=1}
P 7 14 1425 -6717.5 1430 -6717.5 1435 -6717.5 1435 -6712.5 1435 -6692.5 1435 -6687.5 1430 -6687.5 1420 -6687.5 1415 -6687.5 1415 -6692.5 1415 -6712.5 1415 -6717.5 1420 -6717.5 1425 -6717.5 {fill=1
bezier=1}
P 7 14 935 -6037.5 940 -6037.5 945 -6037.5 945 -6032.5 945 -6012.5 945 -6007.5 940 -6007.5 930 -6007.5 925 -6007.5 925 -6012.5 925 -6032.5 925 -6037.5 930 -6037.5 935 -6037.5 {fill=1
bezier=1}
P 7 14 1435 -6047.5 1440 -6047.5 1445 -6047.5 1445 -6042.5 1445 -6022.5 1445 -6017.5 1440 -6017.5 1430 -6017.5 1425 -6017.5 1425 -6022.5 1425 -6042.5 1425 -6047.5 1430 -6047.5 1435 -6047.5 {fill=1
bezier=1}
P 7 14 905 -10057.5 910 -10057.5 915 -10057.5 915 -10052.5 915 -10032.5 915 -10027.5 910 -10027.5 900 -10027.5 895 -10027.5 895 -10032.5 895 -10052.5 895 -10057.5 900 -10057.5 905 -10057.5 {fill=1
bezier=1}
P 7 14 850 -11357.5 855 -11357.5 860 -11357.5 860 -11352.5 860 -11332.5 860 -11327.5 855 -11327.5 845 -11327.5 840 -11327.5 840 -11332.5 840 -11352.5 840 -11357.5 845 -11357.5 850 -11357.5 {fill=1
bezier=1}
P 7 14 1615 -11347.5 1620 -11347.5 1625 -11347.5 1625 -11342.5 1625 -11322.5 1625 -11317.5 1620 -11317.5 1610 -11317.5 1605 -11317.5 1605 -11322.5 1605 -11342.5 1605 -11347.5 1610 -11347.5 1615 -11347.5 {fill=1
bezier=1}
P 7 14 2395 -11337.5 2400 -11337.5 2405 -11337.5 2405 -11332.5 2405 -11312.5 2405 -11307.5 2400 -11307.5 2390 -11307.5 2385 -11307.5 2385 -11312.5 2385 -11332.5 2385 -11337.5 2390 -11337.5 2395 -11337.5 {fill=1
bezier=1}
P 7 14 675 -9477.5 680 -9477.5 685 -9477.5 685 -9472.5 685 -9452.5 685 -9447.5 680 -9447.5 670 -9447.5 665 -9447.5 665 -9452.5 665 -9472.5 665 -9477.5 670 -9477.5 675 -9477.5 {fill=1
bezier=1}
P 7 14 1335 -9497.5 1340 -9497.5 1345 -9497.5 1345 -9492.5 1345 -9472.5 1345 -9467.5 1340 -9467.5 1330 -9467.5 1325 -9467.5 1325 -9472.5 1325 -9492.5 1325 -9497.5 1330 -9497.5 1335 -9497.5 {fill=1
bezier=1}
P 7 14 1415 -5257.5 1420 -5257.5 1425 -5257.5 1425 -5252.5 1425 -5232.5 1425 -5227.5 1420 -5227.5 1410 -5227.5 1405 -5227.5 1405 -5232.5 1405 -5252.5 1405 -5257.5 1410 -5257.5 1415 -5257.5 {fill=1
bezier=1}
P 7 14 2065 -2527.5 2070 -2527.5 2075 -2527.5 2075 -2522.5 2075 -2502.5 2075 -2497.5 2070 -2497.5 2060 -2497.5 2055 -2497.5 2055 -2502.5 2055 -2522.5 2055 -2527.5 2060 -2527.5 2065 -2527.5 {fill=1
bezier=1}
P 7 14 1555 -2497.5 1560 -2497.5 1565 -2497.5 1565 -2492.5 1565 -2472.5 1565 -2467.5 1560 -2467.5 1550 -2467.5 1545 -2467.5 1545 -2472.5 1545 -2492.5 1545 -2497.5 1550 -2497.5 1555 -2497.5 {fill=1
bezier=1}
P 7 14 1445 -4897.5 1440 -4897.5 1435 -4897.5 1435 -4892.5 1435 -4872.5 1435 -4867.5 1440 -4867.5 1450 -4867.5 1455 -4867.5 1455 -4872.5 1455 -4892.5 1455 -4897.5 1450 -4897.5 1445 -4897.5 {fill=1
bezier=1}
P 7 14 1945 -5007.5 1950 -5007.5 1955 -5007.5 1955 -5002.5 1955 -4982.5 1955 -4977.5 1950 -4977.5 1940 -4977.5 1935 -4977.5 1935 -4982.5 1935 -5002.5 1935 -5007.5 1940 -5007.5 1945 -5007.5 {fill=1
bezier=1}
P 7 14 1565 -4487.5 1570 -4487.5 1575 -4487.5 1575 -4482.5 1575 -4462.5 1575 -4457.5 1570 -4457.5 1560 -4457.5 1555 -4457.5 1555 -4462.5 1555 -4482.5 1555 -4487.5 1560 -4487.5 1565 -4487.5 {fill=1
bezier=1}
P 7 14 2055 -4547.5 2060 -4547.5 2065 -4547.5 2065 -4542.5 2065 -4522.5 2065 -4517.5 2060 -4517.5 2050 -4517.5 2045 -4517.5 2045 -4522.5 2045 -4542.5 2045 -4547.5 2050 -4547.5 2055 -4547.5 {fill=1
bezier=1}
P 7 14 975 -11627.5 980 -11627.5 985 -11627.5 985 -11622.5 985 -11602.5 985 -11597.5 980 -11597.5 970 -11597.5 965 -11597.5 965 -11602.5 965 -11622.5 965 -11627.5 970 -11627.5 975 -11627.5 {fill=1
bezier=1}
P 7 14 1555 -2117.5 1560 -2117.5 1565 -2117.5 1565 -2112.5 1565 -2092.5 1565 -2087.5 1560 -2087.5 1550 -2087.5 1545 -2087.5 1545 -2092.5 1545 -2112.5 1545 -2117.5 1550 -2117.5 1555 -2117.5 {fill=1
bezier=1}
P 7 14 2065 -2067.5 2070 -2067.5 2075 -2067.5 2075 -2062.5 2075 -2042.5 2075 -2037.5 2070 -2037.5 2060 -2037.5 2055 -2037.5 2055 -2042.5 2055 -2062.5 2055 -2067.5 2060 -2067.5 2065 -2067.5 {fill=1
bezier=1}
P 7 14 2485 -4927.5 2490 -4927.5 2495 -4927.5 2495 -4922.5 2495 -4902.5 2495 -4897.5 2490 -4897.5 2480 -4897.5 2475 -4897.5 2475 -4902.5 2475 -4922.5 2475 -4927.5 2480 -4927.5 2485 -4927.5 {fill=1
bezier=1}
P 7 14 1805 -2967.5 1810 -2967.5 1815 -2967.5 1815 -2962.5 1815 -2942.5 1815 -2937.5 1810 -2937.5 1800 -2937.5 1795 -2937.5 1795 -2942.5 1795 -2962.5 1795 -2967.5 1800 -2967.5 1805 -2967.5 {fill=1
bezier=1}
P 7 14 655 -2897.5 660 -2897.5 665 -2897.5 665 -2892.5 665 -2872.5 665 -2867.5 660 -2867.5 650 -2867.5 645 -2867.5 645 -2872.5 645 -2892.5 645 -2897.5 650 -2897.5 655 -2897.5 {fill=1
bezier=1}
P 7 14 775 -2897.5 780 -2897.5 785 -2897.5 785 -2892.5 785 -2872.5 785 -2867.5 780 -2867.5 770 -2867.5 765 -2867.5 765 -2872.5 765 -2892.5 765 -2897.5 770 -2897.5 775 -2897.5 {fill=1
bezier=1}
P 7 14 1615 -1567.5 1610 -1567.5 1605 -1567.5 1605 -1562.5 1605 -1542.5 1605 -1537.5 1610 -1537.5 1620 -1537.5 1625 -1537.5 1625 -1542.5 1625 -1562.5 1625 -1567.5 1620 -1567.5 1615 -1567.5 {fill=1
bezier=1}
P 7 14 2265 -6047.5 2270 -6047.5 2275 -6047.5 2275 -6042.5 2275 -6022.5 2275 -6017.5 2270 -6017.5 2260 -6017.5 2255 -6017.5 2255 -6022.5 2255 -6042.5 2255 -6047.5 2260 -6047.5 2265 -6047.5 {fill=1
bezier=1}
P 7 14 1965 -5257.5 1970 -5257.5 1975 -5257.5 1975 -5252.5 1975 -5232.5 1975 -5227.5 1970 -5227.5 1960 -5227.5 1955 -5227.5 1955 -5232.5 1955 -5252.5 1955 -5257.5 1960 -5257.5 1965 -5257.5 {fill=1
bezier=1}
P 7 14 2325 -3557.5 2330 -3557.5 2335 -3557.5 2335 -3552.5 2335 -3532.5 2335 -3527.5 2330 -3527.5 2320 -3527.5 2315 -3527.5 2315 -3532.5 2315 -3552.5 2315 -3557.5 2320 -3557.5 2325 -3557.5 {fill=1
bezier=1}
P 7 14 795 -3677.5 800 -3677.5 805 -3677.5 805 -3672.5 805 -3652.5 805 -3647.5 800 -3647.5 790 -3647.5 785 -3647.5 785 -3652.5 785 -3672.5 785 -3677.5 790 -3677.5 795 -3677.5 {fill=1
bezier=1}
P 7 14 1335 -3657.5 1340 -3657.5 1345 -3657.5 1345 -3652.5 1345 -3632.5 1345 -3627.5 1340 -3627.5 1330 -3627.5 1325 -3627.5 1325 -3632.5 1325 -3652.5 1325 -3657.5 1330 -3657.5 1335 -3657.5 {fill=1
bezier=1}
P 7 14 1245 -3277.5 1250 -3277.5 1255 -3277.5 1255 -3272.5 1255 -3252.5 1255 -3247.5 1250 -3247.5 1240 -3247.5 1235 -3247.5 1235 -3252.5 1235 -3272.5 1235 -3277.5 1240 -3277.5 1245 -3277.5 {fill=1
bezier=1}
P 7 14 2505 -3227.5 2510 -3227.5 2515 -3227.5 2515 -3222.5 2515 -3202.5 2515 -3197.5 2510 -3197.5 2500 -3197.5 2495 -3197.5 2495 -3202.5 2495 -3222.5 2495 -3227.5 2500 -3227.5 2505 -3227.5 {fill=1
bezier=1}
P 7 14 2465 -1817.5 2460 -1817.5 2455 -1817.5 2455 -1812.5 2455 -1792.5 2455 -1787.5 2460 -1787.5 2470 -1787.5 2475 -1787.5 2475 -1792.5 2475 -1812.5 2475 -1817.5 2470 -1817.5 2465 -1817.5 {fill=1
bezier=1}
P 7 14 2525 -9547.5 2530 -9547.5 2535 -9547.5 2535 -9542.5 2535 -9522.5 2535 -9517.5 2530 -9517.5 2520 -9517.5 2515 -9517.5 2515 -9522.5 2515 -9542.5 2515 -9547.5 2520 -9547.5 2525 -9547.5 {fill=1
bezier=1}
P 7 14 1335 -10057.5 1340 -10057.5 1345 -10057.5 1345 -10052.5 1345 -10032.5 1345 -10027.5 1340 -10027.5 1330 -10027.5 1325 -10027.5 1325 -10032.5 1325 -10052.5 1325 -10057.5 1330 -10057.5 1335 -10057.5 {fill=1
bezier=1}
P 7 14 2105 -10057.5 2110 -10057.5 2115 -10057.5 2115 -10052.5 2115 -10032.5 2115 -10027.5 2110 -10027.5 2100 -10027.5 2095 -10027.5 2095 -10032.5 2095 -10052.5 2095 -10057.5 2100 -10057.5 2105 -10057.5 {fill=1
bezier=1}
P 7 14 355 -8907.5 360 -8907.5 365 -8907.5 365 -8902.5 365 -8882.5 365 -8877.5 360 -8877.5 350 -8877.5 345 -8877.5 345 -8882.5 345 -8902.5 345 -8907.5 350 -8907.5 355 -8907.5 {fill=1
bezier=1}
P 7 14 885 -9077.5 890 -9077.5 895 -9077.5 895 -9072.5 895 -9052.5 895 -9047.5 890 -9047.5 880 -9047.5 875 -9047.5 875 -9052.5 875 -9072.5 875 -9077.5 880 -9077.5 885 -9077.5 {fill=1
bezier=1}
P 7 14 1135 -9117.5 1140 -9117.5 1145 -9117.5 1145 -9112.5 1145 -9092.5 1145 -9087.5 1140 -9087.5 1130 -9087.5 1125 -9087.5 1125 -9092.5 1125 -9112.5 1125 -9117.5 1130 -9117.5 1135 -9117.5 {fill=1
bezier=1}
P 7 14 1425 -9117.5 1430 -9117.5 1435 -9117.5 1435 -9112.5 1435 -9092.5 1435 -9087.5 1430 -9087.5 1420 -9087.5 1415 -9087.5 1415 -9092.5 1415 -9112.5 1415 -9117.5 1420 -9117.5 1425 -9117.5 {fill=1
bezier=1}
P 7 14 1885 -9077.5 1890 -9077.5 1895 -9077.5 1895 -9072.5 1895 -9052.5 1895 -9047.5 1890 -9047.5 1880 -9047.5 1875 -9047.5 1875 -9052.5 1875 -9072.5 1875 -9077.5 1880 -9077.5 1885 -9077.5 {fill=1
bezier=1}
P 7 14 2105 -10887.5 2110 -10887.5 2115 -10887.5 2115 -10882.5 2115 -10862.5 2115 -10857.5 2110 -10857.5 2100 -10857.5 2095 -10857.5 2095 -10862.5 2095 -10882.5 2095 -10887.5 2100 -10887.5 2105 -10887.5 {fill=1
bezier=1}
P 7 14 2585 -4677.5 2590 -4677.5 2595 -4677.5 2595 -4672.5 2595 -4652.5 2595 -4647.5 2590 -4647.5 2580 -4647.5 2575 -4647.5 2575 -4652.5 2575 -4672.5 2575 -4677.5 2580 -4677.5 2585 -4677.5 {fill=1
bezier=1}
P 7 14 915 -5627.5 920 -5627.5 925 -5627.5 925 -5622.5 925 -5602.5 925 -5597.5 920 -5597.5 910 -5597.5 905 -5597.5 905 -5602.5 905 -5622.5 905 -5627.5 910 -5627.5 915 -5627.5 {fill=1
bezier=1}
P 7 14 1755 -5677.5 1760 -5677.5 1765 -5677.5 1765 -5672.5 1765 -5652.5 1765 -5647.5 1760 -5647.5 1750 -5647.5 1745 -5647.5 1745 -5652.5 1745 -5672.5 1745 -5677.5 1750 -5677.5 1755 -5677.5 {fill=1
bezier=1}
P 7 14 2515 -5677.5 2520 -5677.5 2525 -5677.5 2525 -5672.5 2525 -5652.5 2525 -5647.5 2520 -5647.5 2510 -5647.5 2505 -5647.5 2505 -5652.5 2505 -5672.5 2505 -5677.5 2510 -5677.5 2515 -5677.5 {fill=1
bezier=1}
P 7 14 890 -9897.5 895 -9897.5 900 -9897.5 900 -9892.5 900 -9872.5 900 -9867.5 895 -9867.5 885 -9867.5 880 -9867.5 880 -9872.5 880 -9892.5 880 -9897.5 885 -9897.5 890 -9897.5 {fill=1
bezier=1}
P 7 14 1425 -9777.5 1430 -9777.5 1435 -9777.5 1435 -9772.5 1435 -9752.5 1435 -9747.5 1430 -9747.5 1420 -9747.5 1415 -9747.5 1415 -9752.5 1415 -9772.5 1415 -9777.5 1420 -9777.5 1425 -9777.5 {fill=1
bezier=1}
P 7 14 1795 -9777.5 1800 -9777.5 1805 -9777.5 1805 -9772.5 1805 -9752.5 1805 -9747.5 1800 -9747.5 1790 -9747.5 1785 -9747.5 1785 -9752.5 1785 -9772.5 1785 -9777.5 1790 -9777.5 1795 -9777.5 {fill=1
bezier=1}
P 7 14 2285 -9777.5 2290 -9777.5 2295 -9777.5 2295 -9772.5 2295 -9752.5 2295 -9747.5 2290 -9747.5 2280 -9747.5 2275 -9747.5 2275 -9752.5 2275 -9772.5 2275 -9777.5 2280 -9777.5 2285 -9777.5 {fill=1
bezier=1}
P 7 14 2235 -8927.5 2240 -8927.5 2245 -8927.5 2245 -8922.5 2245 -8902.5 2245 -8897.5 2240 -8897.5 2230 -8897.5 2225 -8897.5 2225 -8902.5 2225 -8922.5 2225 -8927.5 2230 -8927.5 2235 -8927.5 {fill=1
bezier=1}
P 7 14 2465 -8987.5 2470 -8987.5 2475 -8987.5 2475 -8982.5 2475 -8962.5 2475 -8957.5 2470 -8957.5 2460 -8957.5 2455 -8957.5 2455 -8962.5 2455 -8982.5 2455 -8987.5 2460 -8987.5 2465 -8987.5 {fill=1
bezier=1}
P 7 14 605 -9117.5 610 -9117.5 615 -9117.5 615 -9112.5 615 -9092.5 615 -9087.5 610 -9087.5 600 -9087.5 595 -9087.5 595 -9092.5 595 -9112.5 595 -9117.5 600 -9117.5 605 -9117.5 {fill=1
bezier=1}
P 7 14 635 -937.5 640 -937.5 645 -937.5 645 -932.5 645 -912.5 645 -907.5 640 -907.5 630 -907.5 625 -907.5 625 -912.5 625 -932.5 625 -937.5 630 -937.5 635 -937.5 {fill=1
bezier=1}
P 7 14 1505 -907.5 1510 -907.5 1515 -907.5 1515 -902.5 1515 -882.5 1515 -877.5 1510 -877.5 1500 -877.5 1495 -877.5 1495 -882.5 1495 -902.5 1495 -907.5 1500 -907.5 1505 -907.5 {fill=1
bezier=1}
P 7 14 2435 -967.5 2440 -967.5 2445 -967.5 2445 -962.5 2445 -942.5 2445 -937.5 2440 -937.5 2430 -937.5 2425 -937.5 2425 -942.5 2425 -962.5 2425 -967.5 2430 -967.5 2435 -967.5 {fill=1
bezier=1}
P 7 14 2195 -12017.5 2200 -12017.5 2205 -12017.5 2205 -12012.5 2205 -11992.5 2205 -11987.5 2200 -11987.5 2190 -11987.5 2185 -11987.5 2185 -11992.5 2185 -12012.5 2185 -12017.5 2190 -12017.5 2195 -12017.5 {fill=1
bezier=1}
P 7 14 945 -607.5 950 -607.5 955 -607.5 955 -602.5 955 -582.5 955 -577.5 950 -577.5 940 -577.5 935 -577.5 935 -582.5 935 -602.5 935 -607.5 940 -607.5 945 -607.5 {fill=1
bezier=1}
P 7 14 1115 -327.5 1120 -327.5 1125 -327.5 1125 -322.5 1125 -302.5 1125 -297.5 1120 -297.5 1110 -297.5 1105 -297.5 1105 -302.5 1105 -322.5 1105 -327.5 1110 -327.5 1115 -327.5 {fill=1
bezier=1}
P 9 8 1770 -9440 1912.5 -9412.5 1890 -9380 1980 -9320 1960 -9290 1870 -9350 1845 -9315 1770 -9440 {fill=0}
P 10 7 880 -10860 872.5 -10867.5 877.5 -10872.5 862.5 -10877.5 867.5 -10862.5 872.5 -10867.5 880 -10860 {fill=1}
P 10 7 2110 -10910 2102.5 -10917.5 2107.5 -10922.5 2092.5 -10927.5 2097.5 -10912.5 2102.5 -10917.5 2110 -10910 {fill=1}
P 10 7 1330 -10900 1322.5 -10907.5 1327.5 -10912.5 1312.5 -10917.5 1317.5 -10902.5 1322.5 -10907.5 1330 -10900 {fill=1}
P 10 7 760 -10640 752.5 -10647.5 757.5 -10652.5 742.5 -10657.5 747.5 -10642.5 752.5 -10647.5 760 -10640 {fill=1}
P 10 7 1380 -10640 1372.5 -10647.5 1377.5 -10652.5 1362.5 -10657.5 1367.5 -10642.5 1372.5 -10647.5 1380 -10640 {fill=1}
P 10 7 760 -7050 752.5 -7057.5 757.5 -7062.5 742.5 -7067.5 747.5 -7052.5 752.5 -7057.5 760 -7050 {fill=1}
P 10 7 1380 -7050 1372.5 -7057.5 1377.5 -7062.5 1362.5 -7067.5 1367.5 -7052.5 1372.5 -7057.5 1380 -7050 {fill=1}
P 10 7 760 -6650 752.5 -6657.5 757.5 -6662.5 742.5 -6667.5 747.5 -6652.5 752.5 -6657.5 760 -6650 {fill=1}
P 10 7 1380 -6650 1372.5 -6657.5 1377.5 -6662.5 1362.5 -6667.5 1367.5 -6652.5 1372.5 -6657.5 1380 -6650 {fill=1}
P 10 7 920 -5980 912.5 -5987.5 917.5 -5992.5 902.5 -5997.5 907.5 -5982.5 912.5 -5987.5 920 -5980 {fill=1}
P 10 7 1410 -6040 1402.5 -6047.5 1407.5 -6052.5 1392.5 -6057.5 1397.5 -6042.5 1402.5 -6047.5 1410 -6040 {fill=1}
P 10 7 2230 -6040 2222.5 -6047.5 2227.5 -6052.5 2212.5 -6057.5 2217.5 -6042.5 2222.5 -6047.5 2230 -6040 {fill=1}
P 10 7 880 -10030 872.5 -10037.5 877.5 -10042.5 862.5 -10047.5 867.5 -10032.5 872.5 -10037.5 880 -10030 {fill=1}
P 10 7 2110 -10080 2102.5 -10087.5 2107.5 -10092.5 2092.5 -10097.5 2097.5 -10082.5 2102.5 -10087.5 2110 -10080 {fill=1}
P 10 7 1330 -10070 1322.5 -10077.5 1327.5 -10082.5 1312.5 -10087.5 1317.5 -10072.5 1322.5 -10077.5 1330 -10070 {fill=1}
P 10 7 825 -11330 817.5 -11337.5 822.5 -11342.5 807.5 -11347.5 812.5 -11332.5 817.5 -11337.5 825 -11330 {fill=1}
P 10 7 1630 -11360 1622.5 -11367.5 1627.5 -11372.5 1612.5 -11377.5 1617.5 -11362.5 1622.5 -11367.5 1630 -11360 {fill=1}
P 10 7 2410 -11350 2402.5 -11357.5 2407.5 -11362.5 2392.5 -11367.5 2397.5 -11352.5 2402.5 -11357.5 2410 -11350 {fill=1}
P 10 7 730 -9490 722.5 -9497.5 727.5 -9502.5 712.5 -9507.5 717.5 -9492.5 722.5 -9497.5 730 -9490 {fill=1}
P 10 7 1310 -9490 1302.5 -9497.5 1307.5 -9502.5 1292.5 -9507.5 1297.5 -9492.5 1302.5 -9497.5 1310 -9490 {fill=1}
P 10 7 2520 -9560 2512.5 -9567.5 2517.5 -9572.5 2502.5 -9577.5 2507.5 -9562.5 2512.5 -9567.5 2520 -9560 {fill=1}
P 10 7 1380 -5250 1372.5 -5257.5 1377.5 -5262.5 1362.5 -5267.5 1367.5 -5252.5 1372.5 -5257.5 1380 -5250 {fill=1}
P 10 7 1920 -5290 1912.5 -5297.5 1917.5 -5302.5 1902.5 -5307.5 1907.5 -5292.5 1912.5 -5297.5 1920 -5290 {fill=1}
P 10 7 660 -4150 652.5 -4157.5 657.5 -4162.5 642.5 -4167.5 647.5 -4152.5 652.5 -4157.5 660 -4150 {fill=1}
P 10 7 1240 -4150 1232.5 -4157.5 1237.5 -4162.5 1222.5 -4167.5 1227.5 -4152.5 1232.5 -4157.5 1240 -4150 {fill=1}
P 10 7 1010 -11640 1002.5 -11647.5 1007.5 -11652.5 992.5 -11657.5 997.5 -11642.5 1002.5 -11647.5 1010 -11640 {fill=1}
P 10 7 680 -3910 672.5 -3917.5 677.5 -3922.5 662.5 -3927.5 667.5 -3912.5 672.5 -3917.5 680 -3910 {fill=1}
P 10 7 1300 -3820 1292.5 -3827.5 1297.5 -3832.5 1282.5 -3837.5 1287.5 -3822.5 1292.5 -3827.5 1300 -3820 {fill=1}
P 10 7 760 -3640 752.5 -3647.5 757.5 -3652.5 742.5 -3657.5 747.5 -3642.5 752.5 -3647.5 760 -3640 {fill=1}
P 10 7 1300 -3610 1292.5 -3617.5 1297.5 -3622.5 1282.5 -3627.5 1287.5 -3612.5 1292.5 -3617.5 1300 -3610 {fill=1}
P 10 7 2350 -3580 2342.5 -3587.5 2347.5 -3592.5 2332.5 -3597.5 2337.5 -3582.5 2342.5 -3587.5 2350 -3580 {fill=1}
P 10 7 1830 -2860 1822.5 -2867.5 1827.5 -2872.5 1812.5 -2877.5 1817.5 -2862.5 1822.5 -2867.5 1830 -2860 {fill=1}
P 10 7 700 -2930 692.5 -2937.5 697.5 -2942.5 682.5 -2947.5 687.5 -2932.5 692.5 -2937.5 700 -2930 {fill=1}
P 10 7 820 -2930 812.5 -2937.5 817.5 -2942.5 802.5 -2947.5 807.5 -2932.5 812.5 -2937.5 820 -2930 {fill=1}
P 10 7 930 -1650 922.5 -1657.5 927.5 -1662.5 912.5 -1667.5 917.5 -1652.5 922.5 -1657.5 930 -1650 {fill=1}
P 10 7 1530 -1650 1522.5 -1657.5 1527.5 -1662.5 1512.5 -1667.5 1517.5 -1652.5 1522.5 -1657.5 1530 -1650 {fill=1}
P 10 7 760 -3210 752.5 -3217.5 757.5 -3222.5 742.5 -3227.5 747.5 -3212.5 752.5 -3217.5 760 -3210 {fill=1}
P 10 7 1220 -3260 1212.5 -3267.5 1217.5 -3272.5 1202.5 -3277.5 1207.5 -3262.5 1212.5 -3267.5 1220 -3260 {fill=1}
P 10 7 840 -4900 832.5 -4907.5 837.5 -4912.5 822.5 -4917.5 827.5 -4902.5 832.5 -4907.5 840 -4900 {fill=1}
P 10 7 1380 -4900 1372.5 -4907.5 1377.5 -4912.5 1362.5 -4917.5 1367.5 -4902.5 1372.5 -4907.5 1380 -4900 {fill=1}
P 10 7 1920 -4980 1912.5 -4987.5 1917.5 -4992.5 1902.5 -4997.5 1907.5 -4982.5 1912.5 -4987.5 1920 -4980 {fill=1}
P 10 7 2460 -4900 2452.5 -4907.5 2457.5 -4912.5 2442.5 -4917.5 2447.5 -4902.5 2452.5 -4907.5 2460 -4900 {fill=1}
P 10 7 2560 -4650 2552.5 -4657.5 2557.5 -4662.5 2542.5 -4667.5 2547.5 -4652.5 2552.5 -4657.5 2560 -4650 {fill=1}
P 10 7 2030 -4550 2022.5 -4557.5 2027.5 -4562.5 2012.5 -4567.5 2017.5 -4552.5 2022.5 -4557.5 2030 -4550 {fill=1}
P 10 7 1520 -4540 1512.5 -4547.5 1517.5 -4552.5 1502.5 -4557.5 1507.5 -4542.5 1512.5 -4547.5 1520 -4540 {fill=1}
P 10 8 1770 -9440 1912.5 -9412.5 1890 -9380 1980 -9320 1960 -9290 1870 -9350 1845 -9315 1770 -9440 {fill=1}
P 10 7 2470 -3220 2462.5 -3227.5 2467.5 -3232.5 2452.5 -3237.5 2457.5 -3222.5 2462.5 -3227.5 2470 -3220 {fill=1}
P 10 7 2450 -1830 2442.5 -1837.5 2447.5 -1842.5 2432.5 -1847.5 2437.5 -1832.5 2442.5 -1837.5 2450 -1830 {fill=1}
P 10 7 380 -8980 372.5 -8987.5 377.5 -8992.5 362.5 -8997.5 367.5 -8982.5 372.5 -8987.5 380 -8980 {fill=1}
P 10 7 860 -9050 852.5 -9057.5 857.5 -9062.5 842.5 -9067.5 847.5 -9052.5 852.5 -9057.5 860 -9050 {fill=1}
P 10 7 1110 -9090 1102.5 -9097.5 1107.5 -9102.5 1092.5 -9107.5 1097.5 -9092.5 1102.5 -9097.5 1110 -9090 {fill=1}
P 10 7 1400 -9090 1392.5 -9097.5 1397.5 -9102.5 1382.5 -9107.5 1387.5 -9092.5 1392.5 -9097.5 1400 -9090 {fill=1}
P 10 7 1900 -9090 1892.5 -9097.5 1897.5 -9102.5 1882.5 -9107.5 1887.5 -9092.5 1892.5 -9097.5 1900 -9090 {fill=1}
P 10 7 890 -5580 882.5 -5587.5 887.5 -5592.5 872.5 -5597.5 877.5 -5582.5 882.5 -5587.5 890 -5580 {fill=1}
P 10 7 1730 -5630 1722.5 -5637.5 1727.5 -5642.5 1712.5 -5647.5 1717.5 -5632.5 1722.5 -5637.5 1730 -5630 {fill=1}
P 10 7 2490 -5630 2482.5 -5637.5 2487.5 -5642.5 2472.5 -5647.5 2477.5 -5632.5 2482.5 -5637.5 2490 -5630 {fill=1}
P 10 7 875 -9900 867.5 -9907.5 872.5 -9912.5 857.5 -9917.5 862.5 -9902.5 867.5 -9907.5 875 -9900 {fill=1}
P 10 7 1400 -9790 1392.5 -9797.5 1397.5 -9802.5 1382.5 -9807.5 1387.5 -9792.5 1392.5 -9797.5 1400 -9790 {fill=1}
P 10 7 1850 -9790 1842.5 -9797.5 1847.5 -9802.5 1832.5 -9807.5 1837.5 -9792.5 1842.5 -9797.5 1850 -9790 {fill=1}
P 10 7 2280 -9790 2272.5 -9797.5 2277.5 -9802.5 2262.5 -9807.5 2267.5 -9792.5 2272.5 -9797.5 2280 -9790 {fill=1}
P 10 7 2200 -8920 2192.5 -8927.5 2197.5 -8932.5 2182.5 -8937.5 2187.5 -8922.5 2192.5 -8927.5 2200 -8920 {fill=1}
P 10 7 1025 -8350 1017.5 -8357.5 1022.5 -8362.5 1007.5 -8367.5 1012.5 -8352.5 1017.5 -8357.5 1025 -8350 {fill=1}
P 10 7 1870 -8350 1862.5 -8357.5 1867.5 -8362.5 1852.5 -8367.5 1857.5 -8352.5 1862.5 -8357.5 1870 -8350 {fill=1}
P 10 7 1000 -7920 992.5 -7927.5 997.5 -7932.5 982.5 -7937.5 987.5 -7922.5 992.5 -7927.5 1000 -7920 {fill=1}
P 10 7 1860 -7920 1852.5 -7927.5 1857.5 -7932.5 1842.5 -7937.5 1847.5 -7922.5 1852.5 -7927.5 1860 -7920 {fill=1}
P 10 7 2440 -8980 2432.5 -8987.5 2437.5 -8992.5 2422.5 -8997.5 2427.5 -8982.5 2432.5 -8987.5 2440 -8980 {fill=1}
P 10 7 580 -9090 572.5 -9097.5 577.5 -9102.5 562.5 -9107.5 567.5 -9092.5 572.5 -9097.5 580 -9090 {fill=1}
P 10 7 740 -1280 732.5 -1287.5 737.5 -1292.5 722.5 -1297.5 727.5 -1282.5 732.5 -1287.5 740 -1280 {fill=1}
P 10 7 2320 -1280 2312.5 -1287.5 2317.5 -1292.5 2302.5 -1297.5 2307.5 -1282.5 2312.5 -1287.5 2320 -1280 {fill=1}
P 10 7 1430 -945 1422.5 -952.5 1427.5 -957.5 1412.5 -962.5 1417.5 -947.5 1422.5 -952.5 1430 -945 {fill=1}
P 10 7 2360 -1005 2352.5 -1012.5 2357.5 -1017.5 2342.5 -1022.5 2347.5 -1007.5 2352.5 -1012.5 2360 -1005 {fill=1}
P 10 7 640 -945 632.5 -952.5 637.5 -957.5 622.5 -962.5 627.5 -947.5 632.5 -952.5 640 -945 {fill=1}
P 10 7 2210 -11730 2202.5 -11737.5 2207.5 -11742.5 2192.5 -11747.5 2197.5 -11732.5 2202.5 -11737.5 2210 -11730 {fill=1}
P 10 7 952.5 -630 945 -637.5 950 -642.5 935 -647.5 940 -632.5 945 -637.5 952.5 -630 {fill=1}
P 10 7 1297.5 -642.5 1290 -650 1295 -655 1280 -660 1285 -645 1290 -650 1297.5 -642.5 {fill=1}
P 10 7 1627.5 -642.5 1620 -650 1625 -655 1610 -660 1615 -645 1620 -650 1627.5 -642.5 {fill=1}
P 10 7 1947.5 -642.5 1940 -650 1945 -655 1930 -660 1935 -645 1940 -650 1947.5 -642.5 {fill=1}
P 10 7 1092.5 -330 1085 -337.5 1090 -342.5 1075 -347.5 1080 -332.5 1085 -337.5 1092.5 -330 {fill=1}
T {INTUITIVE_INTERFACE CHEAT SHEET} 1110 -12080 0 0 2 2 {hcenter=1}
T {D} 1275 -11057.5 0 0 0.15 0.15 { layer=2}
T {D} 2055 -11067.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -11057.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -10597.5 0 0 0.15 0.15 {}
T {D} 1285 -10597.5 0 0 0.15 0.15 {}
T {D} 745 -7007.5 0 0 0.15 0.15 {}
T {D} 1285 -7007.5 0 0 0.15 0.15 {}
T {D} 745 -6607.5 0 0 0.15 0.15 {}
T {D} 1285 -6607.5 0 0 0.15 0.15 {}
T {D} 745 -6167.5 0 0 0.15 0.15 { layer=2}
T {D} 2125 -6167.5 0 0 0.15 0.15 { layer=2}
T {D} 1305 -6167.5 0 0 0.15 0.15 { layer=2}
T {(Enable Options → Intuitive Click & Drag interface
or add: `set intuitive_interface 1` in xschemrc file).} 1090 -11940 0 0 1 1 {hcenter=1 layer=1}
T {Move objects} 0 -11130 0 0 1 1 {}
T {Move objects} 0 -10720 0 0 1 1 {}
T {Move objects,
create wires} 0 -7130 0 0 1 1 {}
T {Move objects,
keep attached
wires
} 0 -6730 0 0 1 1 {}
T {Move objects,
keep attached
wires / stretch
circuit
} 0 -6330 0 0 1 1 {}
T {Shift} 1520 -7065 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1520 -7135 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1540 -6025 0 0 0.5 0.5 {hcenter=1}
T {Duplicate objects} 0 -10280 0 0 1 1 {}
T {D} 1275 -10227.5 0 0 0.15 0.15 { layer=2}
T {D} 2055 -10237.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -10227.5 0 0 0.15 0.15 { layer=2}
T {D} 1775 -10227.5 0 0 0.15 0.15 {}
T {Shift} 1270 -10045 0 0 0.5 0.5 {hcenter=1}
T {D} 1815 -11527.5 0 0 0.15 0.15 { layer=2}
T {D} 690 -11527.5 0 0 0.15 0.15 { layer=2}
T {Select
and unselect
objects} 0 -11580 0 0 1 1 {}
T {Shift} 1710 -11325 0 0 0.5 0.5 {hcenter=1}
T {D} 2275 -11527.5 0 0 0.15 0.15 { layer=2}
T {Alt} 2490 -11315 0 0 0.5 0.5 {hcenter=1}
T {Select} 695 -11330 0 0 0.5 0.5 {}
T {Add
Selection} 1770 -11340 0 0 0.5 0.5 {}
T {Remove
Selection} 2220 -11340 0 0 0.5 0.5 {}
T {D} 765 -9387.5 0 0 0.15 0.15 {}
T {D} 1305 -9387.5 0 0 0.15 0.15 {}
T {D} 2435 -9387.5 0 0 0.15 0.15 {}
T {Resize wires} 0 -9510 0 0 1 1 {}
T {Constrained move
horizontal / 
vertical} 0 -5860 0 0 1 1 {}
T {Move components, 
create wires,
resize wires} 0 -5400 0 0 1 1 {}
T {Cut wires} 0 -5050 0 0 1 1 {}
T {Stretch multiple
shapes} 0 -4630 0 0 1 1 {}
T {Ctrl} 1430 -5405 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1430 -5325 0 0 0.5 0.5 {hcenter=1}
T {Accurately position closer
to the wire end to be moved
so it will not be unselected} 1610 -9600 0 0 0.5 0.5 {}
T {Move multiple
objects keeping
connections} 0 -2610 0 0 1 1 {}
T {Ctrl} 2080 -2585 0 0 0.5 0.5 {hcenter=1}
T {Alt} 1430 -4955 0 0 0.5 0.5 {hcenter=1}
T {Click to select wire, release button
click wire endpoint and drag it away} 660 -9600 0 0 0.5 0.5 {}
T {Ctrl} 1580 -4545 0 0 0.5 0.5 {hcenter=1}
T {D} 655 -4207.5 0 0 0.15 0.15 { layer=2}
T {D} 1235 -4207.5 0 0 0.15 0.15 { layer=2}
T {D} 1885 -4207.5 0 0 0.15 0.15 {}
T {Ctrl} 1960 -4245 0 0 0.5 0.5 {hcenter=1}
T {!} 1960 -4165 0 0 0.5 0.5 {hcenter=1}
T {Remove wires
under component
} 0 -4280 0 0 1 1 {}
T {If Shift key is needed for ! 
use also Shift} 2020 -4220 0 0 0.5 0.5 {}
T {D} 1275 -11527.5 0 0 0.15 0.15 { layer=2}
T {Add
Selection} 1090 -11350 0 0 0.5 0.5 {}
T {Shift} 1080 -11605 0 0 0.5 0.5 {hcenter=1}
T {Move multiple
objects keeping
connections,
adding wires} 0 -2230 0 0 1 1 {}
T {Ctrl} 2080 -2205 0 0 0.5 0.5 {hcenter=1}
T {Shift} 2080 -2135 0 0 0.5 0.5 {hcenter=1}
T {Join / Trim wires} 0 -3940 0 0 1 1 {}
T {&} 1920 -3945 0 0 0.5 0.5 {hcenter=1}
T {This wire will not be broken} 1120 -3530 0 0 0.5 0.5 {}
T {&} 1830 -3515 0 0 0.5 0.5 {hcenter=1}
T {This wire is now 
broken} 1890 -3530 0 0 0.5 0.5 {}
T {break wires
at instance
pins} 0 -3010 0 0 1 1 {}
T {!} 1290 -2865 0 0 0.5 0.5 {hcenter=1}
T {Shift} 790 -2795 0 0 0.5 0.5 {hcenter=1}
T {+} 720 -2870 0 0 0.5 0.5 {}
T {The single wire line will be
broken at selected instance pins} 1640 -3040 0 0 0.5 0.5 {}
T {Single wire line} 640 -3030 0 0 0.5 0.5 {}
T {D} 825 -1697.5 0 0 0.15 0.15 {}
T {D} 1425 -1697.5 0 0 0.15 0.15 {}
T {Shift} 1600 -1635 0 0 0.5 0.5 {hcenter=1}
T {Select instance
and all connected
wires} 0 -1830 0 0 1 1 {}
T {Join / Trim wires} 0 -3660 0 0 1 1 {}
T {Options->Auto join / trim wires to perform this function automatically} 840 -3760 0 0 0.5 0.5 {}
T {Join / Trim wires} 0 -3270 0 0 1 1 {}
T {This wire is broken} 630 -3130 0 0 0.5 0.5 {}
T {This wire is still broken} 1170 -3130 0 0 0.5 0.5 {}
T {This wire is now joined} 1800 -3130 0 0 0.5 0.5 {}
T {&} 1920 -3375 0 0 0.5 0.5 {hcenter=1}
T {Options->Auto join / trim wires to perform this function automatically} 840 -3390 0 0 0.5 0.5 {}
T {Options->Auto join / trim wires to perform this function automatically} 840 -4000 0 0 0.5 0.5 {}
T {multiple overlayed wires create
unneeded connecting dots} 1110 -3920 0 0 0.5 0.5 {}
T {overlayed wires are removed} 2270 -3900 0 0 0.5 0.5 {}
T {Ctrl} 2370 -6025 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1980 -5405 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1980 -5325 0 0 0.5 0.5 {hcenter=1}
T {you can now 
select one of
the cut segments...} 1930 -4920 0 0 0.4 0.4 {}
T {... and move it.} 2420 -4840 0 0 0.4 0.4 {}
T {D} 2035 -1697.5 0 0 0.15 0.15 {}
T {Component
wiring} 0 -9030 0 0 1 1 {}
T {Click to
unselect} 850 -9150 0 0 0.5 0.5 {}
T {Click to select} 1810 -9150 0 0 0.5 0.5 {}
T {Click one of the
selected objects
and drag it away.} 2330 -1730 0 0 0.4 0.4 {}
T {This command will work also on multiple selected objects.} 1710 -4070 0 0 0.5 0.5 {}
T {D} 765 -5757.5 0 0 0.15 0.15 {}
T {D} 1325 -5757.5 0 0 0.15 0.15 {}
T {Press and release 'h'
while keeping left mouse
button pressed.
move will be horizontal only} 1550 -5910 0 0 0.5 0.5 {}
T {Press and release 'v'
while keeping left mouse
button pressed.
move will be vertical only} 2050 -5780 0 0 0.5 0.5 {}
T {D} 710 -9807.5 0 0 0.15 0.15 {}
T {Move and
extend
wires} 0 -9900 0 0 1 1 {}
T {D} 1275 -9807.5 0 0 0.15 0.15 {}
T {D} 1775 -9807.5 0 0 0.15 0.15 {}
T {D} 2265 -9807.5 0 0 0.15 0.15 {}
T {Shift} 1980 -9065 0 0 0.5 0.5 {hcenter=1}
T {Rotate / Flip} 0 -8690 0 0 1 1 {}
T {Shift} 510 -8575 0 0 0.5 0.5 {hcenter=1}
T {R} 510 -8505 0 0 0.5 0.5 {hcenter=1}
T {Shift} 820 -8575 0 0 0.5 0.5 {hcenter=1}
T {R} 820 -8505 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1120 -8575 0 0 0.5 0.5 {hcenter=1}
T {R} 1120 -8505 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1430 -8575 0 0 0.5 0.5 {hcenter=1}
T {R} 1430 -8505 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1750 -8575 0 0 0.5 0.5 {hcenter=1}
T {F} 1750 -8505 0 0 0.5 0.5 {hcenter=1}
T {Shift} 2080 -8575 0 0 0.5 0.5 {hcenter=1}
T {V} 2080 -8505 0 0 0.5 0.5 {hcenter=1}
T {D} 775 -8247.5 0 0 0.15 0.15 { layer=2}
T {D} 1727.5 -8125 1 0 0.15 0.15 { layer=2}
T {D} 1250 -8247.5 0 0 0.15 0.15 { layer=2}
T {Shift} 1940 -8385 0 0 0.5 0.5 {hcenter=1}
T {R} 1940 -8315 0 0 0.5 0.5 {hcenter=1}
T {Selected shapes rotate around mouse pointer} 1920 -8240 0 0 0.5 0.5 {}
T {Rotate} 0 -8270 0 0 1 1 {}
T {D} 775 -7817.5 0 0 0.15 0.15 { layer=2}
T {D} 1225 -7817.5 0 0 0.15 0.15 { layer=2}
T {Shift} 1940 -7955 0 0 0.5 0.5 {hcenter=1}
T {F} 1940 -7885 0 0 0.5 0.5 {hcenter=1}
T {Selected shapes flip around mouse pointer} 1920 -7810 0 0 0.5 0.5 {}
T {Flip} 0 -7840 0 0 1 1 {}
T {D} 1595 -7817.5 0 1 0.15 0.15 { layer=2}
T {Rotate around
center point} 0 -7440 0 0 1 1 {}
T {Alt} 1050 -7475 0 0 0.5 0.5 {hcenter=1}
T {R} 1050 -7405 0 0 0.5 0.5 {hcenter=1}
T {Same commands are available for
vertical flip (Alt-v) and
horizontal flip (Alt-f)} 1350 -7450 0 0 0.5 0.5 {}
T {get existing wire} 750 -9965 0 0 0.5 0.5 {}
T {move} 1335 -9855 0 0 0.5 0.5 {}
T {extend} 2310 -9860 0 0 0.5 0.5 {}
T {duplicated} 2070 -8870 0 0 0.5 0.5 {}
T {Ctrl} 1520 -6705 0 0 0.5 0.5 {hcenter=1}
T {Toggle mouse vs 
crosshair display} 0 -1370 0 0 1 1 {}
T {Alt} 1430 -1225 0 0 0.5 0.5 {hcenter=1}
T {x} 1430 -1155 0 0 0.5 0.5 {hcenter=1}
T {Alt} 2310 -1225 0 0 0.5 0.5 {hcenter=1}
T {x} 2310 -1155 0 0 0.5 0.5 {hcenter=1}
T {X1} 1085 -1052 0 0 0.2 0.2 { layer=2}
T {CODE[5:0]} 1075 -1034 0 1 0.2 0.2 { layer=2}
T {SIG_IN} 965 -1034 0 0 0.2 0.2 { layer=2}
T {VREF} 965 -1014 0 0 0.2 0.2 { layer=2}
T {CK} 965 -994 0 0 0.2 0.2 { layer=2}
T {RST} 965 -974 0 0 0.2 0.2 { layer=2}
T {adc} 1009.75 -998.5 0 0 0.2 0.2 { layer=2}
T {Auto-wiring
of components} 0 -970 0 0 1 1 {}
T {X1} 1655 -1052 0 0 0.2 0.2 {}
T {CODE[5:0]} 1645 -1034 0 1 0.2 0.2 {}
T {SIG_IN} 1535 -1034 0 0 0.2 0.2 {}
T {VREF} 1535 -1014 0 0 0.2 0.2 {}
T {CK} 1535 -994 0 0 0.2 0.2 {}
T {RST} 1535 -974 0 0 0.2 0.2 {}
T {adc} 1579.75 -998.5 0 0 0.2 0.2 {}
T {SIG_IN} 932.5 -1038.125 0 1 0.33 0.33 { layer=1}
T {VREF} 932.5 -1018.125 0 1 0.33 0.33 { layer=1}
T {CK} 932.5 -998.125 0 1 0.33 0.33 { layer=1}
T {RST} 932.5 -978.125 0 1 0.33 0.33 { layer=1}
T {CODE[5:0]} 1107.5 -1038.125 0 0 0.33 0.33 { layer=1}
T {Shift} 1010 -915 0 0 0.5 0.5 {hcenter=1}
T {H} 1010 -845 0 0 0.5 0.5 {hcenter=1}
T {SIG_IN} 1432.5 -1038.125 0 1 0.33 0.33 { layer=2}
T {VREF} 1432.5 -1018.125 0 1 0.33 0.33 { layer=2}
T {CK} 1432.5 -998.125 0 1 0.33 0.33 { layer=2}
T {RST} 1432.5 -978.125 0 1 0.33 0.33 { layer=2}
T {Ctrl} 1440 -915 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1440 -845 0 0 0.5 0.5 {hcenter=1}
T {CODE[5:0]} 1677.5 -1038.125 0 0 0.33 0.33 { layer=1}
T {X1} 2185 -1052 0 0 0.2 0.2 {}
T {CODE[5:0]} 2175 -1034 0 1 0.2 0.2 {}
T {SIG_IN} 2065 -1034 0 0 0.2 0.2 {}
T {VREF} 2065 -1014 0 0 0.2 0.2 {}
T {CK} 2065 -994 0 0 0.2 0.2 {}
T {RST} 2065 -974 0 0 0.2 0.2 {}
T {adc} 2109.75 -998.5 0 0 0.2 0.2 {}
T {SIG_IN} 1962.5 -1038.125 0 1 0.33 0.33 { layer=1}
T {VREF} 1962.5 -1018.125 0 1 0.33 0.33 { layer=1}
T {CK} 1962.5 -998.125 0 1 0.33 0.33 { layer=1}
T {RST} 1962.5 -978.125 0 1 0.33 0.33 { layer=1}
T {CODE[5:0]} 2297.5 -1038.125 0 0 0.33 0.33 { layer=2}
T {Ctrl} 2370 -975 0 0 0.5 0.5 {hcenter=1}
T {Shift} 2370 -905 0 0 0.5 0.5 {hcenter=1}
T {X1} 665 -1052 0 0 0.2 0.2 { layer=2}
T {CODE[5:0]} 655 -1034 0 1 0.2 0.2 { layer=2}
T {SIG_IN} 545 -1034 0 0 0.2 0.2 { layer=2}
T {VREF} 545 -1014 0 0 0.2 0.2 { layer=2}
T {CK} 545 -994 0 0 0.2 0.2 { layer=2}
T {RST} 545 -974 0 0 0.2 0.2 { layer=2}
T {adc} 589.75 -998.5 0 0 0.2 0.2 { layer=2}
T {This represents the mouse
device. Red rectangle
indicates a pressed button} 2265 -12030 0 0 0.5 0.5 {}
T {Alt} 2210 -11905 0 0 0.5 0.5 {hcenter=1}
T {This represents 
a pressed modifier key} 2265 -11920 0 0 0.5 0.5 {}
T {R} 2210 -11825 0 0 0.5 0.5 {hcenter=1}
T {This represents 
a pressed key} 2265 -11840 0 0 0.5 0.5 {}
T {This represents the
mouse pointer} 2265 -11770 0 0 0.5 0.5 {}
T {Rotate / Flip
wire labels} 0 -700 0 0 1 1 {}
T {SIG_IN} 572.5 -668.125 0 1 0.33 0.33 { layer=1}
T {SIG_IN} 962.5 -668.125 0 1 0.33 0.33 { layer=2}
T {Shift} 1300 -585 0 0 0.5 0.5 {hcenter=1}
T {R} 1300 -515 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1630 -585 0 0 0.5 0.5 {hcenter=1}
T {R} 1630 -515 0 0 0.5 0.5 {hcenter=1}
T {SIG_IN} 1288.125 -667.5 1 1 0.33 0.33 { layer=2}
T {SIG_IN} 1617.5 -651.875 2 1 0.33 0.33 { layer=2}
T {Shift} 1950 -585 0 0 0.5 0.5 {hcenter=1}
T {F} 1950 -515 0 0 0.5 0.5 {hcenter=1}
T {SIG_IN} 1922.5 -651.875 2 0 0.33 0.33 { layer=2}
T {7/0.15/1} 567.5 -377.5 0 0 0.2 0.2 {}
T {M1} 567.5 -352.5 0 0 0.2 0.2 {}
T {10/0.15/1} 697.5 -377.5 0 0 0.2 0.2 {}
T {M1} 697.5 -352.5 0 0 0.2 0.2 {}
T {4/0.15/1} 567.5 -178.75 0 0 0.2 0.2 {}
T {M1} 567.5 -152.5 0 0 0.2 0.2 {}
T {D} 585 -187.5 0 0 0.15 0.15 {}
T {D} 585 -340 0 0 0.15 0.15 {}
T {D} 715 -340 0 0 0.15 0.15 {}
T {4/0.15/1} 567.5 -98.75 0 0 0.2 0.2 {}
T {M1} 567.5 -72.5 0 0 0.2 0.2 {}
T {D} 585 -107.5 0 0 0.15 0.15 {}
T {7/0.15/1} 937.5 -377.5 0 0 0.2 0.2 { layer=2}
T {M1} 937.5 -352.5 0 0 0.2 0.2 { layer=2}
T {10/0.15/1} 1067.5 -377.5 0 0 0.2 0.2 { layer=2}
T {M1} 1067.5 -352.5 0 0 0.2 0.2 { layer=2}
T {4/0.15/1} 937.5 -178.75 0 0 0.2 0.2 { layer=2}
T {M1} 937.5 -152.5 0 0 0.2 0.2 { layer=2}
T {D} 955 -187.5 0 0 0.15 0.15 { layer=2}
T {D} 955 -340 0 0 0.15 0.15 { layer=2}
T {D} 1085 -340 0 0 0.15 0.15 { layer=2}
T {4/0.15/1} 937.5 -98.75 0 0 0.2 0.2 {}
T {M1} 937.5 -72.5 0 0 0.2 0.2 { layer=2}
T {D} 955 -107.5 0 0 0.15 0.15 { layer=2}
T {Shift} 1220 -305 0 0 0.5 0.5 {hcenter=1}
T {q} 1600 -305 0 0 0.5 0.5 {hcenter=1}
T {or double click
last element} 1680 -310 0 0 0.4 0.4 {}
T {7/0.3/1} 2227.5 -377.5 0 0 0.2 0.2 {}
T {M1} 2227.5 -352.5 0 0 0.2 0.2 {}
T {7/0.3/1} 2357.5 -377.5 0 0 0.2 0.2 {}
T {M1} 2357.5 -352.5 0 0 0.2 0.2 {}
T {4/0.3/1} 2227.5 -178.75 0 0 0.2 0.2 {}
T {M1} 2227.5 -152.5 0 0 0.2 0.2 {}
T {D} 2245 -187.5 0 0 0.15 0.15 {}
T {D} 2245 -340 0 0 0.15 0.15 {}
T {D} 2375 -340 0 0 0.15 0.15 {}
T {4/0.3/1} 2227.5 -98.75 0 0 0.2 0.2 {}
T {M1} 2227.5 -72.5 0 0 0.2 0.2 {}
T {D} 2245 -107.5 0 0 0.15 0.15 {}
T {Select one or multiple
objects using the Shift
key} 1040 -230 0 0 0.4 0.4 {}
T {Only the l=... attribute
is changed. Elements retain
their other attributes.} 2310 -260 0 0 0.4 0.4 {}
T {Edit attributes} 0 -290 0 0 1 1 {}
