v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 1 917.5 -10112.5 922.5 -10112.5 {}
L 1 917.5 -10110 922.5 -10110 {}
L 1 917.5 -10107.5 922.5 -10107.5 {}
L 1 917.5 -10105 922.5 -10105 {}
L 1 917.5 -10102.5 922.5 -10102.5 {}
L 1 917.5 -10100 922.5 -10100 {}
L 1 917.5 -10097.5 922.5 -10097.5 {}
L 1 917.5 -10095 922.5 -10095 {}
L 1 917.5 -10092.5 922.5 -10092.5 {}
L 1 1347.5 -10112.5 1352.5 -10112.5 {}
L 1 1347.5 -10110 1352.5 -10110 {}
L 1 1347.5 -10107.5 1352.5 -10107.5 {}
L 1 1347.5 -10105 1352.5 -10105 {}
L 1 1347.5 -10102.5 1352.5 -10102.5 {}
L 1 1347.5 -10100 1352.5 -10100 {}
L 1 1347.5 -10097.5 1352.5 -10097.5 {}
L 1 1347.5 -10095 1352.5 -10095 {}
L 1 1347.5 -10092.5 1352.5 -10092.5 {}
L 1 2117.5 -10112.5 2122.5 -10112.5 {}
L 1 2117.5 -10110 2122.5 -10110 {}
L 1 2117.5 -10107.5 2122.5 -10107.5 {}
L 1 2117.5 -10105 2122.5 -10105 {}
L 1 2117.5 -10102.5 2122.5 -10102.5 {}
L 1 2117.5 -10100 2122.5 -10100 {}
L 1 2117.5 -10097.5 2122.5 -10097.5 {}
L 1 2117.5 -10095 2122.5 -10095 {}
L 1 2117.5 -10092.5 2122.5 -10092.5 {}
L 1 1417.5 -9922.5 1422.5 -9922.5 {}
L 1 1417.5 -9920 1422.5 -9920 {}
L 1 1417.5 -9917.5 1422.5 -9917.5 {}
L 1 1417.5 -9915 1422.5 -9915 {}
L 1 1417.5 -9912.5 1422.5 -9912.5 {}
L 1 1417.5 -9910 1422.5 -9910 {}
L 1 1417.5 -9907.5 1422.5 -9907.5 {}
L 1 1417.5 -9905 1422.5 -9905 {}
L 1 1417.5 -9902.5 1422.5 -9902.5 {}
L 1 1437.5 -6342.5 1442.5 -6342.5 {}
L 1 1437.5 -6340 1442.5 -6340 {}
L 1 1437.5 -6337.5 1442.5 -6337.5 {}
L 1 1437.5 -6335 1442.5 -6335 {}
L 1 1437.5 -6332.5 1442.5 -6332.5 {}
L 1 1437.5 -6330 1442.5 -6330 {}
L 1 1437.5 -6327.5 1442.5 -6327.5 {}
L 1 1437.5 -6325 1442.5 -6325 {}
L 1 1437.5 -6322.5 1442.5 -6322.5 {}
L 1 1437.5 -5942.5 1442.5 -5942.5 {}
L 1 1437.5 -5940 1442.5 -5940 {}
L 1 1437.5 -5937.5 1442.5 -5937.5 {}
L 1 1437.5 -5935 1442.5 -5935 {}
L 1 1437.5 -5932.5 1442.5 -5932.5 {}
L 1 1437.5 -5930 1442.5 -5930 {}
L 1 1437.5 -5927.5 1442.5 -5927.5 {}
L 1 1437.5 -5925 1442.5 -5925 {}
L 1 1437.5 -5922.5 1442.5 -5922.5 {}
L 1 947.5 -5262.5 952.5 -5262.5 {}
L 1 947.5 -5260 952.5 -5260 {}
L 1 947.5 -5257.5 952.5 -5257.5 {}
L 1 947.5 -5255 952.5 -5255 {}
L 1 947.5 -5252.5 952.5 -5252.5 {}
L 1 947.5 -5250 952.5 -5250 {}
L 1 947.5 -5247.5 952.5 -5247.5 {}
L 1 947.5 -5245 952.5 -5245 {}
L 1 947.5 -5242.5 952.5 -5242.5 {}
L 1 1060 -5520 1300 -5520 {}
L 1 1060 -5260 1300 -5260 {}
L 1 1447.5 -5272.5 1452.5 -5272.5 {}
L 1 1447.5 -5270 1452.5 -5270 {}
L 1 1447.5 -5267.5 1452.5 -5267.5 {}
L 1 1447.5 -5265 1452.5 -5265 {}
L 1 1447.5 -5262.5 1452.5 -5262.5 {}
L 1 1447.5 -5260 1452.5 -5260 {}
L 1 1447.5 -5257.5 1452.5 -5257.5 {}
L 1 1447.5 -5255 1452.5 -5255 {}
L 1 1447.5 -5252.5 1452.5 -5252.5 {}
L 1 917.5 -9282.5 922.5 -9282.5 {}
L 1 917.5 -9280 922.5 -9280 {}
L 1 917.5 -9277.5 922.5 -9277.5 {}
L 1 917.5 -9275 922.5 -9275 {}
L 1 917.5 -9272.5 922.5 -9272.5 {}
L 1 917.5 -9270 922.5 -9270 {}
L 1 917.5 -9267.5 922.5 -9267.5 {}
L 1 917.5 -9265 922.5 -9265 {}
L 1 917.5 -9262.5 922.5 -9262.5 {}
L 1 1347.5 -9282.5 1352.5 -9282.5 {}
L 1 1347.5 -9280 1352.5 -9280 {}
L 1 1347.5 -9277.5 1352.5 -9277.5 {}
L 1 1347.5 -9275 1352.5 -9275 {}
L 1 1347.5 -9272.5 1352.5 -9272.5 {}
L 1 1347.5 -9270 1352.5 -9270 {}
L 1 1347.5 -9267.5 1352.5 -9267.5 {}
L 1 1347.5 -9265 1352.5 -9265 {}
L 1 1347.5 -9262.5 1352.5 -9262.5 {}
L 1 2117.5 -9282.5 2122.5 -9282.5 {}
L 1 2117.5 -9280 2122.5 -9280 {}
L 1 2117.5 -9277.5 2122.5 -9277.5 {}
L 1 2117.5 -9275 2122.5 -9275 {}
L 1 2117.5 -9272.5 2122.5 -9272.5 {}
L 1 2117.5 -9270 2122.5 -9270 {}
L 1 2117.5 -9267.5 2122.5 -9267.5 {}
L 1 2117.5 -9265 2122.5 -9265 {}
L 1 2117.5 -9262.5 2122.5 -9262.5 {}
L 1 862.5 -10582.5 867.5 -10582.5 {}
L 1 862.5 -10580 867.5 -10580 {}
L 1 862.5 -10577.5 867.5 -10577.5 {}
L 1 862.5 -10575 867.5 -10575 {}
L 1 862.5 -10572.5 867.5 -10572.5 {}
L 1 862.5 -10570 867.5 -10570 {}
L 1 862.5 -10567.5 867.5 -10567.5 {}
L 1 862.5 -10565 867.5 -10565 {}
L 1 862.5 -10562.5 867.5 -10562.5 {}
L 1 1627.5 -10572.5 1632.5 -10572.5 {}
L 1 1627.5 -10570 1632.5 -10570 {}
L 1 1627.5 -10567.5 1632.5 -10567.5 {}
L 1 1627.5 -10565 1632.5 -10565 {}
L 1 1627.5 -10562.5 1632.5 -10562.5 {}
L 1 1627.5 -10560 1632.5 -10560 {}
L 1 1627.5 -10557.5 1632.5 -10557.5 {}
L 1 1627.5 -10555 1632.5 -10555 {}
L 1 1627.5 -10552.5 1632.5 -10552.5 {}
L 1 2407.5 -10562.5 2412.5 -10562.5 {}
L 1 2407.5 -10560 2412.5 -10560 {}
L 1 2407.5 -10557.5 2412.5 -10557.5 {}
L 1 2407.5 -10555 2412.5 -10555 {}
L 1 2407.5 -10552.5 2412.5 -10552.5 {}
L 1 2407.5 -10550 2412.5 -10550 {}
L 1 2407.5 -10547.5 2412.5 -10547.5 {}
L 1 2407.5 -10545 2412.5 -10545 {}
L 1 2407.5 -10542.5 2412.5 -10542.5 {}
L 1 820 -4320 820 -3990 {}
L 1 1360 -4320 1360 -3990 {}
L 1 1900 -4150 1900 -3990 {}
L 1 820 -3800 820 -3700 {}
L 1 710 -3800 710 -3700 {}
L 1 930 -3800 930 -3700 {}
L 1 820 -4680 820 -4530 {}
L 1 1360 -4680 1360 -4530 {}
L 1 1900 -4680 1900 -4570 {}
L 1 687.5 -8702.5 692.5 -8702.5 {}
L 1 687.5 -8700 692.5 -8700 {}
L 1 687.5 -8697.5 692.5 -8697.5 {}
L 1 687.5 -8695 692.5 -8695 {}
L 1 687.5 -8692.5 692.5 -8692.5 {}
L 1 687.5 -8690 692.5 -8690 {}
L 1 687.5 -8687.5 692.5 -8687.5 {}
L 1 687.5 -8685 692.5 -8685 {}
L 1 687.5 -8682.5 692.5 -8682.5 {}
L 1 1347.5 -8722.5 1352.5 -8722.5 {}
L 1 1347.5 -8720 1352.5 -8720 {}
L 1 1347.5 -8717.5 1352.5 -8717.5 {}
L 1 1347.5 -8715 1352.5 -8715 {}
L 1 1347.5 -8712.5 1352.5 -8712.5 {}
L 1 1347.5 -8710 1352.5 -8710 {}
L 1 1347.5 -8707.5 1352.5 -8707.5 {}
L 1 1347.5 -8705 1352.5 -8705 {}
L 1 1347.5 -8702.5 1352.5 -8702.5 {}
L 1 2537.5 -8772.5 2542.5 -8772.5 {}
L 1 2537.5 -8770 2542.5 -8770 {}
L 1 2537.5 -8767.5 2542.5 -8767.5 {}
L 1 2537.5 -8765 2542.5 -8765 {}
L 1 2537.5 -8762.5 2542.5 -8762.5 {}
L 1 2537.5 -8760 2542.5 -8760 {}
L 1 2537.5 -8757.5 2542.5 -8757.5 {}
L 1 2537.5 -8755 2542.5 -8755 {}
L 1 2537.5 -8752.5 2542.5 -8752.5 {}
L 1 1427.5 -4482.5 1432.5 -4482.5 {}
L 1 1427.5 -4480 1432.5 -4480 {}
L 1 1427.5 -4477.5 1432.5 -4477.5 {}
L 1 1427.5 -4475 1432.5 -4475 {}
L 1 1427.5 -4472.5 1432.5 -4472.5 {}
L 1 1427.5 -4470 1432.5 -4470 {}
L 1 1427.5 -4467.5 1432.5 -4467.5 {}
L 1 1427.5 -4465 1432.5 -4465 {}
L 1 1427.5 -4462.5 1432.5 -4462.5 {}
L 1 820 -1870 820 -1770 {}
L 1 710 -1870 710 -1770 {}
L 1 930 -1870 930 -1770 {}
L 1 820 -1710 820 -1680 {}
L 1 710 -1710 710 -1680 {}
L 1 930 -1710 930 -1680 {}
L 1 2077.5 -1752.5 2082.5 -1752.5 {}
L 1 2077.5 -1750 2082.5 -1750 {}
L 1 2077.5 -1747.5 2082.5 -1747.5 {}
L 1 2077.5 -1745 2082.5 -1745 {}
L 1 2077.5 -1742.5 2082.5 -1742.5 {}
L 1 2077.5 -1740 2082.5 -1740 {}
L 1 2077.5 -1737.5 2082.5 -1737.5 {}
L 1 2077.5 -1735 2082.5 -1735 {}
L 1 2077.5 -1732.5 2082.5 -1732.5 {}
L 1 1567.5 -1722.5 1572.5 -1722.5 {}
L 1 1567.5 -1720 1572.5 -1720 {}
L 1 1567.5 -1717.5 1572.5 -1717.5 {}
L 1 1567.5 -1715 1572.5 -1715 {}
L 1 1567.5 -1712.5 1572.5 -1712.5 {}
L 1 1567.5 -1710 1572.5 -1710 {}
L 1 1567.5 -1707.5 1572.5 -1707.5 {}
L 1 1567.5 -1705 1572.5 -1705 {}
L 1 1567.5 -1702.5 1572.5 -1702.5 {}
L 1 1427.5 -4122.5 1432.5 -4122.5 {}
L 1 1427.5 -4120 1432.5 -4120 {}
L 1 1427.5 -4117.5 1432.5 -4117.5 {}
L 1 1427.5 -4115 1432.5 -4115 {}
L 1 1427.5 -4112.5 1432.5 -4112.5 {}
L 1 1427.5 -4110 1432.5 -4110 {}
L 1 1427.5 -4107.5 1432.5 -4107.5 {}
L 1 1427.5 -4105 1432.5 -4105 {}
L 1 1427.5 -4102.5 1432.5 -4102.5 {}
L 1 1957.5 -4232.5 1962.5 -4232.5 {}
L 1 1957.5 -4230 1962.5 -4230 {}
L 1 1957.5 -4227.5 1962.5 -4227.5 {}
L 1 1957.5 -4225 1962.5 -4225 {}
L 1 1957.5 -4222.5 1962.5 -4222.5 {}
L 1 1957.5 -4220 1962.5 -4220 {}
L 1 1957.5 -4217.5 1962.5 -4217.5 {}
L 1 1957.5 -4215 1962.5 -4215 {}
L 1 1957.5 -4212.5 1962.5 -4212.5 {}
L 1 1577.5 -3712.5 1582.5 -3712.5 {}
L 1 1577.5 -3710 1582.5 -3710 {}
L 1 1577.5 -3707.5 1582.5 -3707.5 {}
L 1 1577.5 -3705 1582.5 -3705 {}
L 1 1577.5 -3702.5 1582.5 -3702.5 {}
L 1 1577.5 -3700 1582.5 -3700 {}
L 1 1577.5 -3697.5 1582.5 -3697.5 {}
L 1 1577.5 -3695 1582.5 -3695 {}
L 1 1577.5 -3692.5 1582.5 -3692.5 {}
L 1 2067.5 -3772.5 2072.5 -3772.5 {}
L 1 2067.5 -3770 2072.5 -3770 {}
L 1 2067.5 -3767.5 2072.5 -3767.5 {}
L 1 2067.5 -3765 2072.5 -3765 {}
L 1 2067.5 -3762.5 2072.5 -3762.5 {}
L 1 2067.5 -3760 2072.5 -3760 {}
L 1 2067.5 -3757.5 2072.5 -3757.5 {}
L 1 2067.5 -3755 2072.5 -3755 {}
L 1 2067.5 -3752.5 2072.5 -3752.5 {}
L 1 2597.5 -3902.5 2602.5 -3902.5 {}
L 1 2597.5 -3900 2602.5 -3900 {}
L 1 2597.5 -3897.5 2602.5 -3897.5 {}
L 1 2597.5 -3895 2602.5 -3895 {}
L 1 2597.5 -3892.5 2602.5 -3892.5 {}
L 1 2597.5 -3890 2602.5 -3890 {}
L 1 2597.5 -3887.5 2602.5 -3887.5 {}
L 1 2597.5 -3885 2602.5 -3885 {}
L 1 2597.5 -3882.5 2602.5 -3882.5 {}
L 1 987.5 -10852.5 992.5 -10852.5 {}
L 1 987.5 -10850 992.5 -10850 {}
L 1 987.5 -10847.5 992.5 -10847.5 {}
L 1 987.5 -10845 992.5 -10845 {}
L 1 987.5 -10842.5 992.5 -10842.5 {}
L 1 987.5 -10840 992.5 -10840 {}
L 1 987.5 -10837.5 992.5 -10837.5 {}
L 1 987.5 -10835 992.5 -10835 {}
L 1 987.5 -10832.5 992.5 -10832.5 {}
L 1 820 -1490 820 -1390 {}
L 1 710 -1490 710 -1390 {}
L 1 930 -1490 930 -1390 {}
L 1 1567.5 -1342.5 1572.5 -1342.5 {}
L 1 1567.5 -1340 1572.5 -1340 {}
L 1 1567.5 -1337.5 1572.5 -1337.5 {}
L 1 1567.5 -1335 1572.5 -1335 {}
L 1 1567.5 -1332.5 1572.5 -1332.5 {}
L 1 1567.5 -1330 1572.5 -1330 {}
L 1 1567.5 -1327.5 1572.5 -1327.5 {}
L 1 1567.5 -1325 1572.5 -1325 {}
L 1 1567.5 -1322.5 1572.5 -1322.5 {}
L 1 2077.5 -1292.5 2082.5 -1292.5 {}
L 1 2077.5 -1290 2082.5 -1290 {}
L 1 2077.5 -1287.5 2082.5 -1287.5 {}
L 1 2077.5 -1285 2082.5 -1285 {}
L 1 2077.5 -1282.5 2082.5 -1282.5 {}
L 1 2077.5 -1280 2082.5 -1280 {}
L 1 2077.5 -1277.5 2082.5 -1277.5 {}
L 1 2077.5 -1275 2082.5 -1275 {}
L 1 2077.5 -1272.5 2082.5 -1272.5 {}
L 1 620 -3070 870 -3070 {}
L 1 1340 -3070 1410 -3070 {}
L 1 1160 -3070 1220 -3070 {}
L 1 1790 -3070 2040 -3070 {}
L 1 2340 -3070 2590 -3070 {}
L 1 620 -2790 870 -2790 {}
L 1 1160 -2790 1410 -2790 {}
L 1 1790 -2790 2040 -2790 {}
L 1 1910 -2910 1910 -2790 {}
L 1 2460 -2790 2590 -2790 {}
L 1 2460 -2910 2460 -2790 {}
L 1 2360 -4150 2360 -3990 {}
L 1 2497.5 -4152.5 2502.5 -4152.5 {}
L 1 2497.5 -4150 2502.5 -4150 {}
L 1 2497.5 -4147.5 2502.5 -4147.5 {}
L 1 2497.5 -4145 2502.5 -4145 {}
L 1 2497.5 -4142.5 2502.5 -4142.5 {}
L 1 2497.5 -4140 2502.5 -4140 {}
L 1 2497.5 -4137.5 2502.5 -4137.5 {}
L 1 2497.5 -4135 2502.5 -4135 {}
L 1 2497.5 -4132.5 2502.5 -4132.5 {}
L 1 1160 -2210 1410 -2210 {}
L 1 1880 -2080 1950 -2080 {}
L 1 1700 -2080 1760 -2080 {}
L 1 1817.5 -2192.5 1822.5 -2192.5 {}
L 1 1817.5 -2190 1822.5 -2190 {}
L 1 1817.5 -2187.5 1822.5 -2187.5 {}
L 1 1817.5 -2185 1822.5 -2185 {}
L 1 1817.5 -2182.5 1822.5 -2182.5 {}
L 1 1817.5 -2180 1822.5 -2180 {}
L 1 1817.5 -2177.5 1822.5 -2177.5 {}
L 1 1817.5 -2175 1822.5 -2175 {}
L 1 1817.5 -2172.5 1822.5 -2172.5 {}
L 1 620 -2210 870 -2210 {}
L 1 667.5 -2122.5 672.5 -2122.5 {}
L 1 667.5 -2120 672.5 -2120 {}
L 1 667.5 -2117.5 672.5 -2117.5 {}
L 1 667.5 -2115 672.5 -2115 {}
L 1 667.5 -2112.5 672.5 -2112.5 {}
L 1 667.5 -2110 672.5 -2110 {}
L 1 667.5 -2107.5 672.5 -2107.5 {}
L 1 667.5 -2105 672.5 -2105 {}
L 1 667.5 -2102.5 672.5 -2102.5 {}
L 1 787.5 -2122.5 792.5 -2122.5 {}
L 1 787.5 -2120 792.5 -2120 {}
L 1 787.5 -2117.5 792.5 -2117.5 {}
L 1 787.5 -2115 792.5 -2115 {}
L 1 787.5 -2112.5 792.5 -2112.5 {}
L 1 787.5 -2110 792.5 -2110 {}
L 1 787.5 -2107.5 792.5 -2107.5 {}
L 1 787.5 -2105 792.5 -2105 {}
L 1 787.5 -2102.5 792.5 -2102.5 {}
L 1 1597.5 -792.5 1602.5 -792.5 {}
L 1 1597.5 -790 1602.5 -790 {}
L 1 1597.5 -787.5 1602.5 -787.5 {}
L 1 1597.5 -785 1602.5 -785 {}
L 1 1597.5 -782.5 1602.5 -782.5 {}
L 1 1597.5 -780 1602.5 -780 {}
L 1 1597.5 -777.5 1602.5 -777.5 {}
L 1 1597.5 -775 1602.5 -775 {}
L 1 1597.5 -772.5 1602.5 -772.5 {}
L 1 620 -2390 870 -2390 {}
L 1 1160 -2390 1410 -2390 {}
L 1 1790 -2390 2040 -2390 {}
L 1 1830 -2560 1830 -2440 {}
L 1 2277.5 -5272.5 2282.5 -5272.5 {}
L 1 2277.5 -5270 2282.5 -5270 {}
L 1 2277.5 -5267.5 2282.5 -5267.5 {}
L 1 2277.5 -5265 2282.5 -5265 {}
L 1 2277.5 -5262.5 2282.5 -5262.5 {}
L 1 2277.5 -5260 2282.5 -5260 {}
L 1 2277.5 -5257.5 2282.5 -5257.5 {}
L 1 2277.5 -5255 2282.5 -5255 {}
L 1 2277.5 -5252.5 2282.5 -5252.5 {}
L 1 1977.5 -4482.5 1982.5 -4482.5 {}
L 1 1977.5 -4480 1982.5 -4480 {}
L 1 1977.5 -4477.5 1982.5 -4477.5 {}
L 1 1977.5 -4475 1982.5 -4475 {}
L 1 1977.5 -4472.5 1982.5 -4472.5 {}
L 1 1977.5 -4470 1982.5 -4470 {}
L 1 1977.5 -4467.5 1982.5 -4467.5 {}
L 1 1977.5 -4465 1982.5 -4465 {}
L 1 1977.5 -4462.5 1982.5 -4462.5 {}
L 1 2337.5 -2782.5 2342.5 -2782.5 {}
L 1 2337.5 -2780 2342.5 -2780 {}
L 1 2337.5 -2777.5 2342.5 -2777.5 {}
L 1 2337.5 -2775 2342.5 -2775 {}
L 1 2337.5 -2772.5 2342.5 -2772.5 {}
L 1 2337.5 -2770 2342.5 -2770 {}
L 1 2337.5 -2767.5 2342.5 -2767.5 {}
L 1 2337.5 -2765 2342.5 -2765 {}
L 1 2337.5 -2762.5 2342.5 -2762.5 {}
L 1 807.5 -2902.5 812.5 -2902.5 {}
L 1 807.5 -2900 812.5 -2900 {}
L 1 807.5 -2897.5 812.5 -2897.5 {}
L 1 807.5 -2895 812.5 -2895 {}
L 1 807.5 -2892.5 812.5 -2892.5 {}
L 1 807.5 -2890 812.5 -2890 {}
L 1 807.5 -2887.5 812.5 -2887.5 {}
L 1 807.5 -2885 812.5 -2885 {}
L 1 807.5 -2882.5 812.5 -2882.5 {}
L 1 1347.5 -2882.5 1352.5 -2882.5 {}
L 1 1347.5 -2880 1352.5 -2880 {}
L 1 1347.5 -2877.5 1352.5 -2877.5 {}
L 1 1347.5 -2875 1352.5 -2875 {}
L 1 1347.5 -2872.5 1352.5 -2872.5 {}
L 1 1347.5 -2870 1352.5 -2870 {}
L 1 1347.5 -2867.5 1352.5 -2867.5 {}
L 1 1347.5 -2865 1352.5 -2865 {}
L 1 1347.5 -2862.5 1352.5 -2862.5 {}
L 1 2320 -2560 2320 -2440 {}
L 1 1257.5 -2502.5 1262.5 -2502.5 {}
L 1 1257.5 -2500 1262.5 -2500 {}
L 1 1257.5 -2497.5 1262.5 -2497.5 {}
L 1 1257.5 -2495 1262.5 -2495 {}
L 1 1257.5 -2492.5 1262.5 -2492.5 {}
L 1 1257.5 -2490 1262.5 -2490 {}
L 1 1257.5 -2487.5 1262.5 -2487.5 {}
L 1 1257.5 -2485 1262.5 -2485 {}
L 1 1257.5 -2482.5 1262.5 -2482.5 {}
L 1 2517.5 -2452.5 2522.5 -2452.5 {}
L 1 2517.5 -2450 2522.5 -2450 {}
L 1 2517.5 -2447.5 2522.5 -2447.5 {}
L 1 2517.5 -2445 2522.5 -2445 {}
L 1 2517.5 -2442.5 2522.5 -2442.5 {}
L 1 2517.5 -2440 2522.5 -2440 {}
L 1 2517.5 -2437.5 2522.5 -2437.5 {}
L 1 2517.5 -2435 2522.5 -2435 {}
L 1 2517.5 -2432.5 2522.5 -2432.5 {}
L 1 2477.5 -1042.5 2482.5 -1042.5 {}
L 1 2477.5 -1040 2482.5 -1040 {}
L 1 2477.5 -1037.5 2482.5 -1037.5 {}
L 1 2477.5 -1035 2482.5 -1035 {}
L 1 2477.5 -1032.5 2482.5 -1032.5 {}
L 1 2477.5 -1030 2482.5 -1030 {}
L 1 2477.5 -1027.5 2482.5 -1027.5 {}
L 1 2477.5 -1025 2482.5 -1025 {}
L 1 2477.5 -1022.5 2482.5 -1022.5 {}
L 1 367.5 -8132.5 372.5 -8132.5 {}
L 1 367.5 -8130 372.5 -8130 {}
L 1 367.5 -8127.5 372.5 -8127.5 {}
L 1 367.5 -8125 372.5 -8125 {}
L 1 367.5 -8122.5 372.5 -8122.5 {}
L 1 367.5 -8120 372.5 -8120 {}
L 1 367.5 -8117.5 372.5 -8117.5 {}
L 1 367.5 -8115 372.5 -8115 {}
L 1 367.5 -8112.5 372.5 -8112.5 {}
L 1 897.5 -8302.5 902.5 -8302.5 {}
L 1 897.5 -8300 902.5 -8300 {}
L 1 897.5 -8297.5 902.5 -8297.5 {}
L 1 897.5 -8295 902.5 -8295 {}
L 1 897.5 -8292.5 902.5 -8292.5 {}
L 1 897.5 -8290 902.5 -8290 {}
L 1 897.5 -8287.5 902.5 -8287.5 {}
L 1 897.5 -8285 902.5 -8285 {}
L 1 897.5 -8282.5 902.5 -8282.5 {}
L 1 800 -8340 800 -8230 {}
L 1 1147.5 -8342.5 1152.5 -8342.5 {}
L 1 1147.5 -8340 1152.5 -8340 {}
L 1 1147.5 -8337.5 1152.5 -8337.5 {}
L 1 1147.5 -8335 1152.5 -8335 {}
L 1 1147.5 -8332.5 1152.5 -8332.5 {}
L 1 1147.5 -8330 1152.5 -8330 {}
L 1 1147.5 -8327.5 1152.5 -8327.5 {}
L 1 1147.5 -8325 1152.5 -8325 {}
L 1 1147.5 -8322.5 1152.5 -8322.5 {}
L 1 1090 -8340 1090 -8230 {}
L 1 1437.5 -8342.5 1442.5 -8342.5 {}
L 1 1437.5 -8340 1442.5 -8340 {}
L 1 1437.5 -8337.5 1442.5 -8337.5 {}
L 1 1437.5 -8335 1442.5 -8335 {}
L 1 1437.5 -8332.5 1442.5 -8332.5 {}
L 1 1437.5 -8330 1442.5 -8330 {}
L 1 1437.5 -8327.5 1442.5 -8327.5 {}
L 1 1437.5 -8325 1442.5 -8325 {}
L 1 1437.5 -8322.5 1442.5 -8322.5 {}
L 1 1320 -8340 1320 -8230 {}
L 1 1610 -8340 1610 -8230 {}
L 1 1897.5 -8302.5 1902.5 -8302.5 {}
L 1 1897.5 -8300 1902.5 -8300 {}
L 1 1897.5 -8297.5 1902.5 -8297.5 {}
L 1 1897.5 -8295 1902.5 -8295 {}
L 1 1897.5 -8292.5 1902.5 -8292.5 {}
L 1 1897.5 -8290 1902.5 -8290 {}
L 1 1897.5 -8287.5 1902.5 -8287.5 {}
L 1 1897.5 -8285 1902.5 -8285 {}
L 1 1897.5 -8282.5 1902.5 -8282.5 {}
L 1 1850 -8340 1850 -8230 {}
L 1 2150 -8340 2150 -8230 {}
L 1 927.5 -4852.5 932.5 -4852.5 {}
L 1 927.5 -4850 932.5 -4850 {}
L 1 927.5 -4847.5 932.5 -4847.5 {}
L 1 927.5 -4845 932.5 -4845 {}
L 1 927.5 -4842.5 932.5 -4842.5 {}
L 1 927.5 -4840 932.5 -4840 {}
L 1 927.5 -4837.5 932.5 -4837.5 {}
L 1 927.5 -4835 932.5 -4835 {}
L 1 927.5 -4832.5 932.5 -4832.5 {}
L 1 1767.5 -4902.5 1772.5 -4902.5 {}
L 1 1767.5 -4900 1772.5 -4900 {}
L 1 1767.5 -4897.5 1772.5 -4897.5 {}
L 1 1767.5 -4895 1772.5 -4895 {}
L 1 1767.5 -4892.5 1772.5 -4892.5 {}
L 1 1767.5 -4890 1772.5 -4890 {}
L 1 1767.5 -4887.5 1772.5 -4887.5 {}
L 1 1767.5 -4885 1772.5 -4885 {}
L 1 1767.5 -4882.5 1772.5 -4882.5 {}
L 1 2527.5 -4902.5 2532.5 -4902.5 {}
L 1 2527.5 -4900 2532.5 -4900 {}
L 1 2527.5 -4897.5 2532.5 -4897.5 {}
L 1 2527.5 -4895 2532.5 -4895 {}
L 1 2527.5 -4892.5 2532.5 -4892.5 {}
L 1 2527.5 -4890 2532.5 -4890 {}
L 1 2527.5 -4887.5 2532.5 -4887.5 {}
L 1 2527.5 -4885 2532.5 -4885 {}
L 1 2527.5 -4882.5 2532.5 -4882.5 {}
L 1 902.5 -9122.5 907.5 -9122.5 {}
L 1 902.5 -9120 907.5 -9120 {}
L 1 902.5 -9117.5 907.5 -9117.5 {}
L 1 902.5 -9115 907.5 -9115 {}
L 1 902.5 -9112.5 907.5 -9112.5 {}
L 1 902.5 -9110 907.5 -9110 {}
L 1 902.5 -9107.5 907.5 -9107.5 {}
L 1 902.5 -9105 907.5 -9105 {}
L 1 902.5 -9102.5 907.5 -9102.5 {}
L 1 1437.5 -9002.5 1442.5 -9002.5 {}
L 1 1437.5 -9000 1442.5 -9000 {}
L 1 1437.5 -8997.5 1442.5 -8997.5 {}
L 1 1437.5 -8995 1442.5 -8995 {}
L 1 1437.5 -8992.5 1442.5 -8992.5 {}
L 1 1437.5 -8990 1442.5 -8990 {}
L 1 1437.5 -8987.5 1442.5 -8987.5 {}
L 1 1437.5 -8985 1442.5 -8985 {}
L 1 1437.5 -8982.5 1442.5 -8982.5 {}
L 1 465 -9160 705 -9160 {}
L 1 1030 -9160 1270 -9160 {}
L 1 1807.5 -9002.5 1812.5 -9002.5 {}
L 1 1807.5 -9000 1812.5 -9000 {}
L 1 1807.5 -8997.5 1812.5 -8997.5 {}
L 1 1807.5 -8995 1812.5 -8995 {}
L 1 1807.5 -8992.5 1812.5 -8992.5 {}
L 1 1807.5 -8990 1812.5 -8990 {}
L 1 1807.5 -8987.5 1812.5 -8987.5 {}
L 1 1807.5 -8985 1812.5 -8985 {}
L 1 1807.5 -8982.5 1812.5 -8982.5 {}
L 1 1530 -9160 1770 -9160 {}
L 1 2297.5 -9002.5 2302.5 -9002.5 {}
L 1 2297.5 -9000 2302.5 -9000 {}
L 1 2297.5 -8997.5 2302.5 -8997.5 {}
L 1 2297.5 -8995 2302.5 -8995 {}
L 1 2297.5 -8992.5 2302.5 -8992.5 {}
L 1 2297.5 -8990 2302.5 -8990 {}
L 1 2297.5 -8987.5 2302.5 -8987.5 {}
L 1 2297.5 -8985 2302.5 -8985 {}
L 1 2297.5 -8982.5 2302.5 -8982.5 {}
L 1 2020 -9160 2260 -9160 {}
L 1 1610 -8340 1670 -8340 {}
L 1 2247.5 -8152.5 2252.5 -8152.5 {}
L 1 2247.5 -8150 2252.5 -8150 {}
L 1 2247.5 -8147.5 2252.5 -8147.5 {}
L 1 2247.5 -8145 2252.5 -8145 {}
L 1 2247.5 -8142.5 2252.5 -8142.5 {}
L 1 2247.5 -8140 2252.5 -8140 {}
L 1 2247.5 -8137.5 2252.5 -8137.5 {}
L 1 2247.5 -8135 2252.5 -8135 {}
L 1 2247.5 -8132.5 2252.5 -8132.5 {}
L 1 2150 -8340 2210 -8340 {}
L 1 2047.5 -7602.5 2052.5 -7602.5 {}
L 1 2047.5 -7600 2052.5 -7600 {}
L 1 2047.5 -7597.5 2052.5 -7597.5 {}
L 1 2047.5 -7595 2052.5 -7595 {}
L 1 2047.5 -7592.5 2052.5 -7592.5 {}
L 1 2047.5 -7590 2052.5 -7590 {}
L 1 2047.5 -7587.5 2052.5 -7587.5 {}
L 1 2047.5 -7585 2052.5 -7585 {}
L 1 2047.5 -7582.5 2052.5 -7582.5 {}
L 1 2047.5 -7172.5 2052.5 -7172.5 {}
L 1 2047.5 -7170 2052.5 -7170 {}
L 1 2047.5 -7167.5 2052.5 -7167.5 {}
L 1 2047.5 -7165 2052.5 -7165 {}
L 1 2047.5 -7162.5 2052.5 -7162.5 {}
L 1 2047.5 -7160 2052.5 -7160 {}
L 1 2047.5 -7157.5 2052.5 -7157.5 {}
L 1 2047.5 -7155 2052.5 -7155 {}
L 1 2047.5 -7152.5 2052.5 -7152.5 {}
L 1 1157.5 -6692.5 1162.5 -6692.5 {}
L 1 1157.5 -6690 1162.5 -6690 {}
L 1 1157.5 -6687.5 1162.5 -6687.5 {}
L 1 1157.5 -6685 1162.5 -6685 {}
L 1 1157.5 -6682.5 1162.5 -6682.5 {}
L 1 1157.5 -6680 1162.5 -6680 {}
L 1 1157.5 -6677.5 1162.5 -6677.5 {}
L 1 1157.5 -6675 1162.5 -6675 {}
L 1 1157.5 -6672.5 1162.5 -6672.5 {}
L 1 2360 -8340 2360 -8230 {}
L 1 2477.5 -8212.5 2482.5 -8212.5 {}
L 1 2477.5 -8210 2482.5 -8210 {}
L 1 2477.5 -8207.5 2482.5 -8207.5 {}
L 1 2477.5 -8205 2482.5 -8205 {}
L 1 2477.5 -8202.5 2482.5 -8202.5 {}
L 1 2477.5 -8200 2482.5 -8200 {}
L 1 2477.5 -8197.5 2482.5 -8197.5 {}
L 1 2477.5 -8195 2482.5 -8195 {}
L 1 2477.5 -8192.5 2482.5 -8192.5 {}
L 1 2360 -8340 2420 -8340 {}
L 1 617.5 -8342.5 622.5 -8342.5 {}
L 1 617.5 -8340 622.5 -8340 {}
L 1 617.5 -8337.5 622.5 -8337.5 {}
L 1 617.5 -8335 622.5 -8335 {}
L 1 617.5 -8332.5 622.5 -8332.5 {}
L 1 617.5 -8330 622.5 -8330 {}
L 1 617.5 -8327.5 622.5 -8327.5 {}
L 1 617.5 -8325 622.5 -8325 {}
L 1 617.5 -8322.5 622.5 -8322.5 {}
L 1 1970 -260 2040 -260 {}
L 1 1970 -240 2040 -240 {}
L 1 1970 -220 2040 -220 {}
L 1 1970 -200 2040 -200 {}
L 1 647.5 -162.5 652.5 -162.5 {}
L 1 647.5 -160 652.5 -160 {}
L 1 647.5 -157.5 652.5 -157.5 {}
L 1 647.5 -155 652.5 -155 {}
L 1 647.5 -152.5 652.5 -152.5 {}
L 1 647.5 -150 652.5 -150 {}
L 1 647.5 -147.5 652.5 -147.5 {}
L 1 647.5 -145 652.5 -145 {}
L 1 647.5 -142.5 652.5 -142.5 {}
L 1 1097.5 -162.5 1102.5 -162.5 {}
L 1 1097.5 -160 1102.5 -160 {}
L 1 1097.5 -157.5 1102.5 -157.5 {}
L 1 1097.5 -155 1102.5 -155 {}
L 1 1097.5 -152.5 1102.5 -152.5 {}
L 1 1097.5 -150 1102.5 -150 {}
L 1 1097.5 -147.5 1102.5 -147.5 {}
L 1 1097.5 -145 1102.5 -145 {}
L 1 1097.5 -142.5 1102.5 -142.5 {}
L 1 1517.5 -132.5 1522.5 -132.5 {}
L 1 1517.5 -130 1522.5 -130 {}
L 1 1517.5 -127.5 1522.5 -127.5 {}
L 1 1517.5 -125 1522.5 -125 {}
L 1 1517.5 -122.5 1522.5 -122.5 {}
L 1 1517.5 -120 1522.5 -120 {}
L 1 1517.5 -117.5 1522.5 -117.5 {}
L 1 1517.5 -115 1522.5 -115 {}
L 1 1517.5 -112.5 1522.5 -112.5 {}
L 1 2447.5 -192.5 2452.5 -192.5 {}
L 1 2447.5 -190 2452.5 -190 {}
L 1 2447.5 -187.5 2452.5 -187.5 {}
L 1 2447.5 -185 2452.5 -185 {}
L 1 2447.5 -182.5 2452.5 -182.5 {}
L 1 2447.5 -180 2452.5 -180 {}
L 1 2447.5 -177.5 2452.5 -177.5 {}
L 1 2447.5 -175 2452.5 -175 {}
L 1 2447.5 -172.5 2452.5 -172.5 {}
L 1 2207.5 -11242.5 2212.5 -11242.5 {}
L 1 2207.5 -11240 2212.5 -11240 {}
L 1 2207.5 -11237.5 2212.5 -11237.5 {}
L 1 2207.5 -11235 2212.5 -11235 {}
L 1 2207.5 -11232.5 2212.5 -11232.5 {}
L 1 2207.5 -11230 2212.5 -11230 {}
L 1 2207.5 -11227.5 2212.5 -11227.5 {}
L 1 2207.5 -11225 2212.5 -11225 {}
L 1 2207.5 -11222.5 2212.5 -11222.5 {}
L 2 1255 -10290 1255 -10230 {}
L 2 1255 -10280 1270 -10280 {}
L 2 1270 -10290 1270 -10280 {}
L 2 1255 -10240 1270 -10240 {}
L 2 1270 -10240 1270 -10230 {}
L 2 1245 -10275 1245 -10245 {}
L 2 1245 -10260 1245 -10255 {}
L 2 1230 -10260 1237.5 -10260 {}
L 2 1230 -10260 1245 -10260 {}
L 2 1260 -10260 1270 -10260 {}
L 2 1255 -10265 1260 -10260 {}
L 2 1255 -10255 1260 -10260 {}
L 2 1270 -10330 1270 -10320 {}
L 2 1270 -10330 1277.5 -10332.5 {}
L 2 1262.5 -10337.5 1277.5 -10332.5 {}
L 2 1262.5 -10337.5 1277.5 -10342.5 {}
L 2 1262.5 -10347.5 1277.5 -10342.5 {}
L 2 1262.5 -10347.5 1277.5 -10352.5 {}
L 2 1262.5 -10357.5 1277.5 -10352.5 {}
L 2 1262.5 -10357.5 1277.5 -10362.5 {}
L 2 1262.5 -10367.5 1277.5 -10362.5 {}
L 2 1262.5 -10367.5 1270 -10370 {}
L 2 1270 -10380 1270 -10370 {}
L 2 1272.5 -10372.5 1277.5 -10372.5 {}
L 2 1275 -10375 1275 -10370 {}
L 2 1360 -10255 1360 -10230 {}
L 2 1360 -10290 1360 -10265 {}
L 2 1350 -10265 1370 -10265 {}
L 2 1350 -10255 1370 -10255 {}
L 2 1362.5 -10282.5 1367.5 -10282.5 {}
L 2 1365 -10285 1365 -10280 {}
L 2 1270 -10320 1270 -10290 {}
L 2 1270 -10410 1270 -10380 {}
L 2 1360 -10230 1360 -10150 {}
L 2 1270 -10260 1270 -10150 {}
L 2 1270 -10150 1360 -10150 {}
L 2 2035 -10300 2035 -10240 {}
L 2 2035 -10290 2050 -10290 {}
L 2 2050 -10300 2050 -10290 {}
L 2 2035 -10250 2050 -10250 {}
L 2 2050 -10250 2050 -10240 {}
L 2 2025 -10285 2025 -10255 {}
L 2 2025 -10270 2025 -10265 {}
L 2 2010 -10270 2017.5 -10270 {}
L 2 2010 -10270 2025 -10270 {}
L 2 2040 -10270 2050 -10270 {}
L 2 2035 -10275 2040 -10270 {}
L 2 2035 -10265 2040 -10270 {}
L 2 2050 -10340 2050 -10330 {}
L 2 2050 -10340 2057.5 -10342.5 {}
L 2 2042.5 -10347.5 2057.5 -10342.5 {}
L 2 2042.5 -10347.5 2057.5 -10352.5 {}
L 2 2042.5 -10357.5 2057.5 -10352.5 {}
L 2 2042.5 -10357.5 2057.5 -10362.5 {}
L 2 2042.5 -10367.5 2057.5 -10362.5 {}
L 2 2042.5 -10367.5 2057.5 -10372.5 {}
L 2 2042.5 -10377.5 2057.5 -10372.5 {}
L 2 2042.5 -10377.5 2050 -10380 {}
L 2 2050 -10390 2050 -10380 {}
L 2 2052.5 -10382.5 2057.5 -10382.5 {}
L 2 2055 -10385 2055 -10380 {}
L 2 2140 -10265 2140 -10240 {}
L 2 2140 -10300 2140 -10275 {}
L 2 2130 -10275 2150 -10275 {}
L 2 2130 -10265 2150 -10265 {}
L 2 2142.5 -10292.5 2147.5 -10292.5 {}
L 2 2145 -10295 2145 -10290 {}
L 2 2050 -10330 2050 -10300 {}
L 2 2050 -10420 2050 -10390 {}
L 2 2140 -10240 2140 -10160 {}
L 2 2050 -10270 2050 -10160 {}
L 2 2050 -10160 2140 -10160 {}
L 2 1360 -9870 1360 -9860 {}
L 2 1360 -9870 1367.5 -9872.5 {}
L 2 1352.5 -9877.5 1367.5 -9872.5 {}
L 2 1352.5 -9877.5 1367.5 -9882.5 {}
L 2 1352.5 -9887.5 1367.5 -9882.5 {}
L 2 1352.5 -9887.5 1367.5 -9892.5 {}
L 2 1352.5 -9897.5 1367.5 -9892.5 {}
L 2 1352.5 -9897.5 1367.5 -9902.5 {}
L 2 1352.5 -9907.5 1367.5 -9902.5 {}
L 2 1352.5 -9907.5 1360 -9910 {}
L 2 1360 -9920 1360 -9910 {}
L 2 1362.5 -9912.5 1367.5 -9912.5 {}
L 2 1365 -9915 1365 -9910 {}
L 2 1360 -6280 1360 -6270 {}
L 2 1360 -6280 1367.5 -6282.5 {}
L 2 1352.5 -6287.5 1367.5 -6282.5 {}
L 2 1352.5 -6287.5 1367.5 -6292.5 {}
L 2 1352.5 -6297.5 1367.5 -6292.5 {}
L 2 1352.5 -6297.5 1367.5 -6302.5 {}
L 2 1352.5 -6307.5 1367.5 -6302.5 {}
L 2 1352.5 -6307.5 1367.5 -6312.5 {}
L 2 1352.5 -6317.5 1367.5 -6312.5 {}
L 2 1352.5 -6317.5 1360 -6320 {}
L 2 1360 -6330 1360 -6320 {}
L 2 1362.5 -6322.5 1367.5 -6322.5 {}
L 2 1365 -6325 1365 -6320 {}
L 2 1280 -6330 1360 -6330 {}
L 2 1280 -6270 1360 -6270 {}
L 2 1360 -5880 1360 -5870 {}
L 2 1360 -5880 1367.5 -5882.5 {}
L 2 1352.5 -5887.5 1367.5 -5882.5 {}
L 2 1352.5 -5887.5 1367.5 -5892.5 {}
L 2 1352.5 -5897.5 1367.5 -5892.5 {}
L 2 1352.5 -5897.5 1367.5 -5902.5 {}
L 2 1352.5 -5907.5 1367.5 -5902.5 {}
L 2 1352.5 -5907.5 1367.5 -5912.5 {}
L 2 1352.5 -5917.5 1367.5 -5912.5 {}
L 2 1352.5 -5917.5 1360 -5920 {}
L 2 1360 -5930 1360 -5920 {}
L 2 1362.5 -5922.5 1367.5 -5922.5 {}
L 2 1365 -5925 1365 -5920 {}
L 2 1280 -5840 1360 -5870 {}
L 2 1280 -5960 1360 -5930 {}
L 2 725 -10290 725 -10230 {}
L 2 725 -10280 740 -10280 {}
L 2 740 -10290 740 -10280 {}
L 2 725 -10240 740 -10240 {}
L 2 740 -10240 740 -10230 {}
L 2 715 -10275 715 -10245 {}
L 2 715 -10260 715 -10255 {}
L 2 700 -10260 707.5 -10260 {}
L 2 700 -10260 715 -10260 {}
L 2 730 -10260 740 -10260 {}
L 2 725 -10265 730 -10260 {}
L 2 725 -10255 730 -10260 {}
L 2 740 -10330 740 -10320 {}
L 2 740 -10330 747.5 -10332.5 {}
L 2 732.5 -10337.5 747.5 -10332.5 {}
L 2 732.5 -10337.5 747.5 -10342.5 {}
L 2 732.5 -10347.5 747.5 -10342.5 {}
L 2 732.5 -10347.5 747.5 -10352.5 {}
L 2 732.5 -10357.5 747.5 -10352.5 {}
L 2 732.5 -10357.5 747.5 -10362.5 {}
L 2 732.5 -10367.5 747.5 -10362.5 {}
L 2 732.5 -10367.5 740 -10370 {}
L 2 740 -10380 740 -10370 {}
L 2 742.5 -10372.5 747.5 -10372.5 {}
L 2 745 -10375 745 -10370 {}
L 2 830 -10255 830 -10230 {}
L 2 830 -10290 830 -10265 {}
L 2 820 -10265 840 -10265 {}
L 2 820 -10255 840 -10255 {}
L 2 832.5 -10282.5 837.5 -10282.5 {}
L 2 835 -10285 835 -10280 {}
L 2 740 -10320 740 -10290 {}
L 2 740 -10410 740 -10380 {}
L 2 830 -10230 830 -10150 {}
L 2 740 -10260 740 -10150 {}
L 2 740 -10150 830 -10150 {}
L 2 725 -5400 725 -5340 {}
L 2 725 -5390 740 -5390 {}
L 2 740 -5400 740 -5390 {}
L 2 725 -5350 740 -5350 {}
L 2 740 -5350 740 -5340 {}
L 2 715 -5385 715 -5355 {}
L 2 715 -5370 715 -5365 {}
L 2 700 -5370 707.5 -5370 {}
L 2 700 -5370 715 -5370 {}
L 2 730 -5370 740 -5370 {}
L 2 725 -5375 730 -5370 {}
L 2 725 -5365 730 -5370 {}
L 2 740 -5440 740 -5430 {}
L 2 740 -5440 747.5 -5442.5 {}
L 2 732.5 -5447.5 747.5 -5442.5 {}
L 2 732.5 -5447.5 747.5 -5452.5 {}
L 2 732.5 -5457.5 747.5 -5452.5 {}
L 2 732.5 -5457.5 747.5 -5462.5 {}
L 2 732.5 -5467.5 747.5 -5462.5 {}
L 2 732.5 -5467.5 747.5 -5472.5 {}
L 2 732.5 -5477.5 747.5 -5472.5 {}
L 2 732.5 -5477.5 740 -5480 {}
L 2 740 -5490 740 -5480 {}
L 2 742.5 -5482.5 747.5 -5482.5 {}
L 2 745 -5485 745 -5480 {}
L 2 830 -5365 830 -5340 {}
L 2 830 -5400 830 -5375 {}
L 2 820 -5375 840 -5375 {}
L 2 820 -5365 840 -5365 {}
L 2 832.5 -5392.5 837.5 -5392.5 {}
L 2 835 -5395 835 -5390 {}
L 2 740 -5430 740 -5400 {}
L 2 740 -5520 740 -5490 {}
L 2 830 -5340 830 -5260 {}
L 2 740 -5370 740 -5260 {}
L 2 740 -5260 830 -5260 {}
L 2 880 -5400 888.75 -5400 {}
L 2 740 -5400 880 -5400 {}
L 2 1285 -5400 1285 -5340 {}
L 2 1285 -5390 1300 -5390 {}
L 2 1300 -5400 1300 -5390 {}
L 2 1285 -5350 1300 -5350 {}
L 2 1300 -5350 1300 -5340 {}
L 2 1275 -5385 1275 -5355 {}
L 2 1275 -5370 1275 -5365 {}
L 2 1260 -5370 1267.5 -5370 {}
L 2 1260 -5370 1275 -5370 {}
L 2 1290 -5370 1300 -5370 {}
L 2 1285 -5375 1290 -5370 {}
L 2 1285 -5365 1290 -5370 {}
L 2 1300 -5440 1300 -5430 {}
L 2 1300 -5440 1307.5 -5442.5 {}
L 2 1292.5 -5447.5 1307.5 -5442.5 {}
L 2 1292.5 -5447.5 1307.5 -5452.5 {}
L 2 1292.5 -5457.5 1307.5 -5452.5 {}
L 2 1292.5 -5457.5 1307.5 -5462.5 {}
L 2 1292.5 -5467.5 1307.5 -5462.5 {}
L 2 1292.5 -5467.5 1307.5 -5472.5 {}
L 2 1292.5 -5477.5 1307.5 -5472.5 {}
L 2 1292.5 -5477.5 1300 -5480 {}
L 2 1300 -5490 1300 -5480 {}
L 2 1302.5 -5482.5 1307.5 -5482.5 {}
L 2 1305 -5485 1305 -5480 {}
L 2 1390 -5365 1390 -5340 {}
L 2 1390 -5400 1390 -5375 {}
L 2 1380 -5375 1400 -5375 {}
L 2 1380 -5365 1400 -5365 {}
L 2 1392.5 -5392.5 1397.5 -5392.5 {}
L 2 1395 -5395 1395 -5390 {}
L 2 1440 -5400 1448.75 -5400 {}
L 2 1300 -5430 1300 -5400 {}
L 2 1300 -5520 1300 -5490 {}
L 2 1300 -5400 1440 -5400 {}
L 2 1390 -5340 1390 -5260 {}
L 2 1300 -5370 1300 -5260 {}
L 2 1300 -5260 1390 -5260 {}
L 2 2105 -5400 2105 -5340 {}
L 2 2105 -5390 2120 -5390 {}
L 2 2120 -5400 2120 -5390 {}
L 2 2105 -5350 2120 -5350 {}
L 2 2120 -5350 2120 -5340 {}
L 2 2095 -5385 2095 -5355 {}
L 2 2095 -5370 2095 -5365 {}
L 2 2080 -5370 2087.5 -5370 {}
L 2 2080 -5370 2095 -5370 {}
L 2 2110 -5370 2120 -5370 {}
L 2 2105 -5375 2110 -5370 {}
L 2 2105 -5365 2110 -5370 {}
L 2 2120 -5440 2120 -5430 {}
L 2 2120 -5440 2127.5 -5442.5 {}
L 2 2112.5 -5447.5 2127.5 -5442.5 {}
L 2 2112.5 -5447.5 2127.5 -5452.5 {}
L 2 2112.5 -5457.5 2127.5 -5452.5 {}
L 2 2112.5 -5457.5 2127.5 -5462.5 {}
L 2 2112.5 -5467.5 2127.5 -5462.5 {}
L 2 2112.5 -5467.5 2127.5 -5472.5 {}
L 2 2112.5 -5477.5 2127.5 -5472.5 {}
L 2 2112.5 -5477.5 2120 -5480 {}
L 2 2120 -5490 2120 -5480 {}
L 2 2122.5 -5482.5 2127.5 -5482.5 {}
L 2 2125 -5485 2125 -5480 {}
L 2 2210 -5365 2210 -5340 {}
L 2 2210 -5400 2210 -5375 {}
L 2 2200 -5375 2220 -5375 {}
L 2 2200 -5365 2220 -5365 {}
L 2 2212.5 -5392.5 2217.5 -5392.5 {}
L 2 2215 -5395 2215 -5390 {}
L 2 2260 -5400 2268.75 -5400 {}
L 2 2120 -5430 2120 -5400 {}
L 2 2120 -5520 2120 -5490 {}
L 2 2120 -5400 2260 -5400 {}
L 2 2210 -5340 2210 -5260 {}
L 2 2120 -5370 2120 -5260 {}
L 2 2120 -5260 2210 -5260 {}
L 2 1770 -5370 2080 -5370 {}
L 2 1690 -5520 2120 -5520 {}
L 2 1690 -5260 2120 -5260 {}
L 2 1255 -9460 1255 -9400 {}
L 2 1255 -9450 1270 -9450 {}
L 2 1270 -9460 1270 -9450 {}
L 2 1255 -9410 1270 -9410 {}
L 2 1270 -9410 1270 -9400 {}
L 2 1245 -9445 1245 -9415 {}
L 2 1245 -9430 1245 -9425 {}
L 2 1230 -9430 1237.5 -9430 {}
L 2 1230 -9430 1245 -9430 {}
L 2 1260 -9430 1270 -9430 {}
L 2 1255 -9435 1260 -9430 {}
L 2 1255 -9425 1260 -9430 {}
L 2 1270 -9500 1270 -9490 {}
L 2 1270 -9500 1277.5 -9502.5 {}
L 2 1262.5 -9507.5 1277.5 -9502.5 {}
L 2 1262.5 -9507.5 1277.5 -9512.5 {}
L 2 1262.5 -9517.5 1277.5 -9512.5 {}
L 2 1262.5 -9517.5 1277.5 -9522.5 {}
L 2 1262.5 -9527.5 1277.5 -9522.5 {}
L 2 1262.5 -9527.5 1277.5 -9532.5 {}
L 2 1262.5 -9537.5 1277.5 -9532.5 {}
L 2 1262.5 -9537.5 1270 -9540 {}
L 2 1270 -9550 1270 -9540 {}
L 2 1272.5 -9542.5 1277.5 -9542.5 {}
L 2 1275 -9545 1275 -9540 {}
L 2 1360 -9425 1360 -9400 {}
L 2 1360 -9460 1360 -9435 {}
L 2 1350 -9435 1370 -9435 {}
L 2 1350 -9425 1370 -9425 {}
L 2 1362.5 -9452.5 1367.5 -9452.5 {}
L 2 1365 -9455 1365 -9450 {}
L 2 1270 -9490 1270 -9460 {}
L 2 1270 -9580 1270 -9550 {}
L 2 1360 -9400 1360 -9320 {}
L 2 1270 -9430 1270 -9320 {}
L 2 1270 -9320 1360 -9320 {}
L 2 2035 -9470 2035 -9410 {}
L 2 2035 -9460 2050 -9460 {}
L 2 2050 -9470 2050 -9460 {}
L 2 2035 -9420 2050 -9420 {}
L 2 2050 -9420 2050 -9410 {}
L 2 2025 -9455 2025 -9425 {}
L 2 2025 -9440 2025 -9435 {}
L 2 2010 -9440 2017.5 -9440 {}
L 2 2010 -9440 2025 -9440 {}
L 2 2040 -9440 2050 -9440 {}
L 2 2035 -9445 2040 -9440 {}
L 2 2035 -9435 2040 -9440 {}
L 2 2050 -9510 2050 -9500 {}
L 2 2050 -9510 2057.5 -9512.5 {}
L 2 2042.5 -9517.5 2057.5 -9512.5 {}
L 2 2042.5 -9517.5 2057.5 -9522.5 {}
L 2 2042.5 -9527.5 2057.5 -9522.5 {}
L 2 2042.5 -9527.5 2057.5 -9532.5 {}
L 2 2042.5 -9537.5 2057.5 -9532.5 {}
L 2 2042.5 -9537.5 2057.5 -9542.5 {}
L 2 2042.5 -9547.5 2057.5 -9542.5 {}
L 2 2042.5 -9547.5 2050 -9550 {}
L 2 2050 -9560 2050 -9550 {}
L 2 2052.5 -9552.5 2057.5 -9552.5 {}
L 2 2055 -9555 2055 -9550 {}
L 2 2140 -9435 2140 -9410 {}
L 2 2140 -9470 2140 -9445 {}
L 2 2130 -9445 2150 -9445 {}
L 2 2130 -9435 2150 -9435 {}
L 2 2142.5 -9462.5 2147.5 -9462.5 {}
L 2 2145 -9465 2145 -9460 {}
L 2 2050 -9500 2050 -9470 {}
L 2 2050 -9590 2050 -9560 {}
L 2 2140 -9410 2140 -9330 {}
L 2 2050 -9440 2050 -9330 {}
L 2 2050 -9330 2140 -9330 {}
L 2 725 -9460 725 -9400 {}
L 2 725 -9450 740 -9450 {}
L 2 740 -9460 740 -9450 {}
L 2 725 -9410 740 -9410 {}
L 2 740 -9410 740 -9400 {}
L 2 715 -9445 715 -9415 {}
L 2 715 -9430 715 -9425 {}
L 2 700 -9430 707.5 -9430 {}
L 2 700 -9430 715 -9430 {}
L 2 730 -9430 740 -9430 {}
L 2 725 -9435 730 -9430 {}
L 2 725 -9425 730 -9430 {}
L 2 740 -9500 740 -9490 {}
L 2 740 -9500 747.5 -9502.5 {}
L 2 732.5 -9507.5 747.5 -9502.5 {}
L 2 732.5 -9507.5 747.5 -9512.5 {}
L 2 732.5 -9517.5 747.5 -9512.5 {}
L 2 732.5 -9517.5 747.5 -9522.5 {}
L 2 732.5 -9527.5 747.5 -9522.5 {}
L 2 732.5 -9527.5 747.5 -9532.5 {}
L 2 732.5 -9537.5 747.5 -9532.5 {}
L 2 732.5 -9537.5 740 -9540 {}
L 2 740 -9550 740 -9540 {}
L 2 742.5 -9542.5 747.5 -9542.5 {}
L 2 745 -9545 745 -9540 {}
L 2 830 -9425 830 -9400 {}
L 2 830 -9460 830 -9435 {}
L 2 820 -9435 840 -9435 {}
L 2 820 -9425 840 -9425 {}
L 2 832.5 -9452.5 837.5 -9452.5 {}
L 2 835 -9455 835 -9450 {}
L 2 740 -9490 740 -9460 {}
L 2 740 -9580 740 -9550 {}
L 2 830 -9400 830 -9320 {}
L 2 740 -9430 740 -9320 {}
L 2 740 -9320 830 -9320 {}
L 2 1795 -10760 1795 -10700 {}
L 2 1795 -10750 1810 -10750 {}
L 2 1810 -10760 1810 -10750 {}
L 2 1795 -10710 1810 -10710 {}
L 2 1810 -10710 1810 -10700 {}
L 2 1785 -10745 1785 -10715 {}
L 2 1785 -10730 1785 -10725 {}
L 2 1770 -10730 1777.5 -10730 {}
L 2 1770 -10730 1785 -10730 {}
L 2 1800 -10730 1810 -10730 {}
L 2 1795 -10735 1800 -10730 {}
L 2 1795 -10725 1800 -10730 {}
L 2 1810 -10800 1810 -10790 {}
L 2 1810 -10800 1817.5 -10802.5 {}
L 2 1802.5 -10807.5 1817.5 -10802.5 {}
L 2 1802.5 -10807.5 1817.5 -10812.5 {}
L 2 1802.5 -10817.5 1817.5 -10812.5 {}
L 2 1802.5 -10817.5 1817.5 -10822.5 {}
L 2 1802.5 -10827.5 1817.5 -10822.5 {}
L 2 1802.5 -10827.5 1817.5 -10832.5 {}
L 2 1802.5 -10837.5 1817.5 -10832.5 {}
L 2 1802.5 -10837.5 1810 -10840 {}
L 2 1810 -10850 1810 -10840 {}
L 2 1812.5 -10842.5 1817.5 -10842.5 {}
L 2 1815 -10845 1815 -10840 {}
L 2 1900 -10725 1900 -10700 {}
L 2 1900 -10760 1900 -10735 {}
L 2 1890 -10735 1910 -10735 {}
L 2 1890 -10725 1910 -10725 {}
L 2 1902.5 -10752.5 1907.5 -10752.5 {}
L 2 1905 -10755 1905 -10750 {}
L 2 1810 -10790 1810 -10760 {}
L 2 1810 -10880 1810 -10850 {}
L 2 1900 -10700 1900 -10620 {}
L 2 1810 -10730 1810 -10620 {}
L 2 1810 -10620 1900 -10620 {}
L 2 670 -10760 670 -10700 {}
L 2 670 -10750 685 -10750 {}
L 2 685 -10760 685 -10750 {}
L 2 670 -10710 685 -10710 {}
L 2 685 -10710 685 -10700 {}
L 2 660 -10745 660 -10715 {}
L 2 660 -10730 660 -10725 {}
L 2 645 -10730 652.5 -10730 {}
L 2 645 -10730 660 -10730 {}
L 2 675 -10730 685 -10730 {}
L 2 670 -10735 675 -10730 {}
L 2 670 -10725 675 -10730 {}
L 2 685 -10800 685 -10790 {}
L 2 685 -10800 692.5 -10802.5 {}
L 2 677.5 -10807.5 692.5 -10802.5 {}
L 2 677.5 -10807.5 692.5 -10812.5 {}
L 2 677.5 -10817.5 692.5 -10812.5 {}
L 2 677.5 -10817.5 692.5 -10822.5 {}
L 2 677.5 -10827.5 692.5 -10822.5 {}
L 2 677.5 -10827.5 692.5 -10832.5 {}
L 2 677.5 -10837.5 692.5 -10832.5 {}
L 2 677.5 -10837.5 685 -10840 {}
L 2 685 -10850 685 -10840 {}
L 2 687.5 -10842.5 692.5 -10842.5 {}
L 2 690 -10845 690 -10840 {}
L 2 775 -10725 775 -10700 {}
L 2 775 -10760 775 -10735 {}
L 2 765 -10735 785 -10735 {}
L 2 765 -10725 785 -10725 {}
L 2 777.5 -10752.5 782.5 -10752.5 {}
L 2 780 -10755 780 -10750 {}
L 2 685 -10790 685 -10760 {}
L 2 685 -10880 685 -10850 {}
L 2 775 -10700 775 -10620 {}
L 2 685 -10730 685 -10620 {}
L 2 685 -10620 775 -10620 {}
L 2 1572.5 -10692.5 1577.5 -10692.5 {}
L 2 1575 -10695 1575 -10690 {}
L 2 1570 -10700 1570 -10640 {}
L 2 1570 -10640 1570 -10620 {}
L 2 1570 -10880 1570 -10700 {}
L 2 2255 -10760 2255 -10700 {}
L 2 2255 -10750 2270 -10750 {}
L 2 2270 -10760 2270 -10750 {}
L 2 2255 -10710 2270 -10710 {}
L 2 2270 -10710 2270 -10700 {}
L 2 2245 -10745 2245 -10715 {}
L 2 2245 -10730 2245 -10725 {}
L 2 2230 -10730 2237.5 -10730 {}
L 2 2230 -10730 2245 -10730 {}
L 2 2260 -10730 2270 -10730 {}
L 2 2255 -10735 2260 -10730 {}
L 2 2255 -10725 2260 -10730 {}
L 2 2270 -10800 2270 -10790 {}
L 2 2270 -10800 2277.5 -10802.5 {}
L 2 2262.5 -10807.5 2277.5 -10802.5 {}
L 2 2262.5 -10807.5 2277.5 -10812.5 {}
L 2 2262.5 -10817.5 2277.5 -10812.5 {}
L 2 2262.5 -10817.5 2277.5 -10822.5 {}
L 2 2262.5 -10827.5 2277.5 -10822.5 {}
L 2 2262.5 -10827.5 2277.5 -10832.5 {}
L 2 2262.5 -10837.5 2277.5 -10832.5 {}
L 2 2262.5 -10837.5 2270 -10840 {}
L 2 2270 -10850 2270 -10840 {}
L 2 2272.5 -10842.5 2277.5 -10842.5 {}
L 2 2275 -10845 2275 -10840 {}
L 2 2270 -10790 2270 -10760 {}
L 2 2270 -10880 2270 -10850 {}
L 2 2270 -10730 2270 -10620 {}
L 2 2270 -10620 2360 -10620 {}
L 2 2032.5 -10692.5 2037.5 -10692.5 {}
L 2 2035 -10695 2035 -10690 {}
L 2 2030 -10700 2030 -10640 {}
L 2 2030 -10640 2030 -10620 {}
L 2 2030 -10880 2030 -10700 {}
L 2 520 -8740 760 -8740 {}
L 2 1060 -8740 1300 -8740 {}
L 2 2190 -8740 2500 -8810 {}
L 2 1360 -4480 1360 -4470 {}
L 2 1360 -4480 1367.5 -4482.5 {}
L 2 1352.5 -4487.5 1367.5 -4482.5 {}
L 2 1352.5 -4487.5 1367.5 -4492.5 {}
L 2 1352.5 -4497.5 1367.5 -4492.5 {}
L 2 1352.5 -4497.5 1367.5 -4502.5 {}
L 2 1352.5 -4507.5 1367.5 -4502.5 {}
L 2 1352.5 -4507.5 1367.5 -4512.5 {}
L 2 1352.5 -4517.5 1367.5 -4512.5 {}
L 2 1352.5 -4517.5 1360 -4520 {}
L 2 1360 -4530 1360 -4520 {}
L 2 1362.5 -4522.5 1367.5 -4522.5 {}
L 2 1365 -4525 1365 -4520 {}
L 2 1900 -4510 1900 -4470 {}
L 2 1360 -3800 1360 -3700 {}
L 2 1250 -3800 1250 -3700 {}
L 2 1470 -3800 1470 -3700 {}
L 2 1900 -3800 1900 -3700 {}
L 2 1790 -3800 1790 -3700 {}
L 2 2010 -3800 2010 -3700 {}
L 2 2430 -3900 2430 -3700 {}
L 2 2320 -3900 2320 -3700 {}
L 2 2540 -3900 2540 -3700 {}
L 2 1360 -1870 1360 -1770 {}
L 2 1250 -1870 1250 -1770 {}
L 2 1470 -1870 1470 -1770 {}
L 2 1250 -1720 1250 -1710 {}
L 2 1250 -1720 1257.5 -1722.5 {}
L 2 1242.5 -1727.5 1257.5 -1722.5 {}
L 2 1242.5 -1727.5 1257.5 -1732.5 {}
L 2 1242.5 -1737.5 1257.5 -1732.5 {}
L 2 1242.5 -1737.5 1257.5 -1742.5 {}
L 2 1242.5 -1747.5 1257.5 -1742.5 {}
L 2 1242.5 -1747.5 1257.5 -1752.5 {}
L 2 1242.5 -1757.5 1257.5 -1752.5 {}
L 2 1242.5 -1757.5 1250 -1760 {}
L 2 1250 -1770 1250 -1760 {}
L 2 1252.5 -1762.5 1257.5 -1762.5 {}
L 2 1255 -1765 1255 -1760 {}
L 2 1360 -1720 1360 -1710 {}
L 2 1360 -1720 1367.5 -1722.5 {}
L 2 1352.5 -1727.5 1367.5 -1722.5 {}
L 2 1352.5 -1727.5 1367.5 -1732.5 {}
L 2 1352.5 -1737.5 1367.5 -1732.5 {}
L 2 1352.5 -1737.5 1367.5 -1742.5 {}
L 2 1352.5 -1747.5 1367.5 -1742.5 {}
L 2 1352.5 -1747.5 1367.5 -1752.5 {}
L 2 1352.5 -1757.5 1367.5 -1752.5 {}
L 2 1352.5 -1757.5 1360 -1760 {}
L 2 1360 -1770 1360 -1760 {}
L 2 1362.5 -1762.5 1367.5 -1762.5 {}
L 2 1365 -1765 1365 -1760 {}
L 2 1470 -1720 1470 -1710 {}
L 2 1470 -1720 1477.5 -1722.5 {}
L 2 1462.5 -1727.5 1477.5 -1722.5 {}
L 2 1462.5 -1727.5 1477.5 -1732.5 {}
L 2 1462.5 -1737.5 1477.5 -1732.5 {}
L 2 1462.5 -1737.5 1477.5 -1742.5 {}
L 2 1462.5 -1747.5 1477.5 -1742.5 {}
L 2 1462.5 -1747.5 1477.5 -1752.5 {}
L 2 1462.5 -1757.5 1477.5 -1752.5 {}
L 2 1462.5 -1757.5 1470 -1760 {}
L 2 1470 -1770 1470 -1760 {}
L 2 1472.5 -1762.5 1477.5 -1762.5 {}
L 2 1475 -1765 1475 -1760 {}
L 2 1360 -1710 1360 -1680 {}
L 2 1250 -1710 1250 -1680 {}
L 2 1470 -1710 1470 -1680 {}
L 2 1900 -1870 1900 -1820 {}
L 2 1790 -1870 1790 -1820 {}
L 2 2010 -1870 2010 -1820 {}
L 2 1790 -1770 1790 -1760 {}
L 2 1790 -1770 1797.5 -1772.5 {}
L 2 1782.5 -1777.5 1797.5 -1772.5 {}
L 2 1782.5 -1777.5 1797.5 -1782.5 {}
L 2 1782.5 -1787.5 1797.5 -1782.5 {}
L 2 1782.5 -1787.5 1797.5 -1792.5 {}
L 2 1782.5 -1797.5 1797.5 -1792.5 {}
L 2 1782.5 -1797.5 1797.5 -1802.5 {}
L 2 1782.5 -1807.5 1797.5 -1802.5 {}
L 2 1782.5 -1807.5 1790 -1810 {}
L 2 1790 -1820 1790 -1810 {}
L 2 1792.5 -1812.5 1797.5 -1812.5 {}
L 2 1795 -1815 1795 -1810 {}
L 2 1900 -1770 1900 -1760 {}
L 2 1900 -1770 1907.5 -1772.5 {}
L 2 1892.5 -1777.5 1907.5 -1772.5 {}
L 2 1892.5 -1777.5 1907.5 -1782.5 {}
L 2 1892.5 -1787.5 1907.5 -1782.5 {}
L 2 1892.5 -1787.5 1907.5 -1792.5 {}
L 2 1892.5 -1797.5 1907.5 -1792.5 {}
L 2 1892.5 -1797.5 1907.5 -1802.5 {}
L 2 1892.5 -1807.5 1907.5 -1802.5 {}
L 2 1892.5 -1807.5 1900 -1810 {}
L 2 1900 -1820 1900 -1810 {}
L 2 1902.5 -1812.5 1907.5 -1812.5 {}
L 2 1905 -1815 1905 -1810 {}
L 2 2010 -1770 2010 -1760 {}
L 2 2010 -1770 2017.5 -1772.5 {}
L 2 2002.5 -1777.5 2017.5 -1772.5 {}
L 2 2002.5 -1777.5 2017.5 -1782.5 {}
L 2 2002.5 -1787.5 2017.5 -1782.5 {}
L 2 2002.5 -1787.5 2017.5 -1792.5 {}
L 2 2002.5 -1797.5 2017.5 -1792.5 {}
L 2 2002.5 -1797.5 2017.5 -1802.5 {}
L 2 2002.5 -1807.5 2017.5 -1802.5 {}
L 2 2002.5 -1807.5 2010 -1810 {}
L 2 2010 -1820 2010 -1810 {}
L 2 2012.5 -1812.5 2017.5 -1812.5 {}
L 2 2015 -1815 2015 -1810 {}
L 2 1900 -1760 1900 -1680 {}
L 2 1790 -1760 1790 -1680 {}
L 2 2010 -1760 2010 -1680 {}
L 2 635 -3440 635 -3380 {}
L 2 635 -3430 650 -3430 {}
L 2 650 -3440 650 -3430 {}
L 2 635 -3390 650 -3390 {}
L 2 650 -3390 650 -3380 {}
L 2 625 -3425 625 -3395 {}
L 2 625 -3410 625 -3405 {}
L 2 610 -3410 617.5 -3410 {}
L 2 610 -3410 625 -3410 {}
L 2 640 -3410 650 -3410 {}
L 2 635 -3415 640 -3410 {}
L 2 635 -3405 640 -3410 {}
L 2 1215 -3440 1215 -3380 {}
L 2 1215 -3430 1230 -3430 {}
L 2 1230 -3440 1230 -3430 {}
L 2 1215 -3390 1230 -3390 {}
L 2 1230 -3390 1230 -3380 {}
L 2 1205 -3425 1205 -3395 {}
L 2 1205 -3410 1205 -3405 {}
L 2 1190 -3410 1197.5 -3410 {}
L 2 1190 -3410 1205 -3410 {}
L 2 1220 -3410 1230 -3410 {}
L 2 1215 -3415 1220 -3410 {}
L 2 1215 -3405 1220 -3410 {}
L 2 1255 -10760 1255 -10700 {}
L 2 1255 -10750 1270 -10750 {}
L 2 1270 -10760 1270 -10750 {}
L 2 1255 -10710 1270 -10710 {}
L 2 1270 -10710 1270 -10700 {}
L 2 1245 -10745 1245 -10715 {}
L 2 1245 -10730 1245 -10725 {}
L 2 1230 -10730 1237.5 -10730 {}
L 2 1230 -10730 1245 -10730 {}
L 2 1260 -10730 1270 -10730 {}
L 2 1255 -10735 1260 -10730 {}
L 2 1255 -10725 1260 -10730 {}
L 2 1270 -10800 1270 -10790 {}
L 2 1270 -10800 1277.5 -10802.5 {}
L 2 1262.5 -10807.5 1277.5 -10802.5 {}
L 2 1262.5 -10807.5 1277.5 -10812.5 {}
L 2 1262.5 -10817.5 1277.5 -10812.5 {}
L 2 1262.5 -10817.5 1277.5 -10822.5 {}
L 2 1262.5 -10827.5 1277.5 -10822.5 {}
L 2 1262.5 -10827.5 1277.5 -10832.5 {}
L 2 1262.5 -10837.5 1277.5 -10832.5 {}
L 2 1262.5 -10837.5 1270 -10840 {}
L 2 1270 -10850 1270 -10840 {}
L 2 1272.5 -10842.5 1277.5 -10842.5 {}
L 2 1275 -10845 1275 -10840 {}
L 2 1360 -10725 1360 -10700 {}
L 2 1360 -10760 1360 -10735 {}
L 2 1350 -10735 1370 -10735 {}
L 2 1350 -10725 1370 -10725 {}
L 2 1362.5 -10752.5 1367.5 -10752.5 {}
L 2 1365 -10755 1365 -10750 {}
L 2 1270 -10790 1270 -10760 {}
L 2 1270 -10880 1270 -10850 {}
L 2 1360 -10700 1360 -10620 {}
L 2 1270 -10730 1270 -10620 {}
L 2 1270 -10620 1360 -10620 {}
L 2 1360 -1490 1360 -1390 {}
L 2 1250 -1490 1250 -1390 {}
L 2 1470 -1490 1470 -1390 {}
L 2 1250 -1340 1250 -1330 {}
L 2 1250 -1340 1257.5 -1342.5 {}
L 2 1242.5 -1347.5 1257.5 -1342.5 {}
L 2 1242.5 -1347.5 1257.5 -1352.5 {}
L 2 1242.5 -1357.5 1257.5 -1352.5 {}
L 2 1242.5 -1357.5 1257.5 -1362.5 {}
L 2 1242.5 -1367.5 1257.5 -1362.5 {}
L 2 1242.5 -1367.5 1257.5 -1372.5 {}
L 2 1242.5 -1377.5 1257.5 -1372.5 {}
L 2 1242.5 -1377.5 1250 -1380 {}
L 2 1250 -1390 1250 -1380 {}
L 2 1252.5 -1382.5 1257.5 -1382.5 {}
L 2 1255 -1385 1255 -1380 {}
L 2 1360 -1340 1360 -1330 {}
L 2 1360 -1340 1367.5 -1342.5 {}
L 2 1352.5 -1347.5 1367.5 -1342.5 {}
L 2 1352.5 -1347.5 1367.5 -1352.5 {}
L 2 1352.5 -1357.5 1367.5 -1352.5 {}
L 2 1352.5 -1357.5 1367.5 -1362.5 {}
L 2 1352.5 -1367.5 1367.5 -1362.5 {}
L 2 1352.5 -1367.5 1367.5 -1372.5 {}
L 2 1352.5 -1377.5 1367.5 -1372.5 {}
L 2 1352.5 -1377.5 1360 -1380 {}
L 2 1360 -1390 1360 -1380 {}
L 2 1362.5 -1382.5 1367.5 -1382.5 {}
L 2 1365 -1385 1365 -1380 {}
L 2 1470 -1340 1470 -1330 {}
L 2 1470 -1340 1477.5 -1342.5 {}
L 2 1462.5 -1347.5 1477.5 -1342.5 {}
L 2 1462.5 -1347.5 1477.5 -1352.5 {}
L 2 1462.5 -1357.5 1477.5 -1352.5 {}
L 2 1462.5 -1357.5 1477.5 -1362.5 {}
L 2 1462.5 -1367.5 1477.5 -1362.5 {}
L 2 1462.5 -1367.5 1477.5 -1372.5 {}
L 2 1462.5 -1377.5 1477.5 -1372.5 {}
L 2 1462.5 -1377.5 1470 -1380 {}
L 2 1470 -1390 1470 -1380 {}
L 2 1472.5 -1382.5 1477.5 -1382.5 {}
L 2 1475 -1385 1475 -1380 {}
L 2 1900 -1490 1900 -1440 {}
L 2 1790 -1490 1790 -1440 {}
L 2 2010 -1490 2010 -1440 {}
L 2 1790 -1390 1790 -1380 {}
L 2 1790 -1390 1797.5 -1392.5 {}
L 2 1782.5 -1397.5 1797.5 -1392.5 {}
L 2 1782.5 -1397.5 1797.5 -1402.5 {}
L 2 1782.5 -1407.5 1797.5 -1402.5 {}
L 2 1782.5 -1407.5 1797.5 -1412.5 {}
L 2 1782.5 -1417.5 1797.5 -1412.5 {}
L 2 1782.5 -1417.5 1797.5 -1422.5 {}
L 2 1782.5 -1427.5 1797.5 -1422.5 {}
L 2 1782.5 -1427.5 1790 -1430 {}
L 2 1790 -1440 1790 -1430 {}
L 2 1792.5 -1432.5 1797.5 -1432.5 {}
L 2 1795 -1435 1795 -1430 {}
L 2 1900 -1390 1900 -1380 {}
L 2 1900 -1390 1907.5 -1392.5 {}
L 2 1892.5 -1397.5 1907.5 -1392.5 {}
L 2 1892.5 -1397.5 1907.5 -1402.5 {}
L 2 1892.5 -1407.5 1907.5 -1402.5 {}
L 2 1892.5 -1407.5 1907.5 -1412.5 {}
L 2 1892.5 -1417.5 1907.5 -1412.5 {}
L 2 1892.5 -1417.5 1907.5 -1422.5 {}
L 2 1892.5 -1427.5 1907.5 -1422.5 {}
L 2 1892.5 -1427.5 1900 -1430 {}
L 2 1900 -1440 1900 -1430 {}
L 2 1902.5 -1432.5 1907.5 -1432.5 {}
L 2 1905 -1435 1905 -1430 {}
L 2 2010 -1390 2010 -1380 {}
L 2 2010 -1390 2017.5 -1392.5 {}
L 2 2002.5 -1397.5 2017.5 -1392.5 {}
L 2 2002.5 -1397.5 2017.5 -1402.5 {}
L 2 2002.5 -1407.5 2017.5 -1402.5 {}
L 2 2002.5 -1407.5 2017.5 -1412.5 {}
L 2 2002.5 -1417.5 2017.5 -1412.5 {}
L 2 2002.5 -1417.5 2017.5 -1422.5 {}
L 2 2002.5 -1427.5 2017.5 -1422.5 {}
L 2 2002.5 -1427.5 2010 -1430 {}
L 2 2010 -1440 2010 -1430 {}
L 2 2012.5 -1432.5 2017.5 -1432.5 {}
L 2 2015 -1435 2015 -1430 {}
L 2 1900 -1380 1900 -1300 {}
L 2 1790 -1380 1790 -1300 {}
L 2 2010 -1380 2010 -1300 {}
L 2 600 -3160 720 -3160 {}
L 2 1220 -3070 1340 -3070 {}
L 2 740 -2940 740 -2820 {}
L 2 1280 -2910 1280 -2790 {}
L 2 2280 -2830 2410 -2830 {}
L 2 2360 -4320 2440 -4150 {}
L 2 1900 -4320 1900 -4150 {}
L 2 1760 -2110 1880 -2110 {}
L 2 680 -2160 680 -2150 {}
L 2 680 -2160 687.5 -2162.5 {}
L 2 672.5 -2167.5 687.5 -2162.5 {}
L 2 672.5 -2167.5 687.5 -2172.5 {}
L 2 672.5 -2177.5 687.5 -2172.5 {}
L 2 672.5 -2177.5 687.5 -2182.5 {}
L 2 672.5 -2187.5 687.5 -2182.5 {}
L 2 672.5 -2187.5 687.5 -2192.5 {}
L 2 672.5 -2197.5 687.5 -2192.5 {}
L 2 672.5 -2197.5 680 -2200 {}
L 2 680 -2210 680 -2200 {}
L 2 682.5 -2202.5 687.5 -2202.5 {}
L 2 685 -2205 685 -2200 {}
L 2 800 -2160 800 -2150 {}
L 2 800 -2160 807.5 -2162.5 {}
L 2 792.5 -2167.5 807.5 -2162.5 {}
L 2 792.5 -2167.5 807.5 -2172.5 {}
L 2 792.5 -2177.5 807.5 -2172.5 {}
L 2 792.5 -2177.5 807.5 -2182.5 {}
L 2 792.5 -2187.5 807.5 -2182.5 {}
L 2 792.5 -2187.5 807.5 -2192.5 {}
L 2 792.5 -2197.5 807.5 -2192.5 {}
L 2 792.5 -2197.5 800 -2200 {}
L 2 800 -2210 800 -2200 {}
L 2 802.5 -2202.5 807.5 -2202.5 {}
L 2 805 -2205 805 -2200 {}
L 2 1220 -2160 1220 -2150 {}
L 2 1220 -2160 1227.5 -2162.5 {}
L 2 1212.5 -2167.5 1227.5 -2162.5 {}
L 2 1212.5 -2167.5 1227.5 -2172.5 {}
L 2 1212.5 -2177.5 1227.5 -2172.5 {}
L 2 1212.5 -2177.5 1227.5 -2182.5 {}
L 2 1212.5 -2187.5 1227.5 -2182.5 {}
L 2 1212.5 -2187.5 1227.5 -2192.5 {}
L 2 1212.5 -2197.5 1227.5 -2192.5 {}
L 2 1212.5 -2197.5 1220 -2200 {}
L 2 1220 -2210 1220 -2200 {}
L 2 1222.5 -2202.5 1227.5 -2202.5 {}
L 2 1225 -2205 1225 -2200 {}
L 2 1340 -2160 1340 -2150 {}
L 2 1340 -2160 1347.5 -2162.5 {}
L 2 1332.5 -2167.5 1347.5 -2162.5 {}
L 2 1332.5 -2167.5 1347.5 -2172.5 {}
L 2 1332.5 -2177.5 1347.5 -2172.5 {}
L 2 1332.5 -2177.5 1347.5 -2182.5 {}
L 2 1332.5 -2187.5 1347.5 -2182.5 {}
L 2 1332.5 -2187.5 1347.5 -2192.5 {}
L 2 1332.5 -2197.5 1347.5 -2192.5 {}
L 2 1332.5 -2197.5 1340 -2200 {}
L 2 1340 -2210 1340 -2200 {}
L 2 1342.5 -2202.5 1347.5 -2202.5 {}
L 2 1345 -2205 1345 -2200 {}
L 2 1510 -895 1510 -870 {}
L 2 1510 -930 1510 -905 {}
L 2 1500 -905 1520 -905 {}
L 2 1500 -895 1520 -895 {}
L 2 1512.5 -922.5 1517.5 -922.5 {}
L 2 1515 -925 1515 -920 {}
L 2 1510 -870 1510 -790 {}
L 2 1180 -810 1180 -790 {}
L 2 1420 -900 1420 -790 {}
L 2 1420 -790 1510 -790 {}
L 2 1180 -790 1420 -790 {}
L 2 1420 -930 1560 -930 {}
L 2 740 -2510 740 -2390 {}
L 2 1200 -2560 1200 -2440 {}
L 2 2360 -2470 2610 -2470 {}
L 2 2430 -1075 2430 -1050 {}
L 2 2430 -1110 2430 -1085 {}
L 2 2420 -1085 2440 -1085 {}
L 2 2420 -1075 2440 -1075 {}
L 2 2432.5 -1102.5 2437.5 -1102.5 {}
L 2 2435 -1105 2435 -1100 {}
L 2 2430 -1050 2430 -970 {}
L 2 2100 -990 2100 -970 {}
L 2 2340 -1080 2340 -970 {}
L 2 2340 -970 2430 -970 {}
L 2 2100 -970 2340 -970 {}
L 2 2340 -1110 2480 -1110 {}
L 2 560 -8340 560 -8230 {}
L 2 1320 -8340 1380 -8340 {}
L 2 850 -4955 850 -4930 {}
L 2 850 -4990 850 -4965 {}
L 2 840 -4965 860 -4965 {}
L 2 840 -4955 860 -4955 {}
L 2 852.5 -4982.5 857.5 -4982.5 {}
L 2 855 -4985 855 -4980 {}
L 2 850 -4930 850 -4850 {}
L 2 1710 -4955 1710 -4930 {}
L 2 1710 -4990 1710 -4965 {}
L 2 1700 -4965 1720 -4965 {}
L 2 1700 -4955 1720 -4955 {}
L 2 1712.5 -4982.5 1717.5 -4982.5 {}
L 2 1715 -4985 1715 -4980 {}
L 2 1710 -4930 1710 -4850 {}
L 2 2470 -4955 2470 -4930 {}
L 2 2470 -4990 2470 -4965 {}
L 2 2460 -4965 2480 -4965 {}
L 2 2460 -4955 2480 -4955 {}
L 2 2472.5 -4982.5 2477.5 -4982.5 {}
L 2 2475 -4985 2475 -4980 {}
L 2 2470 -4930 2470 -4850 {}
L 2 805 -9150 885 -9150 {}
L 2 1330 -9040 1410 -9040 {}
L 2 1830 -9040 1910 -9040 {}
L 2 2260 -9040 2400 -9040 {}
L 2 1850 -8340 1910 -8340 {}
L 2 2150 -8170 2210 -8170 {}
L 2 515 -7980 515 -7920 {}
L 2 515 -7970 530 -7970 {}
L 2 530 -7980 530 -7970 {}
L 2 515 -7930 530 -7930 {}
L 2 530 -7930 530 -7920 {}
L 2 505 -7965 505 -7935 {}
L 2 505 -7950 505 -7945 {}
L 2 490 -7950 497.5 -7950 {}
L 2 490 -7950 505 -7950 {}
L 2 520 -7950 530 -7950 {}
L 2 515 -7955 520 -7950 {}
L 2 515 -7945 520 -7950 {}
L 2 455 -7950 460 -7950 {}
L 2 460 -7950 490 -7950 {}
L 2 530 -7950 530 -7840 {}
L 2 790 -7895 850 -7895 {}
L 2 840 -7895 840 -7880 {}
L 2 840 -7880 850 -7880 {}
L 2 800 -7895 800 -7880 {}
L 2 790 -7880 800 -7880 {}
L 2 805 -7905 835 -7905 {}
L 2 815 -7905 820 -7905 {}
L 2 820 -7920 820 -7912.5 {}
L 2 820 -7920 820 -7905 {}
L 2 820 -7890 820 -7880 {}
L 2 820 -7890 825 -7895 {}
L 2 815 -7895 820 -7890 {}
L 2 820 -7955 820 -7950 {}
L 2 820 -7950 820 -7920 {}
L 2 710 -7880 820 -7880 {}
L 2 1115 -7910 1115 -7850 {}
L 2 1100 -7860 1115 -7860 {}
L 2 1100 -7860 1100 -7850 {}
L 2 1100 -7900 1115 -7900 {}
L 2 1100 -7910 1100 -7900 {}
L 2 1125 -7895 1125 -7865 {}
L 2 1125 -7885 1125 -7880 {}
L 2 1132.5 -7880 1140 -7880 {}
L 2 1125 -7880 1140 -7880 {}
L 2 1100 -7880 1110 -7880 {}
L 2 1110 -7880 1115 -7875 {}
L 2 1110 -7880 1115 -7885 {}
L 2 1170 -7880 1175 -7880 {}
L 2 1140 -7880 1170 -7880 {}
L 2 1100 -7990 1100 -7880 {}
L 2 1380 -7945 1440 -7945 {}
L 2 1390 -7960 1390 -7945 {}
L 2 1380 -7960 1390 -7960 {}
L 2 1430 -7960 1430 -7945 {}
L 2 1430 -7960 1440 -7960 {}
L 2 1395 -7935 1425 -7935 {}
L 2 1410 -7935 1415 -7935 {}
L 2 1410 -7927.5 1410 -7920 {}
L 2 1410 -7935 1410 -7920 {}
L 2 1410 -7960 1410 -7950 {}
L 2 1405 -7945 1410 -7950 {}
L 2 1410 -7950 1415 -7945 {}
L 2 1410 -7890 1410 -7885 {}
L 2 1410 -7920 1410 -7890 {}
L 2 1410 -7960 1520 -7960 {}
L 2 1720 -7945 1780 -7945 {}
L 2 1770 -7960 1770 -7945 {}
L 2 1770 -7960 1780 -7960 {}
L 2 1730 -7960 1730 -7945 {}
L 2 1720 -7960 1730 -7960 {}
L 2 1735 -7935 1765 -7935 {}
L 2 1745 -7935 1750 -7935 {}
L 2 1750 -7927.5 1750 -7920 {}
L 2 1750 -7935 1750 -7920 {}
L 2 1750 -7960 1750 -7950 {}
L 2 1750 -7950 1755 -7945 {}
L 2 1745 -7945 1750 -7950 {}
L 2 1750 -7890 1750 -7885 {}
L 2 1750 -7920 1750 -7890 {}
L 2 1640 -7960 1750 -7960 {}
L 2 2050 -7905 2110 -7905 {}
L 2 2100 -7905 2100 -7890 {}
L 2 2100 -7890 2110 -7890 {}
L 2 2060 -7905 2060 -7890 {}
L 2 2050 -7890 2060 -7890 {}
L 2 2065 -7915 2095 -7915 {}
L 2 2075 -7915 2080 -7915 {}
L 2 2080 -7930 2080 -7922.5 {}
L 2 2080 -7930 2080 -7915 {}
L 2 2080 -7900 2080 -7890 {}
L 2 2080 -7900 2085 -7905 {}
L 2 2075 -7905 2080 -7900 {}
L 2 2080 -7965 2080 -7960 {}
L 2 2080 -7960 2080 -7930 {}
L 2 1970 -7890 2080 -7890 {}
L 2 530 -7600 770 -7600 {}
L 2 755 -7480 755 -7420 {}
L 2 755 -7470 770 -7470 {}
L 2 770 -7480 770 -7470 {}
L 2 755 -7430 770 -7430 {}
L 2 770 -7430 770 -7420 {}
L 2 745 -7465 745 -7435 {}
L 2 745 -7450 745 -7445 {}
L 2 730 -7450 737.5 -7450 {}
L 2 730 -7450 745 -7450 {}
L 2 760 -7450 770 -7450 {}
L 2 755 -7455 760 -7450 {}
L 2 755 -7445 760 -7450 {}
L 2 770 -7520 770 -7510 {}
L 2 770 -7520 777.5 -7522.5 {}
L 2 762.5 -7527.5 777.5 -7522.5 {}
L 2 762.5 -7527.5 777.5 -7532.5 {}
L 2 762.5 -7537.5 777.5 -7532.5 {}
L 2 762.5 -7537.5 777.5 -7542.5 {}
L 2 762.5 -7547.5 777.5 -7542.5 {}
L 2 762.5 -7547.5 777.5 -7552.5 {}
L 2 762.5 -7557.5 777.5 -7552.5 {}
L 2 762.5 -7557.5 770 -7560 {}
L 2 770 -7570 770 -7560 {}
L 2 772.5 -7562.5 777.5 -7562.5 {}
L 2 775 -7565 775 -7560 {}
L 2 860 -7445 860 -7420 {}
L 2 860 -7480 860 -7455 {}
L 2 850 -7455 870 -7455 {}
L 2 850 -7445 870 -7445 {}
L 2 862.5 -7472.5 867.5 -7472.5 {}
L 2 865 -7475 865 -7470 {}
L 2 532.5 -7412.5 537.5 -7412.5 {}
L 2 535 -7415 535 -7410 {}
L 2 530 -7420 530 -7360 {}
L 2 640 -7340 640 -7327.5 {}
L 2 635 -7327.5 645 -7327.5 {}
L 2 640 -7322.5 645 -7327.5 {}
L 2 635 -7327.5 640 -7322.5 {}
L 2 640 -7620 640 -7600 {}
L 2 630 -7620 650 -7620 {}
L 2 605 -7450 610 -7450 {}
L 2 610 -7450 730 -7450 {}
L 2 770 -7510 770 -7480 {}
L 2 770 -7600 770 -7570 {}
L 2 860 -7420 860 -7340 {}
L 2 530 -7360 530 -7340 {}
L 2 530 -7600 530 -7420 {}
L 2 770 -7450 770 -7340 {}
L 2 770 -7340 860 -7340 {}
L 2 530 -7340 770 -7340 {}
L 2 1005 -7600 1245 -7600 {}
L 2 1230 -7480 1230 -7420 {}
L 2 1230 -7470 1245 -7470 {}
L 2 1245 -7480 1245 -7470 {}
L 2 1230 -7430 1245 -7430 {}
L 2 1245 -7430 1245 -7420 {}
L 2 1220 -7465 1220 -7435 {}
L 2 1220 -7450 1220 -7445 {}
L 2 1205 -7450 1212.5 -7450 {}
L 2 1205 -7450 1220 -7450 {}
L 2 1235 -7450 1245 -7450 {}
L 2 1230 -7455 1235 -7450 {}
L 2 1230 -7445 1235 -7450 {}
L 2 1245 -7520 1245 -7510 {}
L 2 1245 -7520 1252.5 -7522.5 {}
L 2 1237.5 -7527.5 1252.5 -7522.5 {}
L 2 1237.5 -7527.5 1252.5 -7532.5 {}
L 2 1237.5 -7537.5 1252.5 -7532.5 {}
L 2 1237.5 -7537.5 1252.5 -7542.5 {}
L 2 1237.5 -7547.5 1252.5 -7542.5 {}
L 2 1237.5 -7547.5 1252.5 -7552.5 {}
L 2 1237.5 -7557.5 1252.5 -7552.5 {}
L 2 1237.5 -7557.5 1245 -7560 {}
L 2 1245 -7570 1245 -7560 {}
L 2 1247.5 -7562.5 1252.5 -7562.5 {}
L 2 1250 -7565 1250 -7560 {}
L 2 1335 -7445 1335 -7420 {}
L 2 1335 -7480 1335 -7455 {}
L 2 1325 -7455 1345 -7455 {}
L 2 1325 -7445 1345 -7445 {}
L 2 1337.5 -7472.5 1342.5 -7472.5 {}
L 2 1340 -7475 1340 -7470 {}
L 2 1007.5 -7412.5 1012.5 -7412.5 {}
L 2 1010 -7415 1010 -7410 {}
L 2 1005 -7420 1005 -7360 {}
L 2 1115 -7340 1115 -7327.5 {}
L 2 1110 -7327.5 1120 -7327.5 {}
L 2 1115 -7322.5 1120 -7327.5 {}
L 2 1110 -7327.5 1115 -7322.5 {}
L 2 1115 -7620 1115 -7600 {}
L 2 1105 -7620 1125 -7620 {}
L 2 1080 -7450 1085 -7450 {}
L 2 1085 -7450 1205 -7450 {}
L 2 1245 -7510 1245 -7480 {}
L 2 1245 -7600 1245 -7570 {}
L 2 1335 -7420 1335 -7340 {}
L 2 1005 -7360 1005 -7340 {}
L 2 1005 -7600 1005 -7420 {}
L 2 1245 -7450 1245 -7340 {}
L 2 1245 -7340 1335 -7340 {}
L 2 1005 -7340 1245 -7340 {}
L 2 1850 -7600 1850 -7360 {}
L 2 1670 -7375 1730 -7375 {}
L 2 1720 -7375 1720 -7360 {}
L 2 1720 -7360 1730 -7360 {}
L 2 1680 -7375 1680 -7360 {}
L 2 1670 -7360 1680 -7360 {}
L 2 1685 -7385 1715 -7385 {}
L 2 1695 -7385 1700 -7385 {}
L 2 1700 -7400 1700 -7392.5 {}
L 2 1700 -7400 1700 -7385 {}
L 2 1700 -7370 1700 -7360 {}
L 2 1700 -7370 1705 -7375 {}
L 2 1695 -7375 1700 -7370 {}
L 2 1760 -7360 1770 -7360 {}
L 2 1770 -7360 1772.5 -7352.5 {}
L 2 1772.5 -7352.5 1777.5 -7367.5 {}
L 2 1777.5 -7367.5 1782.5 -7352.5 {}
L 2 1782.5 -7352.5 1787.5 -7367.5 {}
L 2 1787.5 -7367.5 1792.5 -7352.5 {}
L 2 1792.5 -7352.5 1797.5 -7367.5 {}
L 2 1797.5 -7367.5 1802.5 -7352.5 {}
L 2 1802.5 -7352.5 1807.5 -7367.5 {}
L 2 1807.5 -7367.5 1810 -7360 {}
L 2 1810 -7360 1820 -7360 {}
L 2 1812.5 -7357.5 1812.5 -7352.5 {}
L 2 1810 -7355 1815 -7355 {}
L 2 1670 -7270 1695 -7270 {}
L 2 1705 -7270 1730 -7270 {}
L 2 1705 -7280 1705 -7260 {}
L 2 1695 -7280 1695 -7260 {}
L 2 1722.5 -7267.5 1722.5 -7262.5 {}
L 2 1720 -7265 1725 -7265 {}
L 2 1662.5 -7597.5 1662.5 -7592.5 {}
L 2 1660 -7595 1665 -7595 {}
L 2 1610 -7600 1670 -7600 {}
L 2 1577.5 -7490 1590 -7490 {}
L 2 1577.5 -7495 1577.5 -7485 {}
L 2 1572.5 -7490 1577.5 -7485 {}
L 2 1572.5 -7490 1577.5 -7495 {}
L 2 1850 -7490 1870 -7490 {}
L 2 1870 -7500 1870 -7480 {}
L 2 1700 -7525 1700 -7520 {}
L 2 1700 -7520 1700 -7400 {}
L 2 1730 -7360 1760 -7360 {}
L 2 1820 -7360 1850 -7360 {}
L 2 1590 -7270 1670 -7270 {}
L 2 1590 -7600 1610 -7600 {}
L 2 1670 -7600 1850 -7600 {}
L 2 1590 -7360 1700 -7360 {}
L 2 1590 -7360 1590 -7270 {}
L 2 1590 -7600 1590 -7360 {}
L 2 530 -7170 770 -7170 {}
L 2 755 -7050 755 -6990 {}
L 2 755 -7040 770 -7040 {}
L 2 770 -7050 770 -7040 {}
L 2 755 -7000 770 -7000 {}
L 2 770 -7000 770 -6990 {}
L 2 745 -7035 745 -7005 {}
L 2 745 -7020 745 -7015 {}
L 2 730 -7020 737.5 -7020 {}
L 2 730 -7020 745 -7020 {}
L 2 760 -7020 770 -7020 {}
L 2 755 -7025 760 -7020 {}
L 2 755 -7015 760 -7020 {}
L 2 770 -7090 770 -7080 {}
L 2 770 -7090 777.5 -7092.5 {}
L 2 762.5 -7097.5 777.5 -7092.5 {}
L 2 762.5 -7097.5 777.5 -7102.5 {}
L 2 762.5 -7107.5 777.5 -7102.5 {}
L 2 762.5 -7107.5 777.5 -7112.5 {}
L 2 762.5 -7117.5 777.5 -7112.5 {}
L 2 762.5 -7117.5 777.5 -7122.5 {}
L 2 762.5 -7127.5 777.5 -7122.5 {}
L 2 762.5 -7127.5 770 -7130 {}
L 2 770 -7140 770 -7130 {}
L 2 772.5 -7132.5 777.5 -7132.5 {}
L 2 775 -7135 775 -7130 {}
L 2 860 -7015 860 -6990 {}
L 2 860 -7050 860 -7025 {}
L 2 850 -7025 870 -7025 {}
L 2 850 -7015 870 -7015 {}
L 2 862.5 -7042.5 867.5 -7042.5 {}
L 2 865 -7045 865 -7040 {}
L 2 532.5 -6982.5 537.5 -6982.5 {}
L 2 535 -6985 535 -6980 {}
L 2 530 -6990 530 -6930 {}
L 2 640 -6910 640 -6897.5 {}
L 2 635 -6897.5 645 -6897.5 {}
L 2 640 -6892.5 645 -6897.5 {}
L 2 635 -6897.5 640 -6892.5 {}
L 2 640 -7190 640 -7170 {}
L 2 630 -7190 650 -7190 {}
L 2 605 -7020 610 -7020 {}
L 2 610 -7020 730 -7020 {}
L 2 770 -7080 770 -7050 {}
L 2 770 -7170 770 -7140 {}
L 2 860 -6990 860 -6910 {}
L 2 530 -6930 530 -6910 {}
L 2 530 -7170 530 -6990 {}
L 2 770 -7020 770 -6910 {}
L 2 770 -6910 860 -6910 {}
L 2 530 -6910 770 -6910 {}
L 2 980 -7170 1220 -7170 {}
L 2 1205 -7050 1205 -6990 {}
L 2 1205 -7040 1220 -7040 {}
L 2 1220 -7050 1220 -7040 {}
L 2 1205 -7000 1220 -7000 {}
L 2 1220 -7000 1220 -6990 {}
L 2 1195 -7035 1195 -7005 {}
L 2 1195 -7020 1195 -7015 {}
L 2 1180 -7020 1187.5 -7020 {}
L 2 1180 -7020 1195 -7020 {}
L 2 1210 -7020 1220 -7020 {}
L 2 1205 -7025 1210 -7020 {}
L 2 1205 -7015 1210 -7020 {}
L 2 1220 -7090 1220 -7080 {}
L 2 1220 -7090 1227.5 -7092.5 {}
L 2 1212.5 -7097.5 1227.5 -7092.5 {}
L 2 1212.5 -7097.5 1227.5 -7102.5 {}
L 2 1212.5 -7107.5 1227.5 -7102.5 {}
L 2 1212.5 -7107.5 1227.5 -7112.5 {}
L 2 1212.5 -7117.5 1227.5 -7112.5 {}
L 2 1212.5 -7117.5 1227.5 -7122.5 {}
L 2 1212.5 -7127.5 1227.5 -7122.5 {}
L 2 1212.5 -7127.5 1220 -7130 {}
L 2 1220 -7140 1220 -7130 {}
L 2 1222.5 -7132.5 1227.5 -7132.5 {}
L 2 1225 -7135 1225 -7130 {}
L 2 1310 -7015 1310 -6990 {}
L 2 1310 -7050 1310 -7025 {}
L 2 1300 -7025 1320 -7025 {}
L 2 1300 -7015 1320 -7015 {}
L 2 1312.5 -7042.5 1317.5 -7042.5 {}
L 2 1315 -7045 1315 -7040 {}
L 2 982.5 -6982.5 987.5 -6982.5 {}
L 2 985 -6985 985 -6980 {}
L 2 980 -6990 980 -6930 {}
L 2 1090 -6910 1090 -6897.5 {}
L 2 1085 -6897.5 1095 -6897.5 {}
L 2 1090 -6892.5 1095 -6897.5 {}
L 2 1085 -6897.5 1090 -6892.5 {}
L 2 1090 -7190 1090 -7170 {}
L 2 1080 -7190 1100 -7190 {}
L 2 1055 -7020 1060 -7020 {}
L 2 1060 -7020 1180 -7020 {}
L 2 1220 -7080 1220 -7050 {}
L 2 1220 -7170 1220 -7140 {}
L 2 1310 -6990 1310 -6910 {}
L 2 980 -6930 980 -6910 {}
L 2 980 -7170 980 -6990 {}
L 2 1220 -7020 1220 -6910 {}
L 2 1220 -6910 1310 -6910 {}
L 2 980 -6910 1220 -6910 {}
L 2 1600 -7170 1840 -7170 {}
L 2 1615 -7050 1615 -6990 {}
L 2 1600 -7040 1615 -7040 {}
L 2 1600 -7050 1600 -7040 {}
L 2 1600 -7000 1615 -7000 {}
L 2 1600 -7000 1600 -6990 {}
L 2 1625 -7035 1625 -7005 {}
L 2 1625 -7020 1625 -7015 {}
L 2 1632.5 -7020 1640 -7020 {}
L 2 1625 -7020 1640 -7020 {}
L 2 1600 -7020 1610 -7020 {}
L 2 1610 -7020 1615 -7025 {}
L 2 1610 -7020 1615 -7015 {}
L 2 1600 -7090 1600 -7080 {}
L 2 1592.5 -7092.5 1600 -7090 {}
L 2 1592.5 -7092.5 1607.5 -7097.5 {}
L 2 1592.5 -7102.5 1607.5 -7097.5 {}
L 2 1592.5 -7102.5 1607.5 -7107.5 {}
L 2 1592.5 -7112.5 1607.5 -7107.5 {}
L 2 1592.5 -7112.5 1607.5 -7117.5 {}
L 2 1592.5 -7122.5 1607.5 -7117.5 {}
L 2 1592.5 -7122.5 1607.5 -7127.5 {}
L 2 1600 -7130 1607.5 -7127.5 {}
L 2 1600 -7140 1600 -7130 {}
L 2 1592.5 -7132.5 1597.5 -7132.5 {}
L 2 1595 -7135 1595 -7130 {}
L 2 1510 -7015 1510 -6990 {}
L 2 1510 -7050 1510 -7025 {}
L 2 1500 -7025 1520 -7025 {}
L 2 1500 -7015 1520 -7015 {}
L 2 1502.5 -7042.5 1507.5 -7042.5 {}
L 2 1505 -7045 1505 -7040 {}
L 2 1832.5 -6982.5 1837.5 -6982.5 {}
L 2 1835 -6985 1835 -6980 {}
L 2 1840 -6990 1840 -6930 {}
L 2 1730 -6910 1730 -6897.5 {}
L 2 1725 -6897.5 1735 -6897.5 {}
L 2 1725 -6897.5 1730 -6892.5 {}
L 2 1730 -6892.5 1735 -6897.5 {}
L 2 1730 -7190 1730 -7170 {}
L 2 1720 -7190 1740 -7190 {}
L 2 1760 -7020 1765 -7020 {}
L 2 1640 -7020 1760 -7020 {}
L 2 1600 -7080 1600 -7050 {}
L 2 1600 -7170 1600 -7140 {}
L 2 1510 -6990 1510 -6910 {}
L 2 1840 -6930 1840 -6910 {}
L 2 1840 -7170 1840 -6990 {}
L 2 1600 -7020 1600 -6910 {}
L 2 1510 -6910 1600 -6910 {}
L 2 1600 -6910 1840 -6910 {}
L 2 610 -6740 610 -6730 {}
L 2 610 -6740 617.5 -6742.5 {}
L 2 602.5 -6747.5 617.5 -6742.5 {}
L 2 602.5 -6747.5 617.5 -6752.5 {}
L 2 602.5 -6757.5 617.5 -6752.5 {}
L 2 602.5 -6757.5 617.5 -6762.5 {}
L 2 602.5 -6767.5 617.5 -6762.5 {}
L 2 602.5 -6767.5 617.5 -6772.5 {}
L 2 602.5 -6777.5 617.5 -6772.5 {}
L 2 602.5 -6777.5 610 -6780 {}
L 2 610 -6790 610 -6780 {}
L 2 612.5 -6782.5 617.5 -6782.5 {}
L 2 615 -6785 615 -6780 {}
L 2 610 -6625 610 -6600 {}
L 2 610 -6660 610 -6635 {}
L 2 600 -6635 620 -6635 {}
L 2 600 -6625 620 -6625 {}
L 2 612.5 -6652.5 617.5 -6652.5 {}
L 2 615 -6655 615 -6650 {}
L 2 610 -6500 610 -6490 {}
L 2 610 -6500 617.5 -6502.5 {}
L 2 602.5 -6507.5 617.5 -6502.5 {}
L 2 602.5 -6507.5 617.5 -6512.5 {}
L 2 602.5 -6517.5 617.5 -6512.5 {}
L 2 602.5 -6517.5 617.5 -6522.5 {}
L 2 602.5 -6527.5 617.5 -6522.5 {}
L 2 602.5 -6527.5 617.5 -6532.5 {}
L 2 602.5 -6537.5 617.5 -6532.5 {}
L 2 602.5 -6537.5 610 -6540 {}
L 2 610 -6550 610 -6540 {}
L 2 612.5 -6542.5 617.5 -6542.5 {}
L 2 615 -6545 615 -6540 {}
L 2 900 -6760 910 -6760 {}
L 2 910 -6760 912.5 -6752.5 {}
L 2 912.5 -6752.5 917.5 -6767.5 {}
L 2 917.5 -6767.5 922.5 -6752.5 {}
L 2 922.5 -6752.5 927.5 -6767.5 {}
L 2 927.5 -6767.5 932.5 -6752.5 {}
L 2 932.5 -6752.5 937.5 -6767.5 {}
L 2 937.5 -6767.5 942.5 -6752.5 {}
L 2 942.5 -6752.5 947.5 -6767.5 {}
L 2 947.5 -6767.5 950 -6760 {}
L 2 950 -6760 960 -6760 {}
L 2 952.5 -6757.5 952.5 -6752.5 {}
L 2 950 -6755 955 -6755 {}
L 2 900 -6630 925 -6630 {}
L 2 935 -6630 960 -6630 {}
L 2 935 -6640 935 -6620 {}
L 2 925 -6640 925 -6620 {}
L 2 952.5 -6627.5 952.5 -6622.5 {}
L 2 950 -6625 955 -6625 {}
L 2 900 -6520 910 -6520 {}
L 2 910 -6520 912.5 -6512.5 {}
L 2 912.5 -6512.5 917.5 -6527.5 {}
L 2 917.5 -6527.5 922.5 -6512.5 {}
L 2 922.5 -6512.5 927.5 -6527.5 {}
L 2 927.5 -6527.5 932.5 -6512.5 {}
L 2 932.5 -6512.5 937.5 -6527.5 {}
L 2 937.5 -6527.5 942.5 -6512.5 {}
L 2 942.5 -6512.5 947.5 -6527.5 {}
L 2 947.5 -6527.5 950 -6520 {}
L 2 950 -6520 960 -6520 {}
L 2 952.5 -6517.5 952.5 -6512.5 {}
L 2 950 -6515 955 -6515 {}
L 2 2360 -8170 2420 -8170 {}
L 2 2420 -8340 2420 -8230 {}
L 2 1440 -260 1510 -260 {}
L 2 1440 -240 1510 -240 {}
L 2 1440 -220 1510 -220 {}
L 2 1440 -200 1510 -200 {}
L 2 2200 -260 2290 -260 {}
L 2 960 -270 1080 -270 {}
L 2 960 -190 1080 -190 {}
L 2 960 -270 960 -190 {}
L 2 1080 -270 1080 -190 {}
L 2 1080 -260 1100 -260 {}
L 2 940 -260 960 -260 {}
L 2 940 -240 960 -240 {}
L 2 940 -220 960 -220 {}
L 2 940 -200 960 -200 {}
L 2 540 -270 660 -270 {}
L 2 540 -190 660 -190 {}
L 2 540 -270 540 -190 {}
L 2 660 -270 660 -190 {}
L 2 660 -260 680 -260 {}
L 2 520 -260 540 -260 {}
L 2 520 -240 540 -240 {}
L 2 520 -220 540 -220 {}
L 2 520 -200 540 -200 {}
L 4 1032.5 -10222.5 1037.5 -10222.5 {}
L 4 1035 -10225 1035 -10220 {}
L 4 1030 -10230 1030 -10170 {}
L 4 1140 -10150 1140 -10137.5 {}
L 4 1135 -10137.5 1145 -10137.5 {}
L 4 1140 -10132.5 1145 -10137.5 {}
L 4 1135 -10137.5 1140 -10132.5 {}
L 4 1140 -10430 1140 -10410 {}
L 4 1130 -10430 1150 -10430 {}
L 4 1572.5 -10222.5 1577.5 -10222.5 {}
L 4 1575 -10225 1575 -10220 {}
L 4 1570 -10230 1570 -10170 {}
L 4 1680 -10150 1680 -10137.5 {}
L 4 1675 -10137.5 1685 -10137.5 {}
L 4 1680 -10132.5 1685 -10137.5 {}
L 4 1675 -10137.5 1680 -10132.5 {}
L 4 1680 -10430 1680 -10410 {}
L 4 1670 -10430 1690 -10430 {}
L 4 502.5 -10222.5 507.5 -10222.5 {}
L 4 505 -10225 505 -10220 {}
L 4 500 -10230 500 -10170 {}
L 4 610 -10150 610 -10137.5 {}
L 4 605 -10137.5 615 -10137.5 {}
L 4 610 -10132.5 615 -10137.5 {}
L 4 605 -10137.5 610 -10132.5 {}
L 4 610 -10430 610 -10410 {}
L 4 600 -10430 620 -10430 {}
L 4 725 -9830 725 -9770 {}
L 4 725 -9820 740 -9820 {}
L 4 740 -9830 740 -9820 {}
L 4 725 -9780 740 -9780 {}
L 4 740 -9780 740 -9770 {}
L 4 715 -9815 715 -9785 {}
L 4 715 -9800 715 -9795 {}
L 4 700 -9800 707.5 -9800 {}
L 4 700 -9800 715 -9800 {}
L 4 730 -9800 740 -9800 {}
L 4 725 -9805 730 -9800 {}
L 4 725 -9795 730 -9800 {}
L 4 740 -9870 740 -9860 {}
L 4 740 -9870 747.5 -9872.5 {}
L 4 732.5 -9877.5 747.5 -9872.5 {}
L 4 732.5 -9877.5 747.5 -9882.5 {}
L 4 732.5 -9887.5 747.5 -9882.5 {}
L 4 732.5 -9887.5 747.5 -9892.5 {}
L 4 732.5 -9897.5 747.5 -9892.5 {}
L 4 732.5 -9897.5 747.5 -9902.5 {}
L 4 732.5 -9907.5 747.5 -9902.5 {}
L 4 732.5 -9907.5 740 -9910 {}
L 4 740 -9920 740 -9910 {}
L 4 742.5 -9912.5 747.5 -9912.5 {}
L 4 745 -9915 745 -9910 {}
L 4 830 -9795 830 -9770 {}
L 4 830 -9830 830 -9805 {}
L 4 820 -9805 840 -9805 {}
L 4 820 -9795 840 -9795 {}
L 4 832.5 -9822.5 837.5 -9822.5 {}
L 4 835 -9825 835 -9820 {}
L 4 502.5 -9762.5 507.5 -9762.5 {}
L 4 505 -9765 505 -9760 {}
L 4 500 -9770 500 -9710 {}
L 4 610 -9690 610 -9677.5 {}
L 4 605 -9677.5 615 -9677.5 {}
L 4 610 -9672.5 615 -9677.5 {}
L 4 605 -9677.5 610 -9672.5 {}
L 4 610 -9970 610 -9950 {}
L 4 600 -9970 620 -9970 {}
L 4 1265 -9830 1265 -9770 {}
L 4 1265 -9820 1280 -9820 {}
L 4 1280 -9830 1280 -9820 {}
L 4 1265 -9780 1280 -9780 {}
L 4 1280 -9780 1280 -9770 {}
L 4 1255 -9815 1255 -9785 {}
L 4 1255 -9800 1255 -9795 {}
L 4 1240 -9800 1247.5 -9800 {}
L 4 1240 -9800 1255 -9800 {}
L 4 1270 -9800 1280 -9800 {}
L 4 1265 -9805 1270 -9800 {}
L 4 1265 -9795 1270 -9800 {}
L 4 1370 -9795 1370 -9770 {}
L 4 1370 -9830 1370 -9805 {}
L 4 1360 -9805 1380 -9805 {}
L 4 1360 -9795 1380 -9795 {}
L 4 1372.5 -9822.5 1377.5 -9822.5 {}
L 4 1375 -9825 1375 -9820 {}
L 4 1042.5 -9762.5 1047.5 -9762.5 {}
L 4 1045 -9765 1045 -9760 {}
L 4 1040 -9770 1040 -9710 {}
L 4 1150 -9690 1150 -9677.5 {}
L 4 1145 -9677.5 1155 -9677.5 {}
L 4 1150 -9672.5 1155 -9677.5 {}
L 4 1145 -9677.5 1150 -9672.5 {}
L 4 1150 -9970 1150 -9950 {}
L 4 1140 -9970 1160 -9970 {}
L 4 725 -6240 725 -6180 {}
L 4 725 -6230 740 -6230 {}
L 4 740 -6240 740 -6230 {}
L 4 725 -6190 740 -6190 {}
L 4 740 -6190 740 -6180 {}
L 4 715 -6225 715 -6195 {}
L 4 715 -6210 715 -6205 {}
L 4 700 -6210 707.5 -6210 {}
L 4 700 -6210 715 -6210 {}
L 4 730 -6210 740 -6210 {}
L 4 725 -6215 730 -6210 {}
L 4 725 -6205 730 -6210 {}
L 4 740 -6280 740 -6270 {}
L 4 740 -6280 747.5 -6282.5 {}
L 4 732.5 -6287.5 747.5 -6282.5 {}
L 4 732.5 -6287.5 747.5 -6292.5 {}
L 4 732.5 -6297.5 747.5 -6292.5 {}
L 4 732.5 -6297.5 747.5 -6302.5 {}
L 4 732.5 -6307.5 747.5 -6302.5 {}
L 4 732.5 -6307.5 747.5 -6312.5 {}
L 4 732.5 -6317.5 747.5 -6312.5 {}
L 4 732.5 -6317.5 740 -6320 {}
L 4 740 -6330 740 -6320 {}
L 4 742.5 -6322.5 747.5 -6322.5 {}
L 4 745 -6325 745 -6320 {}
L 4 830 -6205 830 -6180 {}
L 4 830 -6240 830 -6215 {}
L 4 820 -6215 840 -6215 {}
L 4 820 -6205 840 -6205 {}
L 4 832.5 -6232.5 837.5 -6232.5 {}
L 4 835 -6235 835 -6230 {}
L 4 502.5 -6172.5 507.5 -6172.5 {}
L 4 505 -6175 505 -6170 {}
L 4 500 -6180 500 -6120 {}
L 4 610 -6100 610 -6087.5 {}
L 4 605 -6087.5 615 -6087.5 {}
L 4 610 -6082.5 615 -6087.5 {}
L 4 605 -6087.5 610 -6082.5 {}
L 4 610 -6380 610 -6360 {}
L 4 600 -6380 620 -6380 {}
L 4 1265 -6240 1265 -6180 {}
L 4 1265 -6230 1280 -6230 {}
L 4 1280 -6240 1280 -6230 {}
L 4 1265 -6190 1280 -6190 {}
L 4 1280 -6190 1280 -6180 {}
L 4 1255 -6225 1255 -6195 {}
L 4 1255 -6210 1255 -6205 {}
L 4 1240 -6210 1247.5 -6210 {}
L 4 1240 -6210 1255 -6210 {}
L 4 1270 -6210 1280 -6210 {}
L 4 1265 -6215 1270 -6210 {}
L 4 1265 -6205 1270 -6210 {}
L 4 1370 -6205 1370 -6180 {}
L 4 1370 -6240 1370 -6215 {}
L 4 1360 -6215 1380 -6215 {}
L 4 1360 -6205 1380 -6205 {}
L 4 1372.5 -6232.5 1377.5 -6232.5 {}
L 4 1375 -6235 1375 -6230 {}
L 4 1042.5 -6172.5 1047.5 -6172.5 {}
L 4 1045 -6175 1045 -6170 {}
L 4 1040 -6180 1040 -6120 {}
L 4 1150 -6100 1150 -6087.5 {}
L 4 1145 -6087.5 1155 -6087.5 {}
L 4 1150 -6082.5 1155 -6087.5 {}
L 4 1145 -6087.5 1150 -6082.5 {}
L 4 1150 -6380 1150 -6360 {}
L 4 1140 -6380 1160 -6380 {}
L 4 725 -5840 725 -5780 {}
L 4 725 -5830 740 -5830 {}
L 4 740 -5840 740 -5830 {}
L 4 725 -5790 740 -5790 {}
L 4 740 -5790 740 -5780 {}
L 4 715 -5825 715 -5795 {}
L 4 715 -5810 715 -5805 {}
L 4 700 -5810 707.5 -5810 {}
L 4 700 -5810 715 -5810 {}
L 4 730 -5810 740 -5810 {}
L 4 725 -5815 730 -5810 {}
L 4 725 -5805 730 -5810 {}
L 4 740 -5880 740 -5870 {}
L 4 740 -5880 747.5 -5882.5 {}
L 4 732.5 -5887.5 747.5 -5882.5 {}
L 4 732.5 -5887.5 747.5 -5892.5 {}
L 4 732.5 -5897.5 747.5 -5892.5 {}
L 4 732.5 -5897.5 747.5 -5902.5 {}
L 4 732.5 -5907.5 747.5 -5902.5 {}
L 4 732.5 -5907.5 747.5 -5912.5 {}
L 4 732.5 -5917.5 747.5 -5912.5 {}
L 4 732.5 -5917.5 740 -5920 {}
L 4 740 -5930 740 -5920 {}
L 4 742.5 -5922.5 747.5 -5922.5 {}
L 4 745 -5925 745 -5920 {}
L 4 830 -5805 830 -5780 {}
L 4 830 -5840 830 -5815 {}
L 4 820 -5815 840 -5815 {}
L 4 820 -5805 840 -5805 {}
L 4 832.5 -5832.5 837.5 -5832.5 {}
L 4 835 -5835 835 -5830 {}
L 4 502.5 -5772.5 507.5 -5772.5 {}
L 4 505 -5775 505 -5770 {}
L 4 500 -5780 500 -5720 {}
L 4 610 -5700 610 -5687.5 {}
L 4 605 -5687.5 615 -5687.5 {}
L 4 610 -5682.5 615 -5687.5 {}
L 4 605 -5687.5 610 -5682.5 {}
L 4 610 -5980 610 -5960 {}
L 4 600 -5980 620 -5980 {}
L 4 1265 -5840 1265 -5780 {}
L 4 1265 -5830 1280 -5830 {}
L 4 1280 -5840 1280 -5830 {}
L 4 1265 -5790 1280 -5790 {}
L 4 1280 -5790 1280 -5780 {}
L 4 1255 -5825 1255 -5795 {}
L 4 1255 -5810 1255 -5805 {}
L 4 1240 -5810 1247.5 -5810 {}
L 4 1240 -5810 1255 -5810 {}
L 4 1270 -5810 1280 -5810 {}
L 4 1265 -5815 1270 -5810 {}
L 4 1265 -5805 1270 -5810 {}
L 4 1370 -5805 1370 -5780 {}
L 4 1370 -5840 1370 -5815 {}
L 4 1360 -5815 1380 -5815 {}
L 4 1360 -5805 1380 -5805 {}
L 4 1372.5 -5832.5 1377.5 -5832.5 {}
L 4 1375 -5835 1375 -5830 {}
L 4 1042.5 -5772.5 1047.5 -5772.5 {}
L 4 1045 -5775 1045 -5770 {}
L 4 1040 -5780 1040 -5720 {}
L 4 1150 -5700 1150 -5687.5 {}
L 4 1145 -5687.5 1155 -5687.5 {}
L 4 1150 -5682.5 1155 -5687.5 {}
L 4 1145 -5687.5 1150 -5682.5 {}
L 4 1150 -5980 1150 -5960 {}
L 4 1140 -5980 1160 -5980 {}
L 4 502.5 -5332.5 507.5 -5332.5 {}
L 4 505 -5335 505 -5330 {}
L 4 500 -5340 500 -5280 {}
L 4 610 -5260 610 -5247.5 {}
L 4 605 -5247.5 615 -5247.5 {}
L 4 610 -5242.5 615 -5247.5 {}
L 4 605 -5247.5 610 -5242.5 {}
L 4 610 -5540 610 -5520 {}
L 4 600 -5540 620 -5540 {}
L 4 1692.5 -5332.5 1697.5 -5332.5 {}
L 4 1695 -5335 1695 -5330 {}
L 4 1690 -5340 1690 -5280 {}
L 4 1800 -5260 1800 -5247.5 {}
L 4 1795 -5247.5 1805 -5247.5 {}
L 4 1800 -5242.5 1805 -5247.5 {}
L 4 1795 -5247.5 1800 -5242.5 {}
L 4 1800 -5540 1800 -5520 {}
L 4 1790 -5540 1810 -5540 {}
L 4 1062.5 -5332.5 1067.5 -5332.5 {}
L 4 1065 -5335 1065 -5330 {}
L 4 1060 -5340 1060 -5280 {}
L 4 1170 -5260 1170 -5247.5 {}
L 4 1165 -5247.5 1175 -5247.5 {}
L 4 1170 -5242.5 1175 -5247.5 {}
L 4 1165 -5247.5 1170 -5242.5 {}
L 4 1170 -5540 1170 -5520 {}
L 4 1160 -5540 1180 -5540 {}
L 4 1032.5 -9392.5 1037.5 -9392.5 {}
L 4 1035 -9395 1035 -9390 {}
L 4 1030 -9400 1030 -9340 {}
L 4 1140 -9320 1140 -9307.5 {}
L 4 1135 -9307.5 1145 -9307.5 {}
L 4 1140 -9302.5 1145 -9307.5 {}
L 4 1135 -9307.5 1140 -9302.5 {}
L 4 1140 -9600 1140 -9580 {}
L 4 1130 -9600 1150 -9600 {}
L 4 502.5 -9392.5 507.5 -9392.5 {}
L 4 505 -9395 505 -9390 {}
L 4 500 -9400 500 -9340 {}
L 4 610 -9320 610 -9307.5 {}
L 4 605 -9307.5 615 -9307.5 {}
L 4 610 -9302.5 615 -9307.5 {}
L 4 605 -9307.5 610 -9302.5 {}
L 4 610 -9600 610 -9580 {}
L 4 600 -9600 620 -9600 {}
L 4 1755 -9460 1755 -9400 {}
L 4 1755 -9450 1770 -9450 {}
L 4 1770 -9460 1770 -9450 {}
L 4 1755 -9410 1770 -9410 {}
L 4 1770 -9410 1770 -9400 {}
L 4 1745 -9445 1745 -9415 {}
L 4 1745 -9430 1745 -9425 {}
L 4 1730 -9430 1737.5 -9430 {}
L 4 1730 -9430 1745 -9430 {}
L 4 1760 -9430 1770 -9430 {}
L 4 1755 -9435 1760 -9430 {}
L 4 1755 -9425 1760 -9430 {}
L 4 1770 -9500 1770 -9490 {}
L 4 1770 -9500 1777.5 -9502.5 {}
L 4 1762.5 -9507.5 1777.5 -9502.5 {}
L 4 1762.5 -9507.5 1777.5 -9512.5 {}
L 4 1762.5 -9517.5 1777.5 -9512.5 {}
L 4 1762.5 -9517.5 1777.5 -9522.5 {}
L 4 1762.5 -9527.5 1777.5 -9522.5 {}
L 4 1762.5 -9527.5 1777.5 -9532.5 {}
L 4 1762.5 -9537.5 1777.5 -9532.5 {}
L 4 1762.5 -9537.5 1770 -9540 {}
L 4 1770 -9550 1770 -9540 {}
L 4 1772.5 -9542.5 1777.5 -9542.5 {}
L 4 1775 -9545 1775 -9540 {}
L 4 1860 -9425 1860 -9400 {}
L 4 1860 -9460 1860 -9435 {}
L 4 1850 -9435 1870 -9435 {}
L 4 1850 -9425 1870 -9425 {}
L 4 1862.5 -9452.5 1867.5 -9452.5 {}
L 4 1865 -9455 1865 -9450 {}
L 4 1532.5 -9392.5 1537.5 -9392.5 {}
L 4 1535 -9395 1535 -9390 {}
L 4 1530 -9400 1530 -9340 {}
L 4 1640 -9320 1640 -9307.5 {}
L 4 1635 -9307.5 1645 -9307.5 {}
L 4 1640 -9302.5 1645 -9307.5 {}
L 4 1635 -9307.5 1640 -9302.5 {}
L 4 1640 -9600 1640 -9580 {}
L 4 1630 -9600 1650 -9600 {}
L 4 1680 -10620 1680 -10607.5 {}
L 4 1675 -10607.5 1685 -10607.5 {}
L 4 1680 -10602.5 1685 -10607.5 {}
L 4 1675 -10607.5 1680 -10602.5 {}
L 4 1680 -10900 1680 -10880 {}
L 4 1670 -10900 1690 -10900 {}
L 4 447.5 -10692.5 452.5 -10692.5 {}
L 4 450 -10695 450 -10690 {}
L 4 445 -10700 445 -10640 {}
L 4 555 -10620 555 -10607.5 {}
L 4 550 -10607.5 560 -10607.5 {}
L 4 555 -10602.5 560 -10607.5 {}
L 4 550 -10607.5 555 -10602.5 {}
L 4 555 -10900 555 -10880 {}
L 4 545 -10900 565 -10900 {}
L 4 2140 -10620 2140 -10607.5 {}
L 4 2135 -10607.5 2145 -10607.5 {}
L 4 2140 -10602.5 2145 -10607.5 {}
L 4 2135 -10607.5 2140 -10602.5 {}
L 4 2140 -10900 2140 -10880 {}
L 4 2130 -10900 2150 -10900 {}
L 4 2360 -10725 2360 -10700 {}
L 4 2360 -10760 2360 -10735 {}
L 4 2350 -10735 2370 -10735 {}
L 4 2350 -10725 2370 -10725 {}
L 4 2362.5 -10752.5 2367.5 -10752.5 {}
L 4 2365 -10755 2365 -10750 {}
L 4 745 -8620 745 -8560 {}
L 4 745 -8610 760 -8610 {}
L 4 760 -8620 760 -8610 {}
L 4 745 -8570 760 -8570 {}
L 4 760 -8570 760 -8560 {}
L 4 735 -8605 735 -8575 {}
L 4 735 -8590 735 -8585 {}
L 4 720 -8590 727.5 -8590 {}
L 4 720 -8590 735 -8590 {}
L 4 750 -8590 760 -8590 {}
L 4 745 -8595 750 -8590 {}
L 4 745 -8585 750 -8590 {}
L 4 760 -8660 760 -8650 {}
L 4 760 -8660 767.5 -8662.5 {}
L 4 752.5 -8667.5 767.5 -8662.5 {}
L 4 752.5 -8667.5 767.5 -8672.5 {}
L 4 752.5 -8677.5 767.5 -8672.5 {}
L 4 752.5 -8677.5 767.5 -8682.5 {}
L 4 752.5 -8687.5 767.5 -8682.5 {}
L 4 752.5 -8687.5 767.5 -8692.5 {}
L 4 752.5 -8697.5 767.5 -8692.5 {}
L 4 752.5 -8697.5 760 -8700 {}
L 4 760 -8710 760 -8700 {}
L 4 762.5 -8702.5 767.5 -8702.5 {}
L 4 765 -8705 765 -8700 {}
L 4 850 -8585 850 -8560 {}
L 4 850 -8620 850 -8595 {}
L 4 840 -8595 860 -8595 {}
L 4 840 -8585 860 -8585 {}
L 4 852.5 -8612.5 857.5 -8612.5 {}
L 4 855 -8615 855 -8610 {}
L 4 522.5 -8552.5 527.5 -8552.5 {}
L 4 525 -8555 525 -8550 {}
L 4 520 -8560 520 -8500 {}
L 4 630 -8480 630 -8467.5 {}
L 4 625 -8467.5 635 -8467.5 {}
L 4 630 -8462.5 635 -8467.5 {}
L 4 625 -8467.5 630 -8462.5 {}
L 4 630 -8760 630 -8740 {}
L 4 620 -8760 640 -8760 {}
L 4 1285 -8620 1285 -8560 {}
L 4 1285 -8610 1300 -8610 {}
L 4 1300 -8620 1300 -8610 {}
L 4 1285 -8570 1300 -8570 {}
L 4 1300 -8570 1300 -8560 {}
L 4 1275 -8605 1275 -8575 {}
L 4 1275 -8590 1275 -8585 {}
L 4 1260 -8590 1267.5 -8590 {}
L 4 1260 -8590 1275 -8590 {}
L 4 1290 -8590 1300 -8590 {}
L 4 1285 -8595 1290 -8590 {}
L 4 1285 -8585 1290 -8590 {}
L 4 1300 -8660 1300 -8650 {}
L 4 1300 -8660 1307.5 -8662.5 {}
L 4 1292.5 -8667.5 1307.5 -8662.5 {}
L 4 1292.5 -8667.5 1307.5 -8672.5 {}
L 4 1292.5 -8677.5 1307.5 -8672.5 {}
L 4 1292.5 -8677.5 1307.5 -8682.5 {}
L 4 1292.5 -8687.5 1307.5 -8682.5 {}
L 4 1292.5 -8687.5 1307.5 -8692.5 {}
L 4 1292.5 -8697.5 1307.5 -8692.5 {}
L 4 1292.5 -8697.5 1300 -8700 {}
L 4 1300 -8710 1300 -8700 {}
L 4 1302.5 -8702.5 1307.5 -8702.5 {}
L 4 1305 -8705 1305 -8700 {}
L 4 1390 -8585 1390 -8560 {}
L 4 1390 -8620 1390 -8595 {}
L 4 1380 -8595 1400 -8595 {}
L 4 1380 -8585 1400 -8585 {}
L 4 1392.5 -8612.5 1397.5 -8612.5 {}
L 4 1395 -8615 1395 -8610 {}
L 4 1062.5 -8552.5 1067.5 -8552.5 {}
L 4 1065 -8555 1065 -8550 {}
L 4 1060 -8560 1060 -8500 {}
L 4 1170 -8480 1170 -8467.5 {}
L 4 1165 -8467.5 1175 -8467.5 {}
L 4 1170 -8462.5 1175 -8467.5 {}
L 4 1165 -8467.5 1170 -8462.5 {}
L 4 1170 -8760 1170 -8740 {}
L 4 1160 -8760 1180 -8760 {}
L 4 2415 -8620 2415 -8560 {}
L 4 2415 -8610 2430 -8610 {}
L 4 2430 -8620 2430 -8610 {}
L 4 2415 -8570 2430 -8570 {}
L 4 2430 -8570 2430 -8560 {}
L 4 2405 -8605 2405 -8575 {}
L 4 2405 -8590 2405 -8585 {}
L 4 2390 -8590 2397.5 -8590 {}
L 4 2390 -8590 2405 -8590 {}
L 4 2420 -8590 2430 -8590 {}
L 4 2415 -8595 2420 -8590 {}
L 4 2415 -8585 2420 -8590 {}
L 4 2430 -8660 2430 -8650 {}
L 4 2430 -8660 2437.5 -8662.5 {}
L 4 2422.5 -8667.5 2437.5 -8662.5 {}
L 4 2422.5 -8667.5 2437.5 -8672.5 {}
L 4 2422.5 -8677.5 2437.5 -8672.5 {}
L 4 2422.5 -8677.5 2437.5 -8682.5 {}
L 4 2422.5 -8687.5 2437.5 -8682.5 {}
L 4 2422.5 -8687.5 2437.5 -8692.5 {}
L 4 2422.5 -8697.5 2437.5 -8692.5 {}
L 4 2422.5 -8697.5 2430 -8700 {}
L 4 2430 -8710 2430 -8700 {}
L 4 2432.5 -8702.5 2437.5 -8702.5 {}
L 4 2435 -8705 2435 -8700 {}
L 4 2520 -8585 2520 -8560 {}
L 4 2520 -8620 2520 -8595 {}
L 4 2510 -8595 2530 -8595 {}
L 4 2510 -8585 2530 -8585 {}
L 4 2522.5 -8612.5 2527.5 -8612.5 {}
L 4 2525 -8615 2525 -8610 {}
L 4 2192.5 -8552.5 2197.5 -8552.5 {}
L 4 2195 -8555 2195 -8550 {}
L 4 2190 -8560 2190 -8500 {}
L 4 2300 -8480 2300 -8467.5 {}
L 4 2295 -8467.5 2305 -8467.5 {}
L 4 2300 -8462.5 2305 -8467.5 {}
L 4 2295 -8467.5 2300 -8462.5 {}
L 4 2300 -8760 2300 -8740 {}
L 4 2290 -8760 2310 -8760 {}
L 4 820 -4480 820 -4470 {}
L 4 820 -4480 827.5 -4482.5 {}
L 4 812.5 -4487.5 827.5 -4482.5 {}
L 4 812.5 -4487.5 827.5 -4492.5 {}
L 4 812.5 -4497.5 827.5 -4492.5 {}
L 4 812.5 -4497.5 827.5 -4502.5 {}
L 4 812.5 -4507.5 827.5 -4502.5 {}
L 4 812.5 -4507.5 827.5 -4512.5 {}
L 4 812.5 -4517.5 827.5 -4512.5 {}
L 4 812.5 -4517.5 820 -4520 {}
L 4 820 -4530 820 -4520 {}
L 4 822.5 -4522.5 827.5 -4522.5 {}
L 4 825 -4525 825 -4520 {}
L 4 820 -4420 820 -4410 {}
L 4 820 -4420 827.5 -4422.5 {}
L 4 812.5 -4427.5 827.5 -4422.5 {}
L 4 812.5 -4427.5 827.5 -4432.5 {}
L 4 812.5 -4437.5 827.5 -4432.5 {}
L 4 812.5 -4437.5 827.5 -4442.5 {}
L 4 812.5 -4447.5 827.5 -4442.5 {}
L 4 812.5 -4447.5 827.5 -4452.5 {}
L 4 812.5 -4457.5 827.5 -4452.5 {}
L 4 812.5 -4457.5 820 -4460 {}
L 4 820 -4470 820 -4460 {}
L 4 822.5 -4462.5 827.5 -4462.5 {}
L 4 825 -4465 825 -4460 {}
L 4 1360 -4420 1360 -4410 {}
L 4 1360 -4420 1367.5 -4422.5 {}
L 4 1352.5 -4427.5 1367.5 -4422.5 {}
L 4 1352.5 -4427.5 1367.5 -4432.5 {}
L 4 1352.5 -4437.5 1367.5 -4432.5 {}
L 4 1352.5 -4437.5 1367.5 -4442.5 {}
L 4 1352.5 -4447.5 1367.5 -4442.5 {}
L 4 1352.5 -4447.5 1367.5 -4452.5 {}
L 4 1352.5 -4457.5 1367.5 -4452.5 {}
L 4 1352.5 -4457.5 1360 -4460 {}
L 4 1360 -4470 1360 -4460 {}
L 4 1362.5 -4462.5 1367.5 -4462.5 {}
L 4 1365 -4465 1365 -4460 {}
L 4 1900 -4520 1900 -4510 {}
L 4 1900 -4520 1907.5 -4522.5 {}
L 4 1892.5 -4527.5 1907.5 -4522.5 {}
L 4 1892.5 -4527.5 1907.5 -4532.5 {}
L 4 1892.5 -4537.5 1907.5 -4532.5 {}
L 4 1892.5 -4537.5 1907.5 -4542.5 {}
L 4 1892.5 -4547.5 1907.5 -4542.5 {}
L 4 1892.5 -4547.5 1907.5 -4552.5 {}
L 4 1892.5 -4557.5 1907.5 -4552.5 {}
L 4 1892.5 -4557.5 1900 -4560 {}
L 4 1900 -4570 1900 -4560 {}
L 4 1902.5 -4562.5 1907.5 -4562.5 {}
L 4 1905 -4565 1905 -4560 {}
L 4 1900 -4420 1900 -4410 {}
L 4 1900 -4420 1907.5 -4422.5 {}
L 4 1892.5 -4427.5 1907.5 -4422.5 {}
L 4 1892.5 -4427.5 1907.5 -4432.5 {}
L 4 1892.5 -4437.5 1907.5 -4432.5 {}
L 4 1892.5 -4437.5 1907.5 -4442.5 {}
L 4 1892.5 -4447.5 1907.5 -4442.5 {}
L 4 1892.5 -4447.5 1907.5 -4452.5 {}
L 4 1892.5 -4457.5 1907.5 -4452.5 {}
L 4 1892.5 -4457.5 1900 -4460 {}
L 4 1900 -4470 1900 -4460 {}
L 4 1902.5 -4462.5 1907.5 -4462.5 {}
L 4 1905 -4465 1905 -4460 {}
L 4 710 -3650 710 -3640 {}
L 4 710 -3650 717.5 -3652.5 {}
L 4 702.5 -3657.5 717.5 -3652.5 {}
L 4 702.5 -3657.5 717.5 -3662.5 {}
L 4 702.5 -3667.5 717.5 -3662.5 {}
L 4 702.5 -3667.5 717.5 -3672.5 {}
L 4 702.5 -3677.5 717.5 -3672.5 {}
L 4 702.5 -3677.5 717.5 -3682.5 {}
L 4 702.5 -3687.5 717.5 -3682.5 {}
L 4 702.5 -3687.5 710 -3690 {}
L 4 710 -3700 710 -3690 {}
L 4 712.5 -3692.5 717.5 -3692.5 {}
L 4 715 -3695 715 -3690 {}
L 4 820 -3650 820 -3640 {}
L 4 820 -3650 827.5 -3652.5 {}
L 4 812.5 -3657.5 827.5 -3652.5 {}
L 4 812.5 -3657.5 827.5 -3662.5 {}
L 4 812.5 -3667.5 827.5 -3662.5 {}
L 4 812.5 -3667.5 827.5 -3672.5 {}
L 4 812.5 -3677.5 827.5 -3672.5 {}
L 4 812.5 -3677.5 827.5 -3682.5 {}
L 4 812.5 -3687.5 827.5 -3682.5 {}
L 4 812.5 -3687.5 820 -3690 {}
L 4 820 -3700 820 -3690 {}
L 4 822.5 -3692.5 827.5 -3692.5 {}
L 4 825 -3695 825 -3690 {}
L 4 930 -3650 930 -3640 {}
L 4 930 -3650 937.5 -3652.5 {}
L 4 922.5 -3657.5 937.5 -3652.5 {}
L 4 922.5 -3657.5 937.5 -3662.5 {}
L 4 922.5 -3667.5 937.5 -3662.5 {}
L 4 922.5 -3667.5 937.5 -3672.5 {}
L 4 922.5 -3677.5 937.5 -3672.5 {}
L 4 922.5 -3677.5 937.5 -3682.5 {}
L 4 922.5 -3687.5 937.5 -3682.5 {}
L 4 922.5 -3687.5 930 -3690 {}
L 4 930 -3700 930 -3690 {}
L 4 932.5 -3692.5 937.5 -3692.5 {}
L 4 935 -3695 935 -3690 {}
L 4 1250 -3650 1250 -3640 {}
L 4 1250 -3650 1257.5 -3652.5 {}
L 4 1242.5 -3657.5 1257.5 -3652.5 {}
L 4 1242.5 -3657.5 1257.5 -3662.5 {}
L 4 1242.5 -3667.5 1257.5 -3662.5 {}
L 4 1242.5 -3667.5 1257.5 -3672.5 {}
L 4 1242.5 -3677.5 1257.5 -3672.5 {}
L 4 1242.5 -3677.5 1257.5 -3682.5 {}
L 4 1242.5 -3687.5 1257.5 -3682.5 {}
L 4 1242.5 -3687.5 1250 -3690 {}
L 4 1250 -3700 1250 -3690 {}
L 4 1252.5 -3692.5 1257.5 -3692.5 {}
L 4 1255 -3695 1255 -3690 {}
L 4 1360 -3650 1360 -3640 {}
L 4 1360 -3650 1367.5 -3652.5 {}
L 4 1352.5 -3657.5 1367.5 -3652.5 {}
L 4 1352.5 -3657.5 1367.5 -3662.5 {}
L 4 1352.5 -3667.5 1367.5 -3662.5 {}
L 4 1352.5 -3667.5 1367.5 -3672.5 {}
L 4 1352.5 -3677.5 1367.5 -3672.5 {}
L 4 1352.5 -3677.5 1367.5 -3682.5 {}
L 4 1352.5 -3687.5 1367.5 -3682.5 {}
L 4 1352.5 -3687.5 1360 -3690 {}
L 4 1360 -3700 1360 -3690 {}
L 4 1362.5 -3692.5 1367.5 -3692.5 {}
L 4 1365 -3695 1365 -3690 {}
L 4 1470 -3650 1470 -3640 {}
L 4 1470 -3650 1477.5 -3652.5 {}
L 4 1462.5 -3657.5 1477.5 -3652.5 {}
L 4 1462.5 -3657.5 1477.5 -3662.5 {}
L 4 1462.5 -3667.5 1477.5 -3662.5 {}
L 4 1462.5 -3667.5 1477.5 -3672.5 {}
L 4 1462.5 -3677.5 1477.5 -3672.5 {}
L 4 1462.5 -3677.5 1477.5 -3682.5 {}
L 4 1462.5 -3687.5 1477.5 -3682.5 {}
L 4 1462.5 -3687.5 1470 -3690 {}
L 4 1470 -3700 1470 -3690 {}
L 4 1472.5 -3692.5 1477.5 -3692.5 {}
L 4 1475 -3695 1475 -3690 {}
L 4 1790 -3650 1790 -3640 {}
L 4 1790 -3650 1797.5 -3652.5 {}
L 4 1782.5 -3657.5 1797.5 -3652.5 {}
L 4 1782.5 -3657.5 1797.5 -3662.5 {}
L 4 1782.5 -3667.5 1797.5 -3662.5 {}
L 4 1782.5 -3667.5 1797.5 -3672.5 {}
L 4 1782.5 -3677.5 1797.5 -3672.5 {}
L 4 1782.5 -3677.5 1797.5 -3682.5 {}
L 4 1782.5 -3687.5 1797.5 -3682.5 {}
L 4 1782.5 -3687.5 1790 -3690 {}
L 4 1790 -3700 1790 -3690 {}
L 4 1792.5 -3692.5 1797.5 -3692.5 {}
L 4 1795 -3695 1795 -3690 {}
L 4 1900 -3650 1900 -3640 {}
L 4 1900 -3650 1907.5 -3652.5 {}
L 4 1892.5 -3657.5 1907.5 -3652.5 {}
L 4 1892.5 -3657.5 1907.5 -3662.5 {}
L 4 1892.5 -3667.5 1907.5 -3662.5 {}
L 4 1892.5 -3667.5 1907.5 -3672.5 {}
L 4 1892.5 -3677.5 1907.5 -3672.5 {}
L 4 1892.5 -3677.5 1907.5 -3682.5 {}
L 4 1892.5 -3687.5 1907.5 -3682.5 {}
L 4 1892.5 -3687.5 1900 -3690 {}
L 4 1900 -3700 1900 -3690 {}
L 4 1902.5 -3692.5 1907.5 -3692.5 {}
L 4 1905 -3695 1905 -3690 {}
L 4 2010 -3650 2010 -3640 {}
L 4 2010 -3650 2017.5 -3652.5 {}
L 4 2002.5 -3657.5 2017.5 -3652.5 {}
L 4 2002.5 -3657.5 2017.5 -3662.5 {}
L 4 2002.5 -3667.5 2017.5 -3662.5 {}
L 4 2002.5 -3667.5 2017.5 -3672.5 {}
L 4 2002.5 -3677.5 2017.5 -3672.5 {}
L 4 2002.5 -3677.5 2017.5 -3682.5 {}
L 4 2002.5 -3687.5 2017.5 -3682.5 {}
L 4 2002.5 -3687.5 2010 -3690 {}
L 4 2010 -3700 2010 -3690 {}
L 4 2012.5 -3692.5 2017.5 -3692.5 {}
L 4 2015 -3695 2015 -3690 {}
L 4 2320 -3650 2320 -3640 {}
L 4 2320 -3650 2327.5 -3652.5 {}
L 4 2312.5 -3657.5 2327.5 -3652.5 {}
L 4 2312.5 -3657.5 2327.5 -3662.5 {}
L 4 2312.5 -3667.5 2327.5 -3662.5 {}
L 4 2312.5 -3667.5 2327.5 -3672.5 {}
L 4 2312.5 -3677.5 2327.5 -3672.5 {}
L 4 2312.5 -3677.5 2327.5 -3682.5 {}
L 4 2312.5 -3687.5 2327.5 -3682.5 {}
L 4 2312.5 -3687.5 2320 -3690 {}
L 4 2320 -3700 2320 -3690 {}
L 4 2322.5 -3692.5 2327.5 -3692.5 {}
L 4 2325 -3695 2325 -3690 {}
L 4 2430 -3650 2430 -3640 {}
L 4 2430 -3650 2437.5 -3652.5 {}
L 4 2422.5 -3657.5 2437.5 -3652.5 {}
L 4 2422.5 -3657.5 2437.5 -3662.5 {}
L 4 2422.5 -3667.5 2437.5 -3662.5 {}
L 4 2422.5 -3667.5 2437.5 -3672.5 {}
L 4 2422.5 -3677.5 2437.5 -3672.5 {}
L 4 2422.5 -3677.5 2437.5 -3682.5 {}
L 4 2422.5 -3687.5 2437.5 -3682.5 {}
L 4 2422.5 -3687.5 2430 -3690 {}
L 4 2430 -3700 2430 -3690 {}
L 4 2432.5 -3692.5 2437.5 -3692.5 {}
L 4 2435 -3695 2435 -3690 {}
L 4 2540 -3650 2540 -3640 {}
L 4 2540 -3650 2547.5 -3652.5 {}
L 4 2532.5 -3657.5 2547.5 -3652.5 {}
L 4 2532.5 -3657.5 2547.5 -3662.5 {}
L 4 2532.5 -3667.5 2547.5 -3662.5 {}
L 4 2532.5 -3667.5 2547.5 -3672.5 {}
L 4 2532.5 -3677.5 2547.5 -3672.5 {}
L 4 2532.5 -3677.5 2547.5 -3682.5 {}
L 4 2532.5 -3687.5 2547.5 -3682.5 {}
L 4 2532.5 -3687.5 2540 -3690 {}
L 4 2540 -3700 2540 -3690 {}
L 4 2542.5 -3692.5 2547.5 -3692.5 {}
L 4 2545 -3695 2545 -3690 {}
L 4 710 -1720 710 -1710 {}
L 4 710 -1720 717.5 -1722.5 {}
L 4 702.5 -1727.5 717.5 -1722.5 {}
L 4 702.5 -1727.5 717.5 -1732.5 {}
L 4 702.5 -1737.5 717.5 -1732.5 {}
L 4 702.5 -1737.5 717.5 -1742.5 {}
L 4 702.5 -1747.5 717.5 -1742.5 {}
L 4 702.5 -1747.5 717.5 -1752.5 {}
L 4 702.5 -1757.5 717.5 -1752.5 {}
L 4 702.5 -1757.5 710 -1760 {}
L 4 710 -1770 710 -1760 {}
L 4 712.5 -1762.5 717.5 -1762.5 {}
L 4 715 -1765 715 -1760 {}
L 4 820 -1720 820 -1710 {}
L 4 820 -1720 827.5 -1722.5 {}
L 4 812.5 -1727.5 827.5 -1722.5 {}
L 4 812.5 -1727.5 827.5 -1732.5 {}
L 4 812.5 -1737.5 827.5 -1732.5 {}
L 4 812.5 -1737.5 827.5 -1742.5 {}
L 4 812.5 -1747.5 827.5 -1742.5 {}
L 4 812.5 -1747.5 827.5 -1752.5 {}
L 4 812.5 -1757.5 827.5 -1752.5 {}
L 4 812.5 -1757.5 820 -1760 {}
L 4 820 -1770 820 -1760 {}
L 4 822.5 -1762.5 827.5 -1762.5 {}
L 4 825 -1765 825 -1760 {}
L 4 930 -1720 930 -1710 {}
L 4 930 -1720 937.5 -1722.5 {}
L 4 922.5 -1727.5 937.5 -1722.5 {}
L 4 922.5 -1727.5 937.5 -1732.5 {}
L 4 922.5 -1737.5 937.5 -1732.5 {}
L 4 922.5 -1737.5 937.5 -1742.5 {}
L 4 922.5 -1747.5 937.5 -1742.5 {}
L 4 922.5 -1747.5 937.5 -1752.5 {}
L 4 922.5 -1757.5 937.5 -1752.5 {}
L 4 922.5 -1757.5 930 -1760 {}
L 4 930 -1770 930 -1760 {}
L 4 932.5 -1762.5 937.5 -1762.5 {}
L 4 935 -1765 935 -1760 {}
L 4 710 -1630 710 -1620 {}
L 4 710 -1630 717.5 -1632.5 {}
L 4 702.5 -1637.5 717.5 -1632.5 {}
L 4 702.5 -1637.5 717.5 -1642.5 {}
L 4 702.5 -1647.5 717.5 -1642.5 {}
L 4 702.5 -1647.5 717.5 -1652.5 {}
L 4 702.5 -1657.5 717.5 -1652.5 {}
L 4 702.5 -1657.5 717.5 -1662.5 {}
L 4 702.5 -1667.5 717.5 -1662.5 {}
L 4 702.5 -1667.5 710 -1670 {}
L 4 710 -1680 710 -1670 {}
L 4 712.5 -1672.5 717.5 -1672.5 {}
L 4 715 -1675 715 -1670 {}
L 4 820 -1630 820 -1620 {}
L 4 820 -1630 827.5 -1632.5 {}
L 4 812.5 -1637.5 827.5 -1632.5 {}
L 4 812.5 -1637.5 827.5 -1642.5 {}
L 4 812.5 -1647.5 827.5 -1642.5 {}
L 4 812.5 -1647.5 827.5 -1652.5 {}
L 4 812.5 -1657.5 827.5 -1652.5 {}
L 4 812.5 -1657.5 827.5 -1662.5 {}
L 4 812.5 -1667.5 827.5 -1662.5 {}
L 4 812.5 -1667.5 820 -1670 {}
L 4 820 -1680 820 -1670 {}
L 4 822.5 -1672.5 827.5 -1672.5 {}
L 4 825 -1675 825 -1670 {}
L 4 930 -1630 930 -1620 {}
L 4 930 -1630 937.5 -1632.5 {}
L 4 922.5 -1637.5 937.5 -1632.5 {}
L 4 922.5 -1637.5 937.5 -1642.5 {}
L 4 922.5 -1647.5 937.5 -1642.5 {}
L 4 922.5 -1647.5 937.5 -1652.5 {}
L 4 922.5 -1657.5 937.5 -1652.5 {}
L 4 922.5 -1657.5 937.5 -1662.5 {}
L 4 922.5 -1667.5 937.5 -1662.5 {}
L 4 922.5 -1667.5 930 -1670 {}
L 4 930 -1680 930 -1670 {}
L 4 932.5 -1672.5 937.5 -1672.5 {}
L 4 935 -1675 935 -1670 {}
L 4 1250 -1630 1250 -1620 {}
L 4 1250 -1630 1257.5 -1632.5 {}
L 4 1242.5 -1637.5 1257.5 -1632.5 {}
L 4 1242.5 -1637.5 1257.5 -1642.5 {}
L 4 1242.5 -1647.5 1257.5 -1642.5 {}
L 4 1242.5 -1647.5 1257.5 -1652.5 {}
L 4 1242.5 -1657.5 1257.5 -1652.5 {}
L 4 1242.5 -1657.5 1257.5 -1662.5 {}
L 4 1242.5 -1667.5 1257.5 -1662.5 {}
L 4 1242.5 -1667.5 1250 -1670 {}
L 4 1250 -1680 1250 -1670 {}
L 4 1252.5 -1672.5 1257.5 -1672.5 {}
L 4 1255 -1675 1255 -1670 {}
L 4 1360 -1630 1360 -1620 {}
L 4 1360 -1630 1367.5 -1632.5 {}
L 4 1352.5 -1637.5 1367.5 -1632.5 {}
L 4 1352.5 -1637.5 1367.5 -1642.5 {}
L 4 1352.5 -1647.5 1367.5 -1642.5 {}
L 4 1352.5 -1647.5 1367.5 -1652.5 {}
L 4 1352.5 -1657.5 1367.5 -1652.5 {}
L 4 1352.5 -1657.5 1367.5 -1662.5 {}
L 4 1352.5 -1667.5 1367.5 -1662.5 {}
L 4 1352.5 -1667.5 1360 -1670 {}
L 4 1360 -1680 1360 -1670 {}
L 4 1362.5 -1672.5 1367.5 -1672.5 {}
L 4 1365 -1675 1365 -1670 {}
L 4 1470 -1630 1470 -1620 {}
L 4 1470 -1630 1477.5 -1632.5 {}
L 4 1462.5 -1637.5 1477.5 -1632.5 {}
L 4 1462.5 -1637.5 1477.5 -1642.5 {}
L 4 1462.5 -1647.5 1477.5 -1642.5 {}
L 4 1462.5 -1647.5 1477.5 -1652.5 {}
L 4 1462.5 -1657.5 1477.5 -1652.5 {}
L 4 1462.5 -1657.5 1477.5 -1662.5 {}
L 4 1462.5 -1667.5 1477.5 -1662.5 {}
L 4 1462.5 -1667.5 1470 -1670 {}
L 4 1470 -1680 1470 -1670 {}
L 4 1472.5 -1672.5 1477.5 -1672.5 {}
L 4 1475 -1675 1475 -1670 {}
L 4 1790 -1630 1790 -1620 {}
L 4 1790 -1630 1797.5 -1632.5 {}
L 4 1782.5 -1637.5 1797.5 -1632.5 {}
L 4 1782.5 -1637.5 1797.5 -1642.5 {}
L 4 1782.5 -1647.5 1797.5 -1642.5 {}
L 4 1782.5 -1647.5 1797.5 -1652.5 {}
L 4 1782.5 -1657.5 1797.5 -1652.5 {}
L 4 1782.5 -1657.5 1797.5 -1662.5 {}
L 4 1782.5 -1667.5 1797.5 -1662.5 {}
L 4 1782.5 -1667.5 1790 -1670 {}
L 4 1790 -1680 1790 -1670 {}
L 4 1792.5 -1672.5 1797.5 -1672.5 {}
L 4 1795 -1675 1795 -1670 {}
L 4 1900 -1630 1900 -1620 {}
L 4 1900 -1630 1907.5 -1632.5 {}
L 4 1892.5 -1637.5 1907.5 -1632.5 {}
L 4 1892.5 -1637.5 1907.5 -1642.5 {}
L 4 1892.5 -1647.5 1907.5 -1642.5 {}
L 4 1892.5 -1647.5 1907.5 -1652.5 {}
L 4 1892.5 -1657.5 1907.5 -1652.5 {}
L 4 1892.5 -1657.5 1907.5 -1662.5 {}
L 4 1892.5 -1667.5 1907.5 -1662.5 {}
L 4 1892.5 -1667.5 1900 -1670 {}
L 4 1900 -1680 1900 -1670 {}
L 4 1902.5 -1672.5 1907.5 -1672.5 {}
L 4 1905 -1675 1905 -1670 {}
L 4 2010 -1630 2010 -1620 {}
L 4 2010 -1630 2017.5 -1632.5 {}
L 4 2002.5 -1637.5 2017.5 -1632.5 {}
L 4 2002.5 -1637.5 2017.5 -1642.5 {}
L 4 2002.5 -1647.5 2017.5 -1642.5 {}
L 4 2002.5 -1647.5 2017.5 -1652.5 {}
L 4 2002.5 -1657.5 2017.5 -1652.5 {}
L 4 2002.5 -1657.5 2017.5 -1662.5 {}
L 4 2002.5 -1667.5 2017.5 -1662.5 {}
L 4 2002.5 -1667.5 2010 -1670 {}
L 4 2010 -1680 2010 -1670 {}
L 4 2012.5 -1672.5 2017.5 -1672.5 {}
L 4 2015 -1675 2015 -1670 {}
L 4 1865 -3440 1865 -3380 {}
L 4 1865 -3430 1880 -3430 {}
L 4 1880 -3440 1880 -3430 {}
L 4 1865 -3390 1880 -3390 {}
L 4 1880 -3390 1880 -3380 {}
L 4 1855 -3425 1855 -3395 {}
L 4 1855 -3410 1855 -3405 {}
L 4 1840 -3410 1847.5 -3410 {}
L 4 1840 -3410 1855 -3410 {}
L 4 1870 -3410 1880 -3410 {}
L 4 1865 -3415 1870 -3410 {}
L 4 1865 -3405 1870 -3410 {}
L 4 1140 -10620 1140 -10607.5 {}
L 4 1135 -10607.5 1145 -10607.5 {}
L 4 1140 -10602.5 1145 -10607.5 {}
L 4 1135 -10607.5 1140 -10602.5 {}
L 4 1140 -10900 1140 -10880 {}
L 4 1130 -10900 1150 -10900 {}
L 4 1032.5 -10692.5 1037.5 -10692.5 {}
L 4 1035 -10695 1035 -10690 {}
L 4 1030 -10700 1030 -10640 {}
L 4 710 -1340 710 -1330 {}
L 4 710 -1340 717.5 -1342.5 {}
L 4 702.5 -1347.5 717.5 -1342.5 {}
L 4 702.5 -1347.5 717.5 -1352.5 {}
L 4 702.5 -1357.5 717.5 -1352.5 {}
L 4 702.5 -1357.5 717.5 -1362.5 {}
L 4 702.5 -1367.5 717.5 -1362.5 {}
L 4 702.5 -1367.5 717.5 -1372.5 {}
L 4 702.5 -1377.5 717.5 -1372.5 {}
L 4 702.5 -1377.5 710 -1380 {}
L 4 710 -1390 710 -1380 {}
L 4 712.5 -1382.5 717.5 -1382.5 {}
L 4 715 -1385 715 -1380 {}
L 4 820 -1340 820 -1330 {}
L 4 820 -1340 827.5 -1342.5 {}
L 4 812.5 -1347.5 827.5 -1342.5 {}
L 4 812.5 -1347.5 827.5 -1352.5 {}
L 4 812.5 -1357.5 827.5 -1352.5 {}
L 4 812.5 -1357.5 827.5 -1362.5 {}
L 4 812.5 -1367.5 827.5 -1362.5 {}
L 4 812.5 -1367.5 827.5 -1372.5 {}
L 4 812.5 -1377.5 827.5 -1372.5 {}
L 4 812.5 -1377.5 820 -1380 {}
L 4 820 -1390 820 -1380 {}
L 4 822.5 -1382.5 827.5 -1382.5 {}
L 4 825 -1385 825 -1380 {}
L 4 930 -1340 930 -1330 {}
L 4 930 -1340 937.5 -1342.5 {}
L 4 922.5 -1347.5 937.5 -1342.5 {}
L 4 922.5 -1347.5 937.5 -1352.5 {}
L 4 922.5 -1357.5 937.5 -1352.5 {}
L 4 922.5 -1357.5 937.5 -1362.5 {}
L 4 922.5 -1367.5 937.5 -1362.5 {}
L 4 922.5 -1367.5 937.5 -1372.5 {}
L 4 922.5 -1377.5 937.5 -1372.5 {}
L 4 922.5 -1377.5 930 -1380 {}
L 4 930 -1390 930 -1380 {}
L 4 932.5 -1382.5 937.5 -1382.5 {}
L 4 935 -1385 935 -1380 {}
L 4 710 -1280 710 -1270 {}
L 4 710 -1280 717.5 -1282.5 {}
L 4 702.5 -1287.5 717.5 -1282.5 {}
L 4 702.5 -1287.5 717.5 -1292.5 {}
L 4 702.5 -1297.5 717.5 -1292.5 {}
L 4 702.5 -1297.5 717.5 -1302.5 {}
L 4 702.5 -1307.5 717.5 -1302.5 {}
L 4 702.5 -1307.5 717.5 -1312.5 {}
L 4 702.5 -1317.5 717.5 -1312.5 {}
L 4 702.5 -1317.5 710 -1320 {}
L 4 710 -1330 710 -1320 {}
L 4 712.5 -1322.5 717.5 -1322.5 {}
L 4 715 -1325 715 -1320 {}
L 4 820 -1280 820 -1270 {}
L 4 820 -1280 827.5 -1282.5 {}
L 4 812.5 -1287.5 827.5 -1282.5 {}
L 4 812.5 -1287.5 827.5 -1292.5 {}
L 4 812.5 -1297.5 827.5 -1292.5 {}
L 4 812.5 -1297.5 827.5 -1302.5 {}
L 4 812.5 -1307.5 827.5 -1302.5 {}
L 4 812.5 -1307.5 827.5 -1312.5 {}
L 4 812.5 -1317.5 827.5 -1312.5 {}
L 4 812.5 -1317.5 820 -1320 {}
L 4 820 -1330 820 -1320 {}
L 4 822.5 -1322.5 827.5 -1322.5 {}
L 4 825 -1325 825 -1320 {}
L 4 930 -1280 930 -1270 {}
L 4 930 -1280 937.5 -1282.5 {}
L 4 922.5 -1287.5 937.5 -1282.5 {}
L 4 922.5 -1287.5 937.5 -1292.5 {}
L 4 922.5 -1297.5 937.5 -1292.5 {}
L 4 922.5 -1297.5 937.5 -1302.5 {}
L 4 922.5 -1307.5 937.5 -1302.5 {}
L 4 922.5 -1307.5 937.5 -1312.5 {}
L 4 922.5 -1317.5 937.5 -1312.5 {}
L 4 922.5 -1317.5 930 -1320 {}
L 4 930 -1330 930 -1320 {}
L 4 932.5 -1322.5 937.5 -1322.5 {}
L 4 935 -1325 935 -1320 {}
L 4 1250 -1280 1250 -1270 {}
L 4 1250 -1280 1257.5 -1282.5 {}
L 4 1242.5 -1287.5 1257.5 -1282.5 {}
L 4 1242.5 -1287.5 1257.5 -1292.5 {}
L 4 1242.5 -1297.5 1257.5 -1292.5 {}
L 4 1242.5 -1297.5 1257.5 -1302.5 {}
L 4 1242.5 -1307.5 1257.5 -1302.5 {}
L 4 1242.5 -1307.5 1257.5 -1312.5 {}
L 4 1242.5 -1317.5 1257.5 -1312.5 {}
L 4 1242.5 -1317.5 1250 -1320 {}
L 4 1250 -1330 1250 -1320 {}
L 4 1252.5 -1322.5 1257.5 -1322.5 {}
L 4 1255 -1325 1255 -1320 {}
L 4 1360 -1280 1360 -1270 {}
L 4 1360 -1280 1367.5 -1282.5 {}
L 4 1352.5 -1287.5 1367.5 -1282.5 {}
L 4 1352.5 -1287.5 1367.5 -1292.5 {}
L 4 1352.5 -1297.5 1367.5 -1292.5 {}
L 4 1352.5 -1297.5 1367.5 -1302.5 {}
L 4 1352.5 -1307.5 1367.5 -1302.5 {}
L 4 1352.5 -1307.5 1367.5 -1312.5 {}
L 4 1352.5 -1317.5 1367.5 -1312.5 {}
L 4 1352.5 -1317.5 1360 -1320 {}
L 4 1360 -1330 1360 -1320 {}
L 4 1362.5 -1322.5 1367.5 -1322.5 {}
L 4 1365 -1325 1365 -1320 {}
L 4 1470 -1280 1470 -1270 {}
L 4 1470 -1280 1477.5 -1282.5 {}
L 4 1462.5 -1287.5 1477.5 -1282.5 {}
L 4 1462.5 -1287.5 1477.5 -1292.5 {}
L 4 1462.5 -1297.5 1477.5 -1292.5 {}
L 4 1462.5 -1297.5 1477.5 -1302.5 {}
L 4 1462.5 -1307.5 1477.5 -1302.5 {}
L 4 1462.5 -1307.5 1477.5 -1312.5 {}
L 4 1462.5 -1317.5 1477.5 -1312.5 {}
L 4 1462.5 -1317.5 1470 -1320 {}
L 4 1470 -1330 1470 -1320 {}
L 4 1472.5 -1322.5 1477.5 -1322.5 {}
L 4 1475 -1325 1475 -1320 {}
L 4 1790 -1250 1790 -1240 {}
L 4 1790 -1250 1797.5 -1252.5 {}
L 4 1782.5 -1257.5 1797.5 -1252.5 {}
L 4 1782.5 -1257.5 1797.5 -1262.5 {}
L 4 1782.5 -1267.5 1797.5 -1262.5 {}
L 4 1782.5 -1267.5 1797.5 -1272.5 {}
L 4 1782.5 -1277.5 1797.5 -1272.5 {}
L 4 1782.5 -1277.5 1797.5 -1282.5 {}
L 4 1782.5 -1287.5 1797.5 -1282.5 {}
L 4 1782.5 -1287.5 1790 -1290 {}
L 4 1790 -1300 1790 -1290 {}
L 4 1792.5 -1292.5 1797.5 -1292.5 {}
L 4 1795 -1295 1795 -1290 {}
L 4 1900 -1250 1900 -1240 {}
L 4 1900 -1250 1907.5 -1252.5 {}
L 4 1892.5 -1257.5 1907.5 -1252.5 {}
L 4 1892.5 -1257.5 1907.5 -1262.5 {}
L 4 1892.5 -1267.5 1907.5 -1262.5 {}
L 4 1892.5 -1267.5 1907.5 -1272.5 {}
L 4 1892.5 -1277.5 1907.5 -1272.5 {}
L 4 1892.5 -1277.5 1907.5 -1282.5 {}
L 4 1892.5 -1287.5 1907.5 -1282.5 {}
L 4 1892.5 -1287.5 1900 -1290 {}
L 4 1900 -1300 1900 -1290 {}
L 4 1902.5 -1292.5 1907.5 -1292.5 {}
L 4 1905 -1295 1905 -1290 {}
L 4 2010 -1250 2010 -1240 {}
L 4 2010 -1250 2017.5 -1252.5 {}
L 4 2002.5 -1257.5 2017.5 -1252.5 {}
L 4 2002.5 -1257.5 2017.5 -1262.5 {}
L 4 2002.5 -1267.5 2017.5 -1262.5 {}
L 4 2002.5 -1267.5 2017.5 -1272.5 {}
L 4 2002.5 -1277.5 2017.5 -1272.5 {}
L 4 2002.5 -1277.5 2017.5 -1282.5 {}
L 4 2002.5 -1287.5 2017.5 -1282.5 {}
L 4 2002.5 -1287.5 2010 -1290 {}
L 4 2010 -1300 2010 -1290 {}
L 4 2012.5 -1292.5 2017.5 -1292.5 {}
L 4 2015 -1295 2015 -1290 {}
L 4 1760 -2030 1760 -2020 {}
L 4 1760 -2030 1767.5 -2032.5 {}
L 4 1752.5 -2037.5 1767.5 -2032.5 {}
L 4 1752.5 -2037.5 1767.5 -2042.5 {}
L 4 1752.5 -2047.5 1767.5 -2042.5 {}
L 4 1752.5 -2047.5 1767.5 -2052.5 {}
L 4 1752.5 -2057.5 1767.5 -2052.5 {}
L 4 1752.5 -2057.5 1767.5 -2062.5 {}
L 4 1752.5 -2067.5 1767.5 -2062.5 {}
L 4 1752.5 -2067.5 1760 -2070 {}
L 4 1760 -2080 1760 -2070 {}
L 4 1762.5 -2072.5 1767.5 -2072.5 {}
L 4 1765 -2075 1765 -2070 {}
L 4 1880 -2030 1880 -2020 {}
L 4 1880 -2030 1887.5 -2032.5 {}
L 4 1872.5 -2037.5 1887.5 -2032.5 {}
L 4 1872.5 -2037.5 1887.5 -2042.5 {}
L 4 1872.5 -2047.5 1887.5 -2042.5 {}
L 4 1872.5 -2047.5 1887.5 -2052.5 {}
L 4 1872.5 -2057.5 1887.5 -2052.5 {}
L 4 1872.5 -2057.5 1887.5 -2062.5 {}
L 4 1872.5 -2067.5 1887.5 -2062.5 {}
L 4 1872.5 -2067.5 1880 -2070 {}
L 4 1880 -2080 1880 -2070 {}
L 4 1882.5 -2072.5 1887.5 -2072.5 {}
L 4 1885 -2075 1885 -2070 {}
L 4 805 -930 805 -870 {}
L 4 805 -920 820 -920 {}
L 4 820 -930 820 -920 {}
L 4 805 -880 820 -880 {}
L 4 820 -880 820 -870 {}
L 4 795 -915 795 -885 {}
L 4 795 -900 795 -895 {}
L 4 780 -900 787.5 -900 {}
L 4 780 -900 795 -900 {}
L 4 810 -900 820 -900 {}
L 4 805 -905 810 -900 {}
L 4 805 -895 810 -900 {}
L 4 820 -970 820 -960 {}
L 4 820 -970 827.5 -972.5 {}
L 4 812.5 -977.5 827.5 -972.5 {}
L 4 812.5 -977.5 827.5 -982.5 {}
L 4 812.5 -987.5 827.5 -982.5 {}
L 4 812.5 -987.5 827.5 -992.5 {}
L 4 812.5 -997.5 827.5 -992.5 {}
L 4 812.5 -997.5 827.5 -1002.5 {}
L 4 812.5 -1007.5 827.5 -1002.5 {}
L 4 812.5 -1007.5 820 -1010 {}
L 4 820 -1020 820 -1010 {}
L 4 822.5 -1012.5 827.5 -1012.5 {}
L 4 825 -1015 825 -1010 {}
L 4 910 -895 910 -870 {}
L 4 910 -930 910 -905 {}
L 4 900 -905 920 -905 {}
L 4 900 -895 920 -895 {}
L 4 912.5 -922.5 917.5 -922.5 {}
L 4 915 -925 915 -920 {}
L 4 582.5 -862.5 587.5 -862.5 {}
L 4 585 -865 585 -860 {}
L 4 580 -870 580 -810 {}
L 4 690 -790 690 -777.5 {}
L 4 685 -777.5 695 -777.5 {}
L 4 690 -772.5 695 -777.5 {}
L 4 685 -777.5 690 -772.5 {}
L 4 690 -1070 690 -1050 {}
L 4 680 -1070 700 -1070 {}
L 4 1405 -930 1405 -870 {}
L 4 1405 -920 1420 -920 {}
L 4 1420 -930 1420 -920 {}
L 4 1405 -880 1420 -880 {}
L 4 1420 -880 1420 -870 {}
L 4 1395 -915 1395 -885 {}
L 4 1395 -900 1395 -895 {}
L 4 1380 -900 1387.5 -900 {}
L 4 1380 -900 1395 -900 {}
L 4 1410 -900 1420 -900 {}
L 4 1405 -905 1410 -900 {}
L 4 1405 -895 1410 -900 {}
L 4 1420 -970 1420 -960 {}
L 4 1420 -970 1427.5 -972.5 {}
L 4 1412.5 -977.5 1427.5 -972.5 {}
L 4 1412.5 -977.5 1427.5 -982.5 {}
L 4 1412.5 -987.5 1427.5 -982.5 {}
L 4 1412.5 -987.5 1427.5 -992.5 {}
L 4 1412.5 -997.5 1427.5 -992.5 {}
L 4 1412.5 -997.5 1427.5 -1002.5 {}
L 4 1412.5 -1007.5 1427.5 -1002.5 {}
L 4 1412.5 -1007.5 1420 -1010 {}
L 4 1420 -1020 1420 -1010 {}
L 4 1422.5 -1012.5 1427.5 -1012.5 {}
L 4 1425 -1015 1425 -1010 {}
L 4 1182.5 -862.5 1187.5 -862.5 {}
L 4 1185 -865 1185 -860 {}
L 4 1180 -870 1180 -810 {}
L 4 1290 -790 1290 -777.5 {}
L 4 1285 -777.5 1295 -777.5 {}
L 4 1290 -772.5 1295 -777.5 {}
L 4 1285 -777.5 1290 -772.5 {}
L 4 1290 -1070 1290 -1050 {}
L 4 1280 -1070 1300 -1070 {}
L 4 2015 -930 2015 -870 {}
L 4 2015 -920 2030 -920 {}
L 4 2030 -930 2030 -920 {}
L 4 2015 -880 2030 -880 {}
L 4 2030 -880 2030 -870 {}
L 4 2005 -915 2005 -885 {}
L 4 2005 -900 2005 -895 {}
L 4 1990 -900 1997.5 -900 {}
L 4 1990 -900 2005 -900 {}
L 4 2020 -900 2030 -900 {}
L 4 2015 -905 2020 -900 {}
L 4 2015 -895 2020 -900 {}
L 4 2030 -970 2030 -960 {}
L 4 2030 -970 2037.5 -972.5 {}
L 4 2022.5 -977.5 2037.5 -972.5 {}
L 4 2022.5 -977.5 2037.5 -982.5 {}
L 4 2022.5 -987.5 2037.5 -982.5 {}
L 4 2022.5 -987.5 2037.5 -992.5 {}
L 4 2022.5 -997.5 2037.5 -992.5 {}
L 4 2022.5 -997.5 2037.5 -1002.5 {}
L 4 2022.5 -1007.5 2037.5 -1002.5 {}
L 4 2022.5 -1007.5 2030 -1010 {}
L 4 2030 -1020 2030 -1010 {}
L 4 2032.5 -1012.5 2037.5 -1012.5 {}
L 4 2035 -1015 2035 -1010 {}
L 4 1792.5 -862.5 1797.5 -862.5 {}
L 4 1795 -865 1795 -860 {}
L 4 1790 -870 1790 -810 {}
L 4 1900 -790 1900 -777.5 {}
L 4 1895 -777.5 1905 -777.5 {}
L 4 1900 -772.5 1905 -777.5 {}
L 4 1895 -777.5 1900 -772.5 {}
L 4 1900 -1070 1900 -1050 {}
L 4 1890 -1070 1910 -1070 {}
L 4 360 -8180 360 -8170 {}
L 4 360 -8180 367.5 -8182.5 {}
L 4 352.5 -8187.5 367.5 -8182.5 {}
L 4 352.5 -8187.5 367.5 -8192.5 {}
L 4 352.5 -8197.5 367.5 -8192.5 {}
L 4 352.5 -8197.5 367.5 -8202.5 {}
L 4 352.5 -8207.5 367.5 -8202.5 {}
L 4 352.5 -8207.5 367.5 -8212.5 {}
L 4 352.5 -8217.5 367.5 -8212.5 {}
L 4 352.5 -8217.5 360 -8220 {}
L 4 360 -8230 360 -8220 {}
L 4 362.5 -8222.5 367.5 -8222.5 {}
L 4 365 -8225 365 -8220 {}
L 4 560 -8180 560 -8170 {}
L 4 560 -8180 567.5 -8182.5 {}
L 4 552.5 -8187.5 567.5 -8182.5 {}
L 4 552.5 -8187.5 567.5 -8192.5 {}
L 4 552.5 -8197.5 567.5 -8192.5 {}
L 4 552.5 -8197.5 567.5 -8202.5 {}
L 4 552.5 -8207.5 567.5 -8202.5 {}
L 4 552.5 -8207.5 567.5 -8212.5 {}
L 4 552.5 -8217.5 567.5 -8212.5 {}
L 4 552.5 -8217.5 560 -8220 {}
L 4 560 -8230 560 -8220 {}
L 4 562.5 -8222.5 567.5 -8222.5 {}
L 4 565 -8225 565 -8220 {}
L 4 800 -8180 800 -8170 {}
L 4 800 -8180 807.5 -8182.5 {}
L 4 792.5 -8187.5 807.5 -8182.5 {}
L 4 792.5 -8187.5 807.5 -8192.5 {}
L 4 792.5 -8197.5 807.5 -8192.5 {}
L 4 792.5 -8197.5 807.5 -8202.5 {}
L 4 792.5 -8207.5 807.5 -8202.5 {}
L 4 792.5 -8207.5 807.5 -8212.5 {}
L 4 792.5 -8217.5 807.5 -8212.5 {}
L 4 792.5 -8217.5 800 -8220 {}
L 4 800 -8230 800 -8220 {}
L 4 802.5 -8222.5 807.5 -8222.5 {}
L 4 805 -8225 805 -8220 {}
L 4 1090 -8180 1090 -8170 {}
L 4 1090 -8180 1097.5 -8182.5 {}
L 4 1082.5 -8187.5 1097.5 -8182.5 {}
L 4 1082.5 -8187.5 1097.5 -8192.5 {}
L 4 1082.5 -8197.5 1097.5 -8192.5 {}
L 4 1082.5 -8197.5 1097.5 -8202.5 {}
L 4 1082.5 -8207.5 1097.5 -8202.5 {}
L 4 1082.5 -8207.5 1097.5 -8212.5 {}
L 4 1082.5 -8217.5 1097.5 -8212.5 {}
L 4 1082.5 -8217.5 1090 -8220 {}
L 4 1090 -8230 1090 -8220 {}
L 4 1092.5 -8222.5 1097.5 -8222.5 {}
L 4 1095 -8225 1095 -8220 {}
L 4 1320 -8180 1320 -8170 {}
L 4 1320 -8180 1327.5 -8182.5 {}
L 4 1312.5 -8187.5 1327.5 -8182.5 {}
L 4 1312.5 -8187.5 1327.5 -8192.5 {}
L 4 1312.5 -8197.5 1327.5 -8192.5 {}
L 4 1312.5 -8197.5 1327.5 -8202.5 {}
L 4 1312.5 -8207.5 1327.5 -8202.5 {}
L 4 1312.5 -8207.5 1327.5 -8212.5 {}
L 4 1312.5 -8217.5 1327.5 -8212.5 {}
L 4 1312.5 -8217.5 1320 -8220 {}
L 4 1320 -8230 1320 -8220 {}
L 4 1322.5 -8222.5 1327.5 -8222.5 {}
L 4 1325 -8225 1325 -8220 {}
L 4 1610 -8180 1610 -8170 {}
L 4 1610 -8180 1617.5 -8182.5 {}
L 4 1602.5 -8187.5 1617.5 -8182.5 {}
L 4 1602.5 -8187.5 1617.5 -8192.5 {}
L 4 1602.5 -8197.5 1617.5 -8192.5 {}
L 4 1602.5 -8197.5 1617.5 -8202.5 {}
L 4 1602.5 -8207.5 1617.5 -8202.5 {}
L 4 1602.5 -8207.5 1617.5 -8212.5 {}
L 4 1602.5 -8217.5 1617.5 -8212.5 {}
L 4 1602.5 -8217.5 1610 -8220 {}
L 4 1610 -8230 1610 -8220 {}
L 4 1612.5 -8222.5 1617.5 -8222.5 {}
L 4 1615 -8225 1615 -8220 {}
L 4 1850 -8180 1850 -8170 {}
L 4 1850 -8180 1857.5 -8182.5 {}
L 4 1842.5 -8187.5 1857.5 -8182.5 {}
L 4 1842.5 -8187.5 1857.5 -8192.5 {}
L 4 1842.5 -8197.5 1857.5 -8192.5 {}
L 4 1842.5 -8197.5 1857.5 -8202.5 {}
L 4 1842.5 -8207.5 1857.5 -8202.5 {}
L 4 1842.5 -8207.5 1857.5 -8212.5 {}
L 4 1842.5 -8217.5 1857.5 -8212.5 {}
L 4 1842.5 -8217.5 1850 -8220 {}
L 4 1850 -8230 1850 -8220 {}
L 4 1852.5 -8222.5 1857.5 -8222.5 {}
L 4 1855 -8225 1855 -8220 {}
L 4 2150 -8180 2150 -8170 {}
L 4 2150 -8180 2157.5 -8182.5 {}
L 4 2142.5 -8187.5 2157.5 -8182.5 {}
L 4 2142.5 -8187.5 2157.5 -8192.5 {}
L 4 2142.5 -8197.5 2157.5 -8192.5 {}
L 4 2142.5 -8197.5 2157.5 -8202.5 {}
L 4 2142.5 -8207.5 2157.5 -8202.5 {}
L 4 2142.5 -8207.5 2157.5 -8212.5 {}
L 4 2142.5 -8217.5 2157.5 -8212.5 {}
L 4 2142.5 -8217.5 2150 -8220 {}
L 4 2150 -8230 2150 -8220 {}
L 4 2152.5 -8222.5 2157.5 -8222.5 {}
L 4 2155 -8225 2155 -8220 {}
L 4 745 -4990 745 -4930 {}
L 4 745 -4980 760 -4980 {}
L 4 760 -4990 760 -4980 {}
L 4 745 -4940 760 -4940 {}
L 4 760 -4940 760 -4930 {}
L 4 735 -4975 735 -4945 {}
L 4 735 -4960 735 -4955 {}
L 4 720 -4960 727.5 -4960 {}
L 4 720 -4960 735 -4960 {}
L 4 750 -4960 760 -4960 {}
L 4 745 -4965 750 -4960 {}
L 4 745 -4955 750 -4960 {}
L 4 760 -5030 760 -5020 {}
L 4 760 -5030 767.5 -5032.5 {}
L 4 752.5 -5037.5 767.5 -5032.5 {}
L 4 752.5 -5037.5 767.5 -5042.5 {}
L 4 752.5 -5047.5 767.5 -5042.5 {}
L 4 752.5 -5047.5 767.5 -5052.5 {}
L 4 752.5 -5057.5 767.5 -5052.5 {}
L 4 752.5 -5057.5 767.5 -5062.5 {}
L 4 752.5 -5067.5 767.5 -5062.5 {}
L 4 752.5 -5067.5 760 -5070 {}
L 4 760 -5080 760 -5070 {}
L 4 762.5 -5072.5 767.5 -5072.5 {}
L 4 765 -5075 765 -5070 {}
L 4 522.5 -4922.5 527.5 -4922.5 {}
L 4 525 -4925 525 -4920 {}
L 4 520 -4930 520 -4870 {}
L 4 630 -4850 630 -4837.5 {}
L 4 625 -4837.5 635 -4837.5 {}
L 4 630 -4832.5 635 -4837.5 {}
L 4 625 -4837.5 630 -4832.5 {}
L 4 630 -5130 630 -5110 {}
L 4 620 -5130 640 -5130 {}
L 4 1305 -4990 1305 -4930 {}
L 4 1305 -4980 1320 -4980 {}
L 4 1320 -4990 1320 -4980 {}
L 4 1305 -4940 1320 -4940 {}
L 4 1320 -4940 1320 -4930 {}
L 4 1295 -4975 1295 -4945 {}
L 4 1295 -4960 1295 -4955 {}
L 4 1280 -4960 1287.5 -4960 {}
L 4 1280 -4960 1295 -4960 {}
L 4 1310 -4960 1320 -4960 {}
L 4 1305 -4965 1310 -4960 {}
L 4 1305 -4955 1310 -4960 {}
L 4 1320 -5030 1320 -5020 {}
L 4 1320 -5030 1327.5 -5032.5 {}
L 4 1312.5 -5037.5 1327.5 -5032.5 {}
L 4 1312.5 -5037.5 1327.5 -5042.5 {}
L 4 1312.5 -5047.5 1327.5 -5042.5 {}
L 4 1312.5 -5047.5 1327.5 -5052.5 {}
L 4 1312.5 -5057.5 1327.5 -5052.5 {}
L 4 1312.5 -5057.5 1327.5 -5062.5 {}
L 4 1312.5 -5067.5 1327.5 -5062.5 {}
L 4 1312.5 -5067.5 1320 -5070 {}
L 4 1320 -5080 1320 -5070 {}
L 4 1322.5 -5072.5 1327.5 -5072.5 {}
L 4 1325 -5075 1325 -5070 {}
L 4 1082.5 -4922.5 1087.5 -4922.5 {}
L 4 1085 -4925 1085 -4920 {}
L 4 1080 -4930 1080 -4870 {}
L 4 1190 -4850 1190 -4837.5 {}
L 4 1185 -4837.5 1195 -4837.5 {}
L 4 1190 -4832.5 1195 -4837.5 {}
L 4 1185 -4837.5 1190 -4832.5 {}
L 4 1190 -5130 1190 -5110 {}
L 4 1180 -5130 1200 -5130 {}
L 4 690 -9040 690 -8980 {}
L 4 690 -9030 705 -9030 {}
L 4 705 -9040 705 -9030 {}
L 4 690 -8990 705 -8990 {}
L 4 705 -8990 705 -8980 {}
L 4 680 -9025 680 -8995 {}
L 4 680 -9010 680 -9005 {}
L 4 665 -9010 672.5 -9010 {}
L 4 665 -9010 680 -9010 {}
L 4 695 -9010 705 -9010 {}
L 4 690 -9015 695 -9010 {}
L 4 690 -9005 695 -9010 {}
L 4 705 -9080 705 -9070 {}
L 4 705 -9080 712.5 -9082.5 {}
L 4 697.5 -9087.5 712.5 -9082.5 {}
L 4 697.5 -9087.5 712.5 -9092.5 {}
L 4 697.5 -9097.5 712.5 -9092.5 {}
L 4 697.5 -9097.5 712.5 -9102.5 {}
L 4 697.5 -9107.5 712.5 -9102.5 {}
L 4 697.5 -9107.5 712.5 -9112.5 {}
L 4 697.5 -9117.5 712.5 -9112.5 {}
L 4 697.5 -9117.5 705 -9120 {}
L 4 705 -9130 705 -9120 {}
L 4 707.5 -9122.5 712.5 -9122.5 {}
L 4 710 -9125 710 -9120 {}
L 4 795 -9005 795 -8980 {}
L 4 795 -9040 795 -9015 {}
L 4 785 -9015 805 -9015 {}
L 4 785 -9005 805 -9005 {}
L 4 797.5 -9032.5 802.5 -9032.5 {}
L 4 800 -9035 800 -9030 {}
L 4 467.5 -8972.5 472.5 -8972.5 {}
L 4 470 -8975 470 -8970 {}
L 4 465 -8980 465 -8920 {}
L 4 575 -8900 575 -8887.5 {}
L 4 570 -8887.5 580 -8887.5 {}
L 4 575 -8882.5 580 -8887.5 {}
L 4 570 -8887.5 575 -8882.5 {}
L 4 575 -9180 575 -9160 {}
L 4 565 -9180 585 -9180 {}
L 4 1255 -9040 1255 -8980 {}
L 4 1255 -9030 1270 -9030 {}
L 4 1270 -9040 1270 -9030 {}
L 4 1255 -8990 1270 -8990 {}
L 4 1270 -8990 1270 -8980 {}
L 4 1245 -9025 1245 -8995 {}
L 4 1245 -9010 1245 -9005 {}
L 4 1230 -9010 1237.5 -9010 {}
L 4 1230 -9010 1245 -9010 {}
L 4 1260 -9010 1270 -9010 {}
L 4 1255 -9015 1260 -9010 {}
L 4 1255 -9005 1260 -9010 {}
L 4 1270 -9080 1270 -9070 {}
L 4 1270 -9080 1277.5 -9082.5 {}
L 4 1262.5 -9087.5 1277.5 -9082.5 {}
L 4 1262.5 -9087.5 1277.5 -9092.5 {}
L 4 1262.5 -9097.5 1277.5 -9092.5 {}
L 4 1262.5 -9097.5 1277.5 -9102.5 {}
L 4 1262.5 -9107.5 1277.5 -9102.5 {}
L 4 1262.5 -9107.5 1277.5 -9112.5 {}
L 4 1262.5 -9117.5 1277.5 -9112.5 {}
L 4 1262.5 -9117.5 1270 -9120 {}
L 4 1270 -9130 1270 -9120 {}
L 4 1272.5 -9122.5 1277.5 -9122.5 {}
L 4 1275 -9125 1275 -9120 {}
L 4 1360 -9005 1360 -8980 {}
L 4 1360 -9040 1360 -9015 {}
L 4 1350 -9015 1370 -9015 {}
L 4 1350 -9005 1370 -9005 {}
L 4 1362.5 -9032.5 1367.5 -9032.5 {}
L 4 1365 -9035 1365 -9030 {}
L 4 1032.5 -8972.5 1037.5 -8972.5 {}
L 4 1035 -8975 1035 -8970 {}
L 4 1030 -8980 1030 -8920 {}
L 4 1140 -8900 1140 -8887.5 {}
L 4 1135 -8887.5 1145 -8887.5 {}
L 4 1140 -8882.5 1145 -8887.5 {}
L 4 1135 -8887.5 1140 -8882.5 {}
L 4 1140 -9180 1140 -9160 {}
L 4 1130 -9180 1150 -9180 {}
L 4 1755 -9040 1755 -8980 {}
L 4 1755 -9030 1770 -9030 {}
L 4 1770 -9040 1770 -9030 {}
L 4 1755 -8990 1770 -8990 {}
L 4 1770 -8990 1770 -8980 {}
L 4 1745 -9025 1745 -8995 {}
L 4 1745 -9010 1745 -9005 {}
L 4 1730 -9010 1737.5 -9010 {}
L 4 1730 -9010 1745 -9010 {}
L 4 1760 -9010 1770 -9010 {}
L 4 1755 -9015 1760 -9010 {}
L 4 1755 -9005 1760 -9010 {}
L 4 1770 -9080 1770 -9070 {}
L 4 1770 -9080 1777.5 -9082.5 {}
L 4 1762.5 -9087.5 1777.5 -9082.5 {}
L 4 1762.5 -9087.5 1777.5 -9092.5 {}
L 4 1762.5 -9097.5 1777.5 -9092.5 {}
L 4 1762.5 -9097.5 1777.5 -9102.5 {}
L 4 1762.5 -9107.5 1777.5 -9102.5 {}
L 4 1762.5 -9107.5 1777.5 -9112.5 {}
L 4 1762.5 -9117.5 1777.5 -9112.5 {}
L 4 1762.5 -9117.5 1770 -9120 {}
L 4 1770 -9130 1770 -9120 {}
L 4 1772.5 -9122.5 1777.5 -9122.5 {}
L 4 1775 -9125 1775 -9120 {}
L 4 1860 -9005 1860 -8980 {}
L 4 1860 -9040 1860 -9015 {}
L 4 1850 -9015 1870 -9015 {}
L 4 1850 -9005 1870 -9005 {}
L 4 1862.5 -9032.5 1867.5 -9032.5 {}
L 4 1865 -9035 1865 -9030 {}
L 4 1532.5 -8972.5 1537.5 -8972.5 {}
L 4 1535 -8975 1535 -8970 {}
L 4 1530 -8980 1530 -8920 {}
L 4 1640 -8900 1640 -8887.5 {}
L 4 1635 -8887.5 1645 -8887.5 {}
L 4 1640 -8882.5 1645 -8887.5 {}
L 4 1635 -8887.5 1640 -8882.5 {}
L 4 1640 -9180 1640 -9160 {}
L 4 1630 -9180 1650 -9180 {}
L 4 2245 -9040 2245 -8980 {}
L 4 2245 -9030 2260 -9030 {}
L 4 2260 -9040 2260 -9030 {}
L 4 2245 -8990 2260 -8990 {}
L 4 2260 -8990 2260 -8980 {}
L 4 2235 -9025 2235 -8995 {}
L 4 2235 -9010 2235 -9005 {}
L 4 2220 -9010 2227.5 -9010 {}
L 4 2220 -9010 2235 -9010 {}
L 4 2250 -9010 2260 -9010 {}
L 4 2245 -9015 2250 -9010 {}
L 4 2245 -9005 2250 -9010 {}
L 4 2260 -9080 2260 -9070 {}
L 4 2260 -9080 2267.5 -9082.5 {}
L 4 2252.5 -9087.5 2267.5 -9082.5 {}
L 4 2252.5 -9087.5 2267.5 -9092.5 {}
L 4 2252.5 -9097.5 2267.5 -9092.5 {}
L 4 2252.5 -9097.5 2267.5 -9102.5 {}
L 4 2252.5 -9107.5 2267.5 -9102.5 {}
L 4 2252.5 -9107.5 2267.5 -9112.5 {}
L 4 2252.5 -9117.5 2267.5 -9112.5 {}
L 4 2252.5 -9117.5 2260 -9120 {}
L 4 2260 -9130 2260 -9120 {}
L 4 2262.5 -9122.5 2267.5 -9122.5 {}
L 4 2265 -9125 2265 -9120 {}
L 4 2350 -9005 2350 -8980 {}
L 4 2350 -9040 2350 -9015 {}
L 4 2340 -9015 2360 -9015 {}
L 4 2340 -9005 2360 -9005 {}
L 4 2352.5 -9032.5 2357.5 -9032.5 {}
L 4 2355 -9035 2355 -9030 {}
L 4 2022.5 -8972.5 2027.5 -8972.5 {}
L 4 2025 -8975 2025 -8970 {}
L 4 2020 -8980 2020 -8920 {}
L 4 2130 -8900 2130 -8887.5 {}
L 4 2125 -8887.5 2135 -8887.5 {}
L 4 2130 -8882.5 2135 -8887.5 {}
L 4 2125 -8887.5 2130 -8882.5 {}
L 4 2130 -9180 2130 -9160 {}
L 4 2120 -9180 2140 -9180 {}
L 4 420 -8195 420 -8170 {}
L 4 420 -8230 420 -8205 {}
L 4 410 -8205 430 -8205 {}
L 4 410 -8195 430 -8195 {}
L 4 422.5 -8222.5 427.5 -8222.5 {}
L 4 425 -8225 425 -8220 {}
L 4 620 -8195 620 -8170 {}
L 4 620 -8230 620 -8205 {}
L 4 610 -8205 630 -8205 {}
L 4 610 -8195 630 -8195 {}
L 4 622.5 -8222.5 627.5 -8222.5 {}
L 4 625 -8225 625 -8220 {}
L 4 860 -8195 860 -8170 {}
L 4 860 -8230 860 -8205 {}
L 4 850 -8205 870 -8205 {}
L 4 850 -8195 870 -8195 {}
L 4 862.5 -8222.5 867.5 -8222.5 {}
L 4 865 -8225 865 -8220 {}
L 4 1150 -8195 1150 -8170 {}
L 4 1150 -8230 1150 -8205 {}
L 4 1140 -8205 1160 -8205 {}
L 4 1140 -8195 1160 -8195 {}
L 4 1152.5 -8222.5 1157.5 -8222.5 {}
L 4 1155 -8225 1155 -8220 {}
L 4 1380 -8195 1380 -8170 {}
L 4 1380 -8230 1380 -8205 {}
L 4 1370 -8205 1390 -8205 {}
L 4 1370 -8195 1390 -8195 {}
L 4 1382.5 -8222.5 1387.5 -8222.5 {}
L 4 1385 -8225 1385 -8220 {}
L 4 1670 -8195 1670 -8170 {}
L 4 1670 -8230 1670 -8205 {}
L 4 1660 -8205 1680 -8205 {}
L 4 1660 -8195 1680 -8195 {}
L 4 1672.5 -8222.5 1677.5 -8222.5 {}
L 4 1675 -8225 1675 -8220 {}
L 4 1910 -8195 1910 -8170 {}
L 4 1910 -8230 1910 -8205 {}
L 4 1900 -8205 1920 -8205 {}
L 4 1900 -8195 1920 -8195 {}
L 4 1912.5 -8222.5 1917.5 -8222.5 {}
L 4 1915 -8225 1915 -8220 {}
L 4 2210 -8195 2210 -8170 {}
L 4 2210 -8230 2210 -8205 {}
L 4 2200 -8205 2220 -8205 {}
L 4 2200 -8195 2220 -8195 {}
L 4 2212.5 -8222.5 2217.5 -8222.5 {}
L 4 2215 -8225 2215 -8220 {}
L 4 2360 -8180 2360 -8170 {}
L 4 2360 -8180 2367.5 -8182.5 {}
L 4 2352.5 -8187.5 2367.5 -8182.5 {}
L 4 2352.5 -8187.5 2367.5 -8192.5 {}
L 4 2352.5 -8197.5 2367.5 -8192.5 {}
L 4 2352.5 -8197.5 2367.5 -8202.5 {}
L 4 2352.5 -8207.5 2367.5 -8202.5 {}
L 4 2352.5 -8207.5 2367.5 -8212.5 {}
L 4 2352.5 -8217.5 2367.5 -8212.5 {}
L 4 2352.5 -8217.5 2360 -8220 {}
L 4 2360 -8230 2360 -8220 {}
L 4 2362.5 -8222.5 2367.5 -8222.5 {}
L 4 2365 -8225 2365 -8220 {}
L 4 2420 -8195 2420 -8170 {}
L 4 2420 -8230 2420 -8205 {}
L 4 2410 -8205 2430 -8205 {}
L 4 2410 -8195 2430 -8195 {}
L 4 2422.5 -8222.5 2427.5 -8222.5 {}
L 4 2425 -8225 2425 -8220 {}
L 4 1120 -7120 1120 -7060 {}
L 4 1530 -270 1650 -270 {}
L 4 1530 -190 1650 -190 {}
L 4 1530 -270 1530 -190 {}
L 4 1650 -270 1650 -190 {}
L 4 1650 -260 1670 -260 {}
L 4 1510 -260 1530 -260 {}
L 4 1510 -240 1530 -240 {}
L 4 1510 -220 1530 -220 {}
L 4 1510 -200 1530 -200 {}
L 4 2060 -270 2180 -270 {}
L 4 2060 -190 2180 -190 {}
L 4 2060 -270 2060 -190 {}
L 4 2180 -270 2180 -190 {}
L 4 2180 -260 2200 -260 {}
L 4 2040 -260 2060 -260 {}
L 4 2040 -240 2060 -240 {}
L 4 2040 -220 2060 -220 {}
L 4 2040 -200 2060 -200 {}
L 5 1105 -10260 1110 -10260 {}
L 5 1410 -10290 1418.75 -10290 {}
L 5 1645 -10260 1650 -10260 {}
L 5 1950 -10290 1958.75 -10290 {}
L 5 575 -10260 580 -10260 {}
L 5 880 -10290 888.75 -10290 {}
L 5 575 -9800 580 -9800 {}
L 5 880 -9830 888.75 -9830 {}
L 5 1115 -9800 1120 -9800 {}
L 5 1420 -9830 1428.75 -9830 {}
L 5 575 -6210 580 -6210 {}
L 5 880 -6240 888.75 -6240 {}
L 5 1115 -6210 1120 -6210 {}
L 5 1420 -6240 1428.75 -6240 {}
L 5 575 -5810 580 -5810 {}
L 5 880 -5840 888.75 -5840 {}
L 5 1115 -5810 1120 -5810 {}
L 5 1420 -5840 1428.75 -5840 {}
L 5 575 -5370 580 -5370 {}
L 5 1765 -5370 1770 -5370 {}
L 5 1135 -5370 1140 -5370 {}
L 5 1105 -9430 1110 -9430 {}
L 5 1410 -9460 1418.75 -9460 {}
L 5 575 -9430 580 -9430 {}
L 5 880 -9460 888.75 -9460 {}
L 5 1605 -9430 1610 -9430 {}
L 5 1910 -9460 1918.75 -9460 {}
L 5 1645 -10730 1650 -10730 {}
L 5 1950 -10760 1958.75 -10760 {}
L 5 520 -10730 525 -10730 {}
L 5 825 -10760 833.75 -10760 {}
L 5 2105 -10730 2110 -10730 {}
L 5 2410 -10760 2418.75 -10760 {}
L 5 595 -8590 600 -8590 {}
L 5 900 -8620 908.75 -8620 {}
L 5 1135 -8590 1140 -8590 {}
L 5 1440 -8620 1448.75 -8620 {}
L 5 2265 -8590 2270 -8590 {}
L 5 2570 -8620 2578.75 -8620 {}
L 5 1105 -10730 1110 -10730 {}
L 5 1410 -10760 1418.75 -10760 {}
L 5 655 -900 660 -900 {}
L 5 960 -930 968.75 -930 {}
L 5 1255 -900 1260 -900 {}
L 5 1560 -930 1568.75 -930 {}
L 5 1865 -900 1870 -900 {}
L 5 2170 -930 2178.75 -930 {}
L 5 595 -4960 600 -4960 {}
L 5 900 -4990 908.75 -4990 {}
L 5 1155 -4960 1160 -4960 {}
L 5 1460 -4990 1468.75 -4990 {}
L 5 540 -9010 545 -9010 {}
L 5 845 -9040 853.75 -9040 {}
L 5 1105 -9010 1110 -9010 {}
L 5 1410 -9040 1418.75 -9040 {}
L 5 1605 -9010 1610 -9010 {}
L 5 1910 -9040 1918.75 -9040 {}
L 5 2095 -9010 2100 -9010 {}
L 5 2400 -9040 2408.75 -9040 {}
L 6 1110 -10260 1230 -10260 {}
L 6 1030 -10410 1270 -10410 {}
L 6 1270 -10290 1410 -10290 {}
L 6 1030 -10170 1030 -10150 {}
L 6 1030 -10410 1030 -10230 {}
L 6 1030 -10150 1270 -10150 {}
L 6 1650 -10260 1770 -10260 {}
L 6 1570 -10410 1810 -10410 {}
L 6 1810 -10290 1950 -10290 {}
L 6 1570 -10170 1570 -10150 {}
L 6 1570 -10410 1570 -10230 {}
L 6 1570 -10150 1810 -10150 {}
L 6 580 -10260 700 -10260 {}
L 6 500 -10410 740 -10410 {}
L 6 740 -10290 880 -10290 {}
L 6 500 -10170 500 -10150 {}
L 6 500 -10410 500 -10230 {}
L 6 500 -10150 740 -10150 {}
L 6 580 -9800 700 -9800 {}
L 6 740 -9860 740 -9830 {}
L 6 740 -9950 740 -9920 {}
L 6 500 -9950 740 -9950 {}
L 6 740 -9830 880 -9830 {}
L 6 830 -9770 830 -9690 {}
L 6 500 -9710 500 -9690 {}
L 6 500 -9950 500 -9770 {}
L 6 740 -9800 740 -9690 {}
L 6 740 -9690 830 -9690 {}
L 6 500 -9690 740 -9690 {}
L 6 1120 -9800 1240 -9800 {}
L 6 1280 -9860 1280 -9830 {}
L 6 1280 -9950 1280 -9920 {}
L 6 1040 -9950 1280 -9950 {}
L 6 1280 -9830 1420 -9830 {}
L 6 1370 -9770 1370 -9690 {}
L 6 1040 -9710 1040 -9690 {}
L 6 1040 -9950 1040 -9770 {}
L 6 1280 -9800 1280 -9690 {}
L 6 1280 -9690 1370 -9690 {}
L 6 1040 -9690 1280 -9690 {}
L 6 580 -6210 700 -6210 {}
L 6 740 -6270 740 -6240 {}
L 6 740 -6360 740 -6330 {}
L 6 500 -6360 740 -6360 {}
L 6 740 -6240 880 -6240 {}
L 6 830 -6180 830 -6100 {}
L 6 500 -6120 500 -6100 {}
L 6 500 -6360 500 -6180 {}
L 6 740 -6210 740 -6100 {}
L 6 740 -6100 830 -6100 {}
L 6 500 -6100 740 -6100 {}
L 6 1120 -6210 1240 -6210 {}
L 6 1280 -6270 1280 -6240 {}
L 6 1280 -6360 1280 -6330 {}
L 6 1040 -6360 1280 -6360 {}
L 6 1280 -6240 1420 -6240 {}
L 6 1370 -6180 1370 -6100 {}
L 6 1040 -6120 1040 -6100 {}
L 6 1040 -6360 1040 -6180 {}
L 6 1280 -6210 1280 -6100 {}
L 6 1280 -6100 1370 -6100 {}
L 6 1040 -6100 1280 -6100 {}
L 6 580 -5810 700 -5810 {}
L 6 740 -5870 740 -5840 {}
L 6 740 -5960 740 -5930 {}
L 6 500 -5960 740 -5960 {}
L 6 740 -5840 880 -5840 {}
L 6 830 -5780 830 -5700 {}
L 6 500 -5720 500 -5700 {}
L 6 500 -5960 500 -5780 {}
L 6 740 -5810 740 -5700 {}
L 6 740 -5700 830 -5700 {}
L 6 500 -5700 740 -5700 {}
L 6 1120 -5810 1240 -5810 {}
L 6 1040 -5960 1280 -5960 {}
L 6 1280 -5840 1420 -5840 {}
L 6 1370 -5780 1370 -5700 {}
L 6 1040 -5720 1040 -5700 {}
L 6 1040 -5960 1040 -5780 {}
L 6 1280 -5810 1280 -5700 {}
L 6 1280 -5700 1370 -5700 {}
L 6 1040 -5700 1280 -5700 {}
L 6 580 -5370 700 -5370 {}
L 6 500 -5520 740 -5520 {}
L 6 500 -5280 500 -5260 {}
L 6 500 -5520 500 -5340 {}
L 6 500 -5260 740 -5260 {}
L 6 1690 -5280 1690 -5260 {}
L 6 1690 -5520 1690 -5340 {}
L 6 1140 -5370 1260 -5370 {}
L 6 1060 -5280 1060 -5260 {}
L 6 1060 -5520 1060 -5340 {}
L 6 1110 -9430 1230 -9430 {}
L 6 1030 -9580 1270 -9580 {}
L 6 1270 -9460 1410 -9460 {}
L 6 1030 -9340 1030 -9320 {}
L 6 1030 -9580 1030 -9400 {}
L 6 1030 -9320 1270 -9320 {}
L 6 580 -9430 700 -9430 {}
L 6 500 -9580 740 -9580 {}
L 6 740 -9460 880 -9460 {}
L 6 500 -9340 500 -9320 {}
L 6 500 -9580 500 -9400 {}
L 6 500 -9320 740 -9320 {}
L 6 1610 -9430 1730 -9430 {}
L 6 1770 -9490 1770 -9460 {}
L 6 1770 -9580 1770 -9550 {}
L 6 1530 -9580 1770 -9580 {}
L 6 1770 -9460 1910 -9460 {}
L 6 1860 -9400 1860 -9320 {}
L 6 1530 -9340 1530 -9320 {}
L 6 1530 -9580 1530 -9400 {}
L 6 1770 -9430 1770 -9320 {}
L 6 1770 -9320 1860 -9320 {}
L 6 1530 -9320 1770 -9320 {}
L 6 1650 -10730 1770 -10730 {}
L 6 1570 -10880 1810 -10880 {}
L 6 1810 -10760 1950 -10760 {}
L 6 1570 -10620 1810 -10620 {}
L 6 525 -10730 645 -10730 {}
L 6 445 -10880 685 -10880 {}
L 6 685 -10760 825 -10760 {}
L 6 445 -10640 445 -10620 {}
L 6 445 -10880 445 -10700 {}
L 6 445 -10620 685 -10620 {}
L 6 2110 -10730 2230 -10730 {}
L 6 2030 -10880 2270 -10880 {}
L 6 2270 -10760 2410 -10760 {}
L 6 2030 -10620 2270 -10620 {}
L 6 2360 -10700 2360 -10620 {}
L 6 600 -8590 720 -8590 {}
L 6 760 -8650 760 -8620 {}
L 6 760 -8740 760 -8710 {}
L 6 760 -8620 900 -8620 {}
L 6 850 -8560 850 -8480 {}
L 6 520 -8500 520 -8480 {}
L 6 520 -8740 520 -8560 {}
L 6 760 -8590 760 -8480 {}
L 6 760 -8480 850 -8480 {}
L 6 520 -8480 760 -8480 {}
L 6 1140 -8590 1260 -8590 {}
L 6 1300 -8650 1300 -8620 {}
L 6 1300 -8740 1300 -8710 {}
L 6 1300 -8620 1440 -8620 {}
L 6 1390 -8560 1390 -8480 {}
L 6 1060 -8500 1060 -8480 {}
L 6 1060 -8740 1060 -8560 {}
L 6 1300 -8590 1300 -8480 {}
L 6 1300 -8480 1390 -8480 {}
L 6 1060 -8480 1300 -8480 {}
L 6 2270 -8590 2390 -8590 {}
L 6 2430 -8650 2430 -8620 {}
L 6 2430 -8740 2430 -8710 {}
L 6 2430 -8620 2570 -8620 {}
L 6 2520 -8560 2520 -8480 {}
L 6 2190 -8500 2190 -8480 {}
L 6 2190 -8740 2190 -8560 {}
L 6 2430 -8590 2430 -8480 {}
L 6 2430 -8480 2520 -8480 {}
L 6 2190 -8480 2430 -8480 {}
L 6 690 -3500 690 -3320 {}
L 6 1230 -3500 1230 -3320 {}
L 6 1880 -3500 1880 -3440 {}
L 6 1880 -3380 1880 -3320 {}
L 6 1110 -10730 1230 -10730 {}
L 6 1030 -10880 1270 -10880 {}
L 6 1270 -10760 1410 -10760 {}
L 6 1030 -10620 1270 -10620 {}
L 6 1030 -10640 1030 -10620 {}
L 6 1030 -10880 1030 -10700 {}
L 6 660 -900 780 -900 {}
L 6 820 -960 820 -930 {}
L 6 820 -1050 820 -1020 {}
L 6 580 -1050 820 -1050 {}
L 6 820 -930 960 -930 {}
L 6 910 -870 910 -790 {}
L 6 580 -810 580 -790 {}
L 6 580 -1050 580 -870 {}
L 6 820 -900 820 -790 {}
L 6 820 -790 910 -790 {}
L 6 580 -790 820 -790 {}
L 6 1260 -900 1380 -900 {}
L 6 1420 -960 1420 -930 {}
L 6 1420 -1050 1420 -1020 {}
L 6 1180 -1050 1420 -1050 {}
L 6 1180 -1050 1180 -870 {}
L 6 1870 -900 1990 -900 {}
L 6 2030 -960 2030 -930 {}
L 6 2030 -1050 2030 -1020 {}
L 6 1790 -1050 2030 -1050 {}
L 6 1790 -1050 1790 -870 {}
L 6 600 -4960 720 -4960 {}
L 6 760 -5020 760 -4990 {}
L 6 760 -5110 760 -5080 {}
L 6 520 -5110 760 -5110 {}
L 6 760 -4990 900 -4990 {}
L 6 520 -4870 520 -4850 {}
L 6 520 -5110 520 -4930 {}
L 6 760 -4960 760 -4850 {}
L 6 760 -4850 850 -4850 {}
L 6 520 -4850 760 -4850 {}
L 6 1160 -4960 1280 -4960 {}
L 6 1320 -5020 1320 -4990 {}
L 6 1320 -5110 1320 -5080 {}
L 6 1080 -5110 1320 -5110 {}
L 6 1320 -4990 1460 -4990 {}
L 6 1080 -4870 1080 -4850 {}
L 6 1080 -5110 1080 -4930 {}
L 6 1320 -4960 1320 -4850 {}
L 6 1320 -4850 1410 -4850 {}
L 6 1080 -4850 1320 -4850 {}
L 6 545 -9010 665 -9010 {}
L 6 705 -9070 705 -9040 {}
L 6 705 -9160 705 -9130 {}
L 6 795 -8980 795 -8900 {}
L 6 465 -8920 465 -8900 {}
L 6 465 -9160 465 -8980 {}
L 6 705 -9010 705 -8900 {}
L 6 705 -8900 795 -8900 {}
L 6 465 -8900 705 -8900 {}
L 6 1110 -9010 1230 -9010 {}
L 6 1270 -9070 1270 -9040 {}
L 6 1270 -9160 1270 -9130 {}
L 6 1360 -8980 1360 -8900 {}
L 6 1030 -8920 1030 -8900 {}
L 6 1030 -9160 1030 -8980 {}
L 6 1270 -9010 1270 -8900 {}
L 6 1270 -8900 1360 -8900 {}
L 6 1030 -8900 1270 -8900 {}
L 6 1610 -9010 1730 -9010 {}
L 6 1770 -9070 1770 -9040 {}
L 6 1770 -9160 1770 -9130 {}
L 6 1860 -8980 1860 -8900 {}
L 6 1530 -8920 1530 -8900 {}
L 6 1530 -9160 1530 -8980 {}
L 6 1770 -9010 1770 -8900 {}
L 6 1770 -8900 1860 -8900 {}
L 6 1530 -8900 1770 -8900 {}
L 6 2100 -9010 2220 -9010 {}
L 6 2260 -9070 2260 -9040 {}
L 6 2260 -9160 2260 -9130 {}
L 6 2350 -8980 2350 -8900 {}
L 6 2020 -8920 2020 -8900 {}
L 6 2020 -9160 2020 -8980 {}
L 6 2260 -9010 2260 -8900 {}
L 6 2260 -8900 2350 -8900 {}
L 6 2020 -8900 2260 -8900 {}
L 7 600 -6760 620 -6760 {dash=3}
L 7 610 -6770 610 -6750 {dash=3}
L 7 600 -6630 620 -6630 {dash=3}
L 7 610 -6640 610 -6620 {dash=3}
L 7 600 -6520 620 -6520 {dash=3}
L 7 610 -6530 610 -6510 {dash=3}
L 7 920 -6760 940 -6760 {dash=3}
L 7 930 -6770 930 -6750 {dash=3}
L 7 920 -6630 940 -6630 {dash=3}
L 7 930 -6640 930 -6620 {dash=3}
L 7 920 -6520 940 -6520 {dash=3}
L 7 930 -6530 930 -6510 {dash=3}
L 7 1510 -670 1510 -350 {dash=3}
L 7 1260 -520 1780 -520 {dash=3}
L 9 0 -5660 2670 -5660 {dash=4}
L 9 0 -6050 2670 -6050 {dash=4}
L 9 0 -9210 2670 -9210 {dash=4}
L 9 0 -10040 2670 -10040 {dash=4}
L 9 0 -9650 2670 -9650 {dash=4}
L 9 0 -10490 2670 -10490 {dash=4}
L 9 0 -4370 2670 -4370 {dash=4}
L 9 0 -4750 2670 -4750 {dash=4}
L 9 0 -5180 2670 -5180 {dash=4}
L 9 0 -3950 2670 -3950 {dash=4}
L 9 0 -3570 2670 -3570 {dash=4}
L 9 0 -1540 2670 -1540 {dash=4}
L 9 0 -3250 2670 -3250 {dash=4}
L 9 0 -2310 2670 -2310 {dash=4}
L 9 0 -1940 2670 -1940 {dash=4}
L 9 0 -1140 2670 -1140 {dash=4}
L 9 0 -710 2670 -710 {dash=4}
L 9 0 -3020 2670 -3020 {dash=4}
L 9 0 -2650 2670 -2650 {dash=4}
L 9 0 -8430 2670 -8430 {dash=4}
L 9 0 -8860 2670 -8860 {dash=4}
L 9 0 -8040 2670 -8040 {dash=4}
L 9 0 -7650 2670 -7650 {dash=4}
L 9 0 -7230 2670 -7230 {dash=4}
L 9 0 -6840 2670 -6840 {dash=4}
L 9 0 -6440 2670 -6440 {dash=4}
L 9 490 -8360 490 -8110 {dash=4}
L 9 710 -8360 710 -8110 {dash=4}
L 9 1000 -8360 1000 -8110 {dash=4}
L 9 1240 -8360 1240 -8110 {dash=4}
L 9 1520 -8360 1520 -8110 {dash=4}
L 9 1760 -8360 1760 -8110 {dash=4}
L 9 2070 -8360 2070 -8110 {dash=4}
L 9 2310 -8360 2310 -8110 {dash=4}
L 9 980 -9155 980 -8905 {dash=4}
L 9 1490 -9155 1490 -8905 {dash=4}
L 9 1965 -9155 1965 -8905 {dash=4}
L 9 975 -9565 975 -9315 {dash=4}
L 9 1460 -9565 1460 -9315 {dash=4}
L 9 930 -10855 930 -10605 {dash=4}
L 9 1475 -10855 1475 -10605 {dash=4}
L 9 1990 -10855 1990 -10605 {dash=4}
L 9 975 -10405 975 -10155 {dash=4}
L 9 1480 -10405 1480 -10155 {dash=4}
L 9 960 -9965 960 -9715 {dash=4}
L 9 970 -8745 970 -8495 {dash=4}
L 9 1545 -8745 1545 -8495 {dash=4}
L 9 2070 -8745 2070 -8495 {dash=4}
L 9 920 -7580 920 -7330 {dash=4}
L 9 1435 -7580 1435 -7330 {dash=4}
L 9 920 -7165 920 -6915 {dash=4}
L 9 1435 -7165 1435 -6915 {dash=4}
L 9 765 -6770 765 -6520 {dash=4}
L 9 960 -6370 960 -6120 {dash=4}
L 9 955 -5990 955 -5740 {dash=4}
L 9 1000 -5550 1000 -5300 {dash=4}
L 9 1610 -5550 1610 -5300 {dash=4}
L 9 990 -5110 990 -4860 {dash=4}
L 9 1080 -4660 1080 -4410 {dash=4}
L 9 1650 -4660 1650 -4410 {dash=4}
L 9 1080 -4270 1080 -4020 {dash=4}
L 9 1650 -4270 1650 -4020 {dash=4}
L 9 2230 -4270 2230 -4020 {dash=4}
L 9 1080 -3890 1080 -3640 {dash=4}
L 9 1680 -3890 1680 -3640 {dash=4}
L 9 2230 -3890 2230 -3640 {dash=4}
L 9 960 -3540 960 -3290 {dash=4}
L 9 1480 -3530 1480 -3280 {dash=4}
L 9 970 -3180 970 -3070 {dash=4}
L 9 1610 -3180 1610 -3070 {dash=4}
L 9 2130 -3180 2130 -3070 {dash=4}
L 9 1000 -2940 1000 -2690 {dash=4}
L 9 1620 -2940 1620 -2690 {dash=4}
L 9 2160 -2940 2160 -2690 {dash=4}
L 9 990 -2580 990 -2330 {dash=4}
L 9 1580 -2580 1580 -2330 {dash=4}
L 9 2210 -2580 2210 -2330 {dash=4}
L 9 1000 -2260 1000 -2010 {dash=4}
L 9 1570 -2260 1570 -2010 {dash=4}
L 9 1070 -1850 1070 -1600 {dash=4}
L 9 1680 -1850 1680 -1600 {dash=4}
L 9 1060 -1460 1060 -1210 {dash=4}
L 9 1660 -1460 1660 -1210 {dash=4}
L 9 1060 -1080 1060 -830 {dash=4}
L 9 1720 -1070 1720 -820 {dash=4}
L 9 0 -310 2670 -310 {dash=4}
L 9 1030 -640 1030 -390 {dash=4}
L 9 1970 -640 1970 -390 {dash=4}
L 9 1260 -290 1260 -40 {dash=4}
L 9 1830 -290 1830 -40 {dash=4}
L 9 0 0 2670 0 {dash=4}
B 1 1790 -8650 1820 -8500 {}
B 2 660 -10430 860 -10110 {}
B 2 1267.5 -10292.5 1272.5 -10287.5 {name=d dir=inout}
B 2 1227.5 -10262.5 1232.5 -10257.5 {name=g dir=in}
B 2 1267.5 -10232.5 1272.5 -10227.5 {name=s dir=inout}
B 2 1267.5 -10262.5 1272.5 -10257.5 {name=b dir=in}
B 2 1267.5 -10382.5 1272.5 -10377.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -10322.5 1272.5 -10317.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -10292.5 1362.5 -10287.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -10232.5 1362.5 -10227.5 {name=m dir=inout pinnumber=2}
B 2 2047.5 -10302.5 2052.5 -10297.5 {name=d dir=inout}
B 2 2007.5 -10272.5 2012.5 -10267.5 {name=g dir=in}
B 2 2047.5 -10242.5 2052.5 -10237.5 {name=s dir=inout}
B 2 2047.5 -10272.5 2052.5 -10267.5 {name=b dir=in}
B 2 2047.5 -10392.5 2052.5 -10387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2047.5 -10332.5 2052.5 -10327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2137.5 -10302.5 2142.5 -10297.5 {name=p dir=inout pinnumber=1}
B 2 2137.5 -10242.5 2142.5 -10237.5 {name=m dir=inout pinnumber=2}
B 2 1357.5 -9922.5 1362.5 -9917.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -9862.5 1362.5 -9857.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -6332.5 1362.5 -6327.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -6272.5 1362.5 -6267.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -5932.5 1362.5 -5927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -5872.5 1362.5 -5867.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 660 -5550 900 -5230 {}
B 2 737.5 -10292.5 742.5 -10287.5 {name=d dir=inout}
B 2 737.5 -10232.5 742.5 -10227.5 {name=s dir=inout}
B 2 737.5 -10262.5 742.5 -10257.5 {name=b dir=in}
B 2 737.5 -10382.5 742.5 -10377.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -10322.5 742.5 -10317.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -10292.5 832.5 -10287.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -10232.5 832.5 -10227.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -5402.5 742.5 -5397.5 {name=d dir=inout}
B 2 737.5 -5342.5 742.5 -5337.5 {name=s dir=inout}
B 2 737.5 -5372.5 742.5 -5367.5 {name=b dir=in}
B 2 737.5 -5492.5 742.5 -5487.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -5432.5 742.5 -5427.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -5402.5 832.5 -5397.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -5342.5 832.5 -5337.5 {name=m dir=inout pinnumber=2}
B 2 878.75 -5401.25 881.25 -5398.75 {name=p dir=in}
B 2 1297.5 -5402.5 1302.5 -5397.5 {name=d dir=inout}
B 2 1257.5 -5372.5 1262.5 -5367.5 {name=g dir=in}
B 2 1297.5 -5342.5 1302.5 -5337.5 {name=s dir=inout}
B 2 1297.5 -5372.5 1302.5 -5367.5 {name=b dir=in}
B 2 1297.5 -5492.5 1302.5 -5487.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1297.5 -5432.5 1302.5 -5427.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1387.5 -5402.5 1392.5 -5397.5 {name=p dir=inout pinnumber=1}
B 2 1387.5 -5342.5 1392.5 -5337.5 {name=m dir=inout pinnumber=2}
B 2 1438.75 -5401.25 1441.25 -5398.75 {name=p dir=in}
B 2 2117.5 -5402.5 2122.5 -5397.5 {name=d dir=inout}
B 2 2077.5 -5372.5 2082.5 -5367.5 {name=g dir=in}
B 2 2117.5 -5342.5 2122.5 -5337.5 {name=s dir=inout}
B 2 2117.5 -5372.5 2122.5 -5367.5 {name=b dir=in}
B 2 2117.5 -5492.5 2122.5 -5487.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2117.5 -5432.5 2122.5 -5427.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2207.5 -5402.5 2212.5 -5397.5 {name=p dir=inout pinnumber=1}
B 2 2207.5 -5342.5 2212.5 -5337.5 {name=m dir=inout pinnumber=2}
B 2 2258.75 -5401.25 2261.25 -5398.75 {name=p dir=in}
B 2 660 -9600 860 -9280 {}
B 2 1267.5 -9462.5 1272.5 -9457.5 {name=d dir=inout}
B 2 1227.5 -9432.5 1232.5 -9427.5 {name=g dir=in}
B 2 1267.5 -9402.5 1272.5 -9397.5 {name=s dir=inout}
B 2 1267.5 -9432.5 1272.5 -9427.5 {name=b dir=in}
B 2 1267.5 -9552.5 1272.5 -9547.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -9492.5 1272.5 -9487.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -9462.5 1362.5 -9457.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -9402.5 1362.5 -9397.5 {name=m dir=inout pinnumber=2}
B 2 2047.5 -9472.5 2052.5 -9467.5 {name=d dir=inout}
B 2 2007.5 -9442.5 2012.5 -9437.5 {name=g dir=in}
B 2 2047.5 -9412.5 2052.5 -9407.5 {name=s dir=inout}
B 2 2047.5 -9442.5 2052.5 -9437.5 {name=b dir=in}
B 2 2047.5 -9562.5 2052.5 -9557.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2047.5 -9502.5 2052.5 -9497.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2137.5 -9472.5 2142.5 -9467.5 {name=p dir=inout pinnumber=1}
B 2 2137.5 -9412.5 2142.5 -9407.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -9462.5 742.5 -9457.5 {name=d dir=inout}
B 2 737.5 -9402.5 742.5 -9397.5 {name=s dir=inout}
B 2 737.5 -9432.5 742.5 -9427.5 {name=b dir=in}
B 2 737.5 -9552.5 742.5 -9547.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -9492.5 742.5 -9487.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -9462.5 832.5 -9457.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -9402.5 832.5 -9397.5 {name=m dir=inout pinnumber=2}
B 2 605 -10900 805 -10580 {}
B 2 1807.5 -10762.5 1812.5 -10757.5 {name=d dir=inout}
B 2 1767.5 -10732.5 1772.5 -10727.5 {name=g dir=in}
B 2 1807.5 -10702.5 1812.5 -10697.5 {name=s dir=inout}
B 2 1807.5 -10732.5 1812.5 -10727.5 {name=b dir=in}
B 2 1807.5 -10852.5 1812.5 -10847.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1807.5 -10792.5 1812.5 -10787.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -10762.5 1902.5 -10757.5 {name=p dir=inout pinnumber=1}
B 2 1897.5 -10702.5 1902.5 -10697.5 {name=m dir=inout pinnumber=2}
B 2 682.5 -10762.5 687.5 -10757.5 {name=d dir=inout}
B 2 682.5 -10702.5 687.5 -10697.5 {name=s dir=inout}
B 2 682.5 -10732.5 687.5 -10727.5 {name=b dir=in}
B 2 682.5 -10852.5 687.5 -10847.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 682.5 -10792.5 687.5 -10787.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 772.5 -10762.5 777.5 -10757.5 {name=p dir=inout pinnumber=1}
B 2 772.5 -10702.5 777.5 -10697.5 {name=m dir=inout pinnumber=2}
B 2 1530 -10890 1610 -10610 {}
B 2 1567.5 -10702.5 1572.5 -10697.5 {name=p dir=inout}
B 2 1567.5 -10642.5 1572.5 -10637.5 {name=m dir=inout}
B 2 2267.5 -10762.5 2272.5 -10757.5 {name=d dir=inout}
B 2 2227.5 -10732.5 2232.5 -10727.5 {name=g dir=in}
B 2 2267.5 -10702.5 2272.5 -10697.5 {name=s dir=inout}
B 2 2267.5 -10732.5 2272.5 -10727.5 {name=b dir=in}
B 2 2267.5 -10852.5 2272.5 -10847.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2267.5 -10792.5 2272.5 -10787.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2027.5 -10702.5 2032.5 -10697.5 {name=p dir=inout}
B 2 2027.5 -10642.5 2032.5 -10637.5 {name=m dir=inout}
B 2 2320 -10780 2390 -10600 {}
B 2 1670 -8680 1820 -8650 {}
B 2 1357.5 -4532.5 1362.5 -4527.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -4472.5 1362.5 -4467.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1210 -3860 1500 -3790 {}
B 2 1210 -1780 1500 -1700 {}
B 2 1247.5 -1772.5 1252.5 -1767.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1247.5 -1712.5 1252.5 -1707.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -1772.5 1362.5 -1767.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -1712.5 1362.5 -1707.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1467.5 -1772.5 1472.5 -1767.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1467.5 -1712.5 1472.5 -1707.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1787.5 -1822.5 1792.5 -1817.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1787.5 -1762.5 1792.5 -1757.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -1822.5 1902.5 -1817.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1897.5 -1762.5 1902.5 -1757.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2007.5 -1822.5 2012.5 -1817.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2007.5 -1762.5 2012.5 -1757.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 647.5 -3442.5 652.5 -3437.5 {name=d dir=inout}
B 2 607.5 -3412.5 612.5 -3407.5 {name=g dir=in}
B 2 647.5 -3382.5 652.5 -3377.5 {name=s dir=inout}
B 2 647.5 -3412.5 652.5 -3407.5 {name=b dir=in}
B 2 1227.5 -3442.5 1232.5 -3437.5 {name=d dir=inout}
B 2 1187.5 -3412.5 1192.5 -3407.5 {name=g dir=in}
B 2 1227.5 -3382.5 1232.5 -3377.5 {name=s dir=inout}
B 2 1227.5 -3412.5 1232.5 -3407.5 {name=b dir=in}
B 2 1267.5 -10762.5 1272.5 -10757.5 {name=d dir=inout}
B 2 1227.5 -10732.5 1232.5 -10727.5 {name=g dir=in}
B 2 1267.5 -10702.5 1272.5 -10697.5 {name=s dir=inout}
B 2 1267.5 -10732.5 1272.5 -10727.5 {name=b dir=in}
B 2 1267.5 -10852.5 1272.5 -10847.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -10792.5 1272.5 -10787.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -10762.5 1362.5 -10757.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -10702.5 1362.5 -10697.5 {name=m dir=inout pinnumber=2}
B 2 1210 -1400 1500 -1320 {}
B 2 1247.5 -1392.5 1252.5 -1387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1247.5 -1332.5 1252.5 -1327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -1392.5 1362.5 -1387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -1332.5 1362.5 -1327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1467.5 -1392.5 1472.5 -1387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1467.5 -1332.5 1472.5 -1327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1787.5 -1442.5 1792.5 -1437.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1787.5 -1382.5 1792.5 -1377.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -1442.5 1902.5 -1437.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1897.5 -1382.5 1902.5 -1377.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2007.5 -1442.5 2012.5 -1437.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2007.5 -1382.5 2012.5 -1377.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 677.5 -2212.5 682.5 -2207.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 677.5 -2152.5 682.5 -2147.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 797.5 -2212.5 802.5 -2207.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1217.5 -2212.5 1222.5 -2207.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1217.5 -2152.5 1222.5 -2147.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1337.5 -2212.5 1342.5 -2207.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1337.5 -2152.5 1342.5 -2147.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1507.5 -932.5 1512.5 -927.5 {name=p dir=inout pinnumber=1}
B 2 1507.5 -872.5 1512.5 -867.5 {name=m dir=inout pinnumber=2}
B 2 2427.5 -1112.5 2432.5 -1107.5 {name=p dir=inout pinnumber=1}
B 2 2427.5 -1052.5 2432.5 -1047.5 {name=m dir=inout pinnumber=2}
B 2 820 -5010 870 -4830 {}
B 2 847.5 -4992.5 852.5 -4987.5 {name=p dir=inout pinnumber=1}
B 2 847.5 -4932.5 852.5 -4927.5 {name=m dir=inout pinnumber=2}
B 2 1707.5 -4992.5 1712.5 -4987.5 {name=p dir=inout pinnumber=1}
B 2 1707.5 -4932.5 1712.5 -4927.5 {name=m dir=inout pinnumber=2}
B 2 2467.5 -4992.5 2472.5 -4987.5 {name=p dir=inout pinnumber=1}
B 2 2467.5 -4932.5 2472.5 -4927.5 {name=m dir=inout pinnumber=2}
B 2 527.5 -7982.5 532.5 -7977.5 {name=d dir=inout}
B 2 487.5 -7952.5 492.5 -7947.5 {name=g dir=in}
B 2 527.5 -7922.5 532.5 -7917.5 {name=s dir=inout}
B 2 527.5 -7952.5 532.5 -7947.5 {name=b dir=in}
B 2 458.75 -7951.25 461.25 -7948.75 {name=p dir=out}
B 2 847.5 -7882.5 852.5 -7877.5 {name=d dir=inout}
B 2 817.5 -7922.5 822.5 -7917.5 {name=g dir=in}
B 2 787.5 -7882.5 792.5 -7877.5 {name=s dir=inout}
B 2 817.5 -7882.5 822.5 -7877.5 {name=b dir=in}
B 2 818.75 -7951.25 821.25 -7948.75 {name=p dir=out}
B 2 1097.5 -7852.5 1102.5 -7847.5 {name=d dir=inout}
B 2 1137.5 -7882.5 1142.5 -7877.5 {name=g dir=in}
B 2 1097.5 -7912.5 1102.5 -7907.5 {name=s dir=inout}
B 2 1097.5 -7882.5 1102.5 -7877.5 {name=b dir=in}
B 2 1168.75 -7881.25 1171.25 -7878.75 {name=p dir=out}
B 2 1377.5 -7962.5 1382.5 -7957.5 {name=d dir=inout}
B 2 1407.5 -7922.5 1412.5 -7917.5 {name=g dir=in}
B 2 1437.5 -7962.5 1442.5 -7957.5 {name=s dir=inout}
B 2 1407.5 -7962.5 1412.5 -7957.5 {name=b dir=in}
B 2 1408.75 -7891.25 1411.25 -7888.75 {name=p dir=out}
B 2 1777.5 -7962.5 1782.5 -7957.5 {name=d dir=inout}
B 2 1747.5 -7922.5 1752.5 -7917.5 {name=g dir=in}
B 2 1717.5 -7962.5 1722.5 -7957.5 {name=s dir=inout}
B 2 1747.5 -7962.5 1752.5 -7957.5 {name=b dir=in}
B 2 1748.75 -7891.25 1751.25 -7888.75 {name=p dir=out}
B 2 2107.5 -7892.5 2112.5 -7887.5 {name=d dir=inout}
B 2 2077.5 -7932.5 2082.5 -7927.5 {name=g dir=in}
B 2 2047.5 -7892.5 2052.5 -7887.5 {name=s dir=inout}
B 2 2077.5 -7892.5 2082.5 -7887.5 {name=b dir=in}
B 2 2078.75 -7961.25 2081.25 -7958.75 {name=p dir=out}
B 2 767.5 -7482.5 772.5 -7477.5 {name=d dir=inout}
B 2 727.5 -7452.5 732.5 -7447.5 {name=g dir=in}
B 2 767.5 -7422.5 772.5 -7417.5 {name=s dir=inout}
B 2 767.5 -7452.5 772.5 -7447.5 {name=b dir=in}
B 2 767.5 -7572.5 772.5 -7567.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 767.5 -7512.5 772.5 -7507.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 857.5 -7482.5 862.5 -7477.5 {name=p dir=inout pinnumber=1}
B 2 857.5 -7422.5 862.5 -7417.5 {name=m dir=inout pinnumber=2}
B 2 527.5 -7422.5 532.5 -7417.5 {name=p dir=inout}
B 2 527.5 -7362.5 532.5 -7357.5 {name=m dir=inout}
B 2 608.75 -7451.25 611.25 -7448.75 {name=p dir=out}
B 2 637.5 -7342.5 642.5 -7337.5 {name=p dir=inout goto=0}
B 2 637.5 -7602.5 642.5 -7597.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1242.5 -7482.5 1247.5 -7477.5 {name=d dir=inout}
B 2 1202.5 -7452.5 1207.5 -7447.5 {name=g dir=in}
B 2 1242.5 -7422.5 1247.5 -7417.5 {name=s dir=inout}
B 2 1242.5 -7452.5 1247.5 -7447.5 {name=b dir=in}
B 2 1242.5 -7572.5 1247.5 -7567.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1242.5 -7512.5 1247.5 -7507.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1332.5 -7482.5 1337.5 -7477.5 {name=p dir=inout pinnumber=1}
B 2 1332.5 -7422.5 1337.5 -7417.5 {name=m dir=inout pinnumber=2}
B 2 1002.5 -7422.5 1007.5 -7417.5 {name=p dir=inout}
B 2 1002.5 -7362.5 1007.5 -7357.5 {name=m dir=inout}
B 2 1083.75 -7451.25 1086.25 -7448.75 {name=p dir=out}
B 2 1112.5 -7342.5 1117.5 -7337.5 {name=p dir=inout goto=0}
B 2 1112.5 -7602.5 1117.5 -7597.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1727.5 -7362.5 1732.5 -7357.5 {name=d dir=inout}
B 2 1697.5 -7402.5 1702.5 -7397.5 {name=g dir=in}
B 2 1667.5 -7362.5 1672.5 -7357.5 {name=s dir=inout}
B 2 1697.5 -7362.5 1702.5 -7357.5 {name=b dir=in}
B 2 1817.5 -7362.5 1822.5 -7357.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1757.5 -7362.5 1762.5 -7357.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1727.5 -7272.5 1732.5 -7267.5 {name=p dir=inout pinnumber=1}
B 2 1667.5 -7272.5 1672.5 -7267.5 {name=m dir=inout pinnumber=2}
B 2 1667.5 -7602.5 1672.5 -7597.5 {name=p dir=inout}
B 2 1607.5 -7602.5 1612.5 -7597.5 {name=m dir=inout}
B 2 1698.75 -7521.25 1701.25 -7518.75 {name=p dir=out}
B 2 1587.5 -7492.5 1592.5 -7487.5 {name=p dir=inout goto=0}
B 2 1847.5 -7492.5 1852.5 -7487.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 767.5 -7052.5 772.5 -7047.5 {name=d dir=inout}
B 2 727.5 -7022.5 732.5 -7017.5 {name=g dir=in}
B 2 767.5 -6992.5 772.5 -6987.5 {name=s dir=inout}
B 2 767.5 -7022.5 772.5 -7017.5 {name=b dir=in}
B 2 767.5 -7142.5 772.5 -7137.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 767.5 -7082.5 772.5 -7077.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 857.5 -7052.5 862.5 -7047.5 {name=p dir=inout pinnumber=1}
B 2 857.5 -6992.5 862.5 -6987.5 {name=m dir=inout pinnumber=2}
B 2 527.5 -6992.5 532.5 -6987.5 {name=p dir=inout}
B 2 527.5 -6932.5 532.5 -6927.5 {name=m dir=inout}
B 2 608.75 -7021.25 611.25 -7018.75 {name=p dir=out}
B 2 637.5 -6912.5 642.5 -6907.5 {name=p dir=inout goto=0}
B 2 637.5 -7172.5 642.5 -7167.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1217.5 -7052.5 1222.5 -7047.5 {name=d dir=inout}
B 2 1177.5 -7022.5 1182.5 -7017.5 {name=g dir=in}
B 2 1217.5 -6992.5 1222.5 -6987.5 {name=s dir=inout}
B 2 1217.5 -7022.5 1222.5 -7017.5 {name=b dir=in}
B 2 1217.5 -7142.5 1222.5 -7137.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1217.5 -7082.5 1222.5 -7077.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1307.5 -7052.5 1312.5 -7047.5 {name=p dir=inout pinnumber=1}
B 2 1307.5 -6992.5 1312.5 -6987.5 {name=m dir=inout pinnumber=2}
B 2 977.5 -6992.5 982.5 -6987.5 {name=p dir=inout}
B 2 977.5 -6932.5 982.5 -6927.5 {name=m dir=inout}
B 2 1058.75 -7021.25 1061.25 -7018.75 {name=p dir=out}
B 2 1087.5 -6912.5 1092.5 -6907.5 {name=p dir=inout goto=0}
B 2 1087.5 -7172.5 1092.5 -7167.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1597.5 -7052.5 1602.5 -7047.5 {name=d dir=inout}
B 2 1637.5 -7022.5 1642.5 -7017.5 {name=g dir=in}
B 2 1597.5 -6992.5 1602.5 -6987.5 {name=s dir=inout}
B 2 1597.5 -7022.5 1602.5 -7017.5 {name=b dir=in}
B 2 1597.5 -7142.5 1602.5 -7137.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1597.5 -7082.5 1602.5 -7077.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1507.5 -7052.5 1512.5 -7047.5 {name=p dir=inout pinnumber=1}
B 2 1507.5 -6992.5 1512.5 -6987.5 {name=m dir=inout pinnumber=2}
B 2 1837.5 -6992.5 1842.5 -6987.5 {name=p dir=inout}
B 2 1837.5 -6932.5 1842.5 -6927.5 {name=m dir=inout}
B 2 1758.75 -7021.25 1761.25 -7018.75 {name=p dir=out}
B 2 1727.5 -6912.5 1732.5 -6907.5 {name=p dir=inout goto=0}
B 2 1727.5 -7172.5 1732.5 -7167.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 607.5 -6792.5 612.5 -6787.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 607.5 -6732.5 612.5 -6727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 607.5 -6662.5 612.5 -6657.5 {name=p dir=inout pinnumber=1}
B 2 607.5 -6602.5 612.5 -6597.5 {name=m dir=inout pinnumber=2}
B 2 607.5 -6552.5 612.5 -6547.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 607.5 -6492.5 612.5 -6487.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 957.5 -6762.5 962.5 -6757.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 897.5 -6762.5 902.5 -6757.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 957.5 -6632.5 962.5 -6627.5 {name=p dir=inout pinnumber=1}
B 2 897.5 -6632.5 902.5 -6627.5 {name=m dir=inout pinnumber=2}
B 2 957.5 -6522.5 962.5 -6517.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 897.5 -6522.5 902.5 -6517.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1507.5 -262.5 1512.5 -257.5 {name=SIG_IN dir=in }
B 2 1507.5 -242.5 1512.5 -237.5 {name=VREF dir=in }
B 2 1507.5 -222.5 1512.5 -217.5 {name=CK dir=in }
B 2 1507.5 -202.5 1512.5 -197.5 {name=RST dir=in }
B 2 1438.75 -261.25 1441.25 -258.75 {name=p dir=in}
B 2 1438.75 -241.25 1441.25 -238.75 {name=p dir=in}
B 2 1438.75 -221.25 1441.25 -218.75 {name=p dir=in}
B 2 1438.75 -201.25 1441.25 -198.75 {name=p dir=in}
B 2 2037.5 -262.5 2042.5 -257.5 {name=SIG_IN dir=in }
B 2 2037.5 -242.5 2042.5 -237.5 {name=VREF dir=in }
B 2 2037.5 -222.5 2042.5 -217.5 {name=CK dir=in }
B 2 2037.5 -202.5 2042.5 -197.5 {name=RST dir=in }
B 2 2288.75 -261.25 2291.25 -258.75 {name=p dir=in}
B 2 1097.5 -262.5 1102.5 -257.5 {name=CODE[5:0] dir=out }
B 2 937.5 -262.5 942.5 -257.5 {name=SIG_IN dir=in }
B 2 937.5 -242.5 942.5 -237.5 {name=VREF dir=in }
B 2 937.5 -222.5 942.5 -217.5 {name=CK dir=in }
B 2 937.5 -202.5 942.5 -197.5 {name=RST dir=in }
B 2 677.5 -262.5 682.5 -257.5 {name=CODE[5:0] dir=out }
B 2 517.5 -262.5 522.5 -257.5 {name=SIG_IN dir=in }
B 2 517.5 -242.5 522.5 -237.5 {name=VREF dir=in }
B 2 517.5 -222.5 522.5 -217.5 {name=CK dir=in }
B 2 517.5 -202.5 522.5 -197.5 {name=RST dir=in }
B 4 2140 -11270 2650 -10930 {fill=0}
B 5 1027.5 -10232.5 1032.5 -10227.5 {name=p dir=inout}
B 5 1027.5 -10172.5 1032.5 -10167.5 {name=m dir=inout}
B 5 1108.75 -10261.25 1111.25 -10258.75 {name=p dir=out}
B 5 1137.5 -10152.5 1142.5 -10147.5 {name=p dir=inout goto=0}
B 5 1137.5 -10412.5 1142.5 -10407.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -10291.25 1411.25 -10288.75 {name=p dir=in}
B 5 1567.5 -10232.5 1572.5 -10227.5 {name=p dir=inout}
B 5 1567.5 -10172.5 1572.5 -10167.5 {name=m dir=inout}
B 5 1648.75 -10261.25 1651.25 -10258.75 {name=p dir=out}
B 5 1677.5 -10152.5 1682.5 -10147.5 {name=p dir=inout goto=0}
B 5 1677.5 -10412.5 1682.5 -10407.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1948.75 -10291.25 1951.25 -10288.75 {name=p dir=in}
B 5 697.5 -10262.5 702.5 -10257.5 {name=g dir=in}
B 5 497.5 -10232.5 502.5 -10227.5 {name=p dir=inout}
B 5 497.5 -10172.5 502.5 -10167.5 {name=m dir=inout}
B 5 578.75 -10261.25 581.25 -10258.75 {name=p dir=out}
B 5 607.5 -10152.5 612.5 -10147.5 {name=p dir=inout goto=0}
B 5 607.5 -10412.5 612.5 -10407.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -10291.25 881.25 -10288.75 {name=p dir=in}
B 5 737.5 -9832.5 742.5 -9827.5 {name=d dir=inout}
B 5 697.5 -9802.5 702.5 -9797.5 {name=g dir=in}
B 5 737.5 -9772.5 742.5 -9767.5 {name=s dir=inout}
B 5 737.5 -9802.5 742.5 -9797.5 {name=b dir=in}
B 5 737.5 -9922.5 742.5 -9917.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -9862.5 742.5 -9857.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -9832.5 832.5 -9827.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -9772.5 832.5 -9767.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -9772.5 502.5 -9767.5 {name=p dir=inout}
B 5 497.5 -9712.5 502.5 -9707.5 {name=m dir=inout}
B 5 578.75 -9801.25 581.25 -9798.75 {name=p dir=out}
B 5 607.5 -9692.5 612.5 -9687.5 {name=p dir=inout goto=0}
B 5 607.5 -9952.5 612.5 -9947.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -9831.25 881.25 -9828.75 {name=p dir=in}
B 5 1277.5 -9832.5 1282.5 -9827.5 {name=d dir=inout}
B 5 1237.5 -9802.5 1242.5 -9797.5 {name=g dir=in}
B 5 1277.5 -9772.5 1282.5 -9767.5 {name=s dir=inout}
B 5 1277.5 -9802.5 1282.5 -9797.5 {name=b dir=in}
B 5 1367.5 -9832.5 1372.5 -9827.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -9772.5 1372.5 -9767.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -9772.5 1042.5 -9767.5 {name=p dir=inout}
B 5 1037.5 -9712.5 1042.5 -9707.5 {name=m dir=inout}
B 5 1118.75 -9801.25 1121.25 -9798.75 {name=p dir=out}
B 5 1147.5 -9692.5 1152.5 -9687.5 {name=p dir=inout goto=0}
B 5 1147.5 -9952.5 1152.5 -9947.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -9831.25 1421.25 -9828.75 {name=p dir=in}
B 5 737.5 -6242.5 742.5 -6237.5 {name=d dir=inout}
B 5 697.5 -6212.5 702.5 -6207.5 {name=g dir=in}
B 5 737.5 -6182.5 742.5 -6177.5 {name=s dir=inout}
B 5 737.5 -6212.5 742.5 -6207.5 {name=b dir=in}
B 5 737.5 -6332.5 742.5 -6327.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -6272.5 742.5 -6267.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -6242.5 832.5 -6237.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -6182.5 832.5 -6177.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -6182.5 502.5 -6177.5 {name=p dir=inout}
B 5 497.5 -6122.5 502.5 -6117.5 {name=m dir=inout}
B 5 578.75 -6211.25 581.25 -6208.75 {name=p dir=out}
B 5 607.5 -6102.5 612.5 -6097.5 {name=p dir=inout goto=0}
B 5 607.5 -6362.5 612.5 -6357.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -6241.25 881.25 -6238.75 {name=p dir=in}
B 5 1277.5 -6242.5 1282.5 -6237.5 {name=d dir=inout}
B 5 1237.5 -6212.5 1242.5 -6207.5 {name=g dir=in}
B 5 1277.5 -6182.5 1282.5 -6177.5 {name=s dir=inout}
B 5 1277.5 -6212.5 1282.5 -6207.5 {name=b dir=in}
B 5 1367.5 -6242.5 1372.5 -6237.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -6182.5 1372.5 -6177.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -6182.5 1042.5 -6177.5 {name=p dir=inout}
B 5 1037.5 -6122.5 1042.5 -6117.5 {name=m dir=inout}
B 5 1118.75 -6211.25 1121.25 -6208.75 {name=p dir=out}
B 5 1147.5 -6102.5 1152.5 -6097.5 {name=p dir=inout goto=0}
B 5 1147.5 -6362.5 1152.5 -6357.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -6241.25 1421.25 -6238.75 {name=p dir=in}
B 5 737.5 -5842.5 742.5 -5837.5 {name=d dir=inout}
B 5 697.5 -5812.5 702.5 -5807.5 {name=g dir=in}
B 5 737.5 -5782.5 742.5 -5777.5 {name=s dir=inout}
B 5 737.5 -5812.5 742.5 -5807.5 {name=b dir=in}
B 5 737.5 -5932.5 742.5 -5927.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -5872.5 742.5 -5867.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -5842.5 832.5 -5837.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -5782.5 832.5 -5777.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -5782.5 502.5 -5777.5 {name=p dir=inout}
B 5 497.5 -5722.5 502.5 -5717.5 {name=m dir=inout}
B 5 578.75 -5811.25 581.25 -5808.75 {name=p dir=out}
B 5 607.5 -5702.5 612.5 -5697.5 {name=p dir=inout goto=0}
B 5 607.5 -5962.5 612.5 -5957.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -5841.25 881.25 -5838.75 {name=p dir=in}
B 5 1277.5 -5842.5 1282.5 -5837.5 {name=d dir=inout}
B 5 1237.5 -5812.5 1242.5 -5807.5 {name=g dir=in}
B 5 1277.5 -5782.5 1282.5 -5777.5 {name=s dir=inout}
B 5 1277.5 -5812.5 1282.5 -5807.5 {name=b dir=in}
B 5 1367.5 -5842.5 1372.5 -5837.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -5782.5 1372.5 -5777.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -5782.5 1042.5 -5777.5 {name=p dir=inout}
B 5 1037.5 -5722.5 1042.5 -5717.5 {name=m dir=inout}
B 5 1118.75 -5811.25 1121.25 -5808.75 {name=p dir=out}
B 5 1147.5 -5702.5 1152.5 -5697.5 {name=p dir=inout goto=0}
B 5 1147.5 -5962.5 1152.5 -5957.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -5841.25 1421.25 -5838.75 {name=p dir=in}
B 5 697.5 -5372.5 702.5 -5367.5 {name=g dir=in}
B 5 497.5 -5342.5 502.5 -5337.5 {name=p dir=inout}
B 5 497.5 -5282.5 502.5 -5277.5 {name=m dir=inout}
B 5 578.75 -5371.25 581.25 -5368.75 {name=p dir=out}
B 5 607.5 -5262.5 612.5 -5257.5 {name=p dir=inout goto=0}
B 5 607.5 -5522.5 612.5 -5517.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1687.5 -5342.5 1692.5 -5337.5 {name=p dir=inout}
B 5 1687.5 -5282.5 1692.5 -5277.5 {name=m dir=inout}
B 5 1768.75 -5371.25 1771.25 -5368.75 {name=p dir=out}
B 5 1797.5 -5262.5 1802.5 -5257.5 {name=p dir=inout goto=0}
B 5 1797.5 -5522.5 1802.5 -5517.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1057.5 -5342.5 1062.5 -5337.5 {name=p dir=inout}
B 5 1057.5 -5282.5 1062.5 -5277.5 {name=m dir=inout}
B 5 1138.75 -5371.25 1141.25 -5368.75 {name=p dir=out}
B 5 1167.5 -5262.5 1172.5 -5257.5 {name=p dir=inout goto=0}
B 5 1167.5 -5522.5 1172.5 -5517.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1027.5 -9402.5 1032.5 -9397.5 {name=p dir=inout}
B 5 1027.5 -9342.5 1032.5 -9337.5 {name=m dir=inout}
B 5 1108.75 -9431.25 1111.25 -9428.75 {name=p dir=out}
B 5 1137.5 -9322.5 1142.5 -9317.5 {name=p dir=inout goto=0}
B 5 1137.5 -9582.5 1142.5 -9577.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -9461.25 1411.25 -9458.75 {name=p dir=in}
B 5 697.5 -9432.5 702.5 -9427.5 {name=g dir=in}
B 5 497.5 -9402.5 502.5 -9397.5 {name=p dir=inout}
B 5 497.5 -9342.5 502.5 -9337.5 {name=m dir=inout}
B 5 578.75 -9431.25 581.25 -9428.75 {name=p dir=out}
B 5 607.5 -9322.5 612.5 -9317.5 {name=p dir=inout goto=0}
B 5 607.5 -9582.5 612.5 -9577.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -9461.25 881.25 -9458.75 {name=p dir=in}
B 5 1767.5 -9462.5 1772.5 -9457.5 {name=d dir=inout}
B 5 1727.5 -9432.5 1732.5 -9427.5 {name=g dir=in}
B 5 1767.5 -9402.5 1772.5 -9397.5 {name=s dir=inout}
B 5 1767.5 -9432.5 1772.5 -9427.5 {name=b dir=in}
B 5 1767.5 -9552.5 1772.5 -9547.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1767.5 -9492.5 1772.5 -9487.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1857.5 -9462.5 1862.5 -9457.5 {name=p dir=inout pinnumber=1}
B 5 1857.5 -9402.5 1862.5 -9397.5 {name=m dir=inout pinnumber=2}
B 5 1527.5 -9402.5 1532.5 -9397.5 {name=p dir=inout}
B 5 1527.5 -9342.5 1532.5 -9337.5 {name=m dir=inout}
B 5 1608.75 -9431.25 1611.25 -9428.75 {name=p dir=out}
B 5 1637.5 -9322.5 1642.5 -9317.5 {name=p dir=inout goto=0}
B 5 1637.5 -9582.5 1642.5 -9577.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1908.75 -9461.25 1911.25 -9458.75 {name=p dir=in}
B 5 1648.75 -10731.25 1651.25 -10728.75 {name=p dir=out}
B 5 1677.5 -10622.5 1682.5 -10617.5 {name=p dir=inout goto=0}
B 5 1677.5 -10882.5 1682.5 -10877.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1948.75 -10761.25 1951.25 -10758.75 {name=p dir=in}
B 5 642.5 -10732.5 647.5 -10727.5 {name=g dir=in}
B 5 442.5 -10702.5 447.5 -10697.5 {name=p dir=inout}
B 5 442.5 -10642.5 447.5 -10637.5 {name=m dir=inout}
B 5 523.75 -10731.25 526.25 -10728.75 {name=p dir=out}
B 5 552.5 -10622.5 557.5 -10617.5 {name=p dir=inout goto=0}
B 5 552.5 -10882.5 557.5 -10877.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 823.75 -10761.25 826.25 -10758.75 {name=p dir=in}
B 5 2108.75 -10731.25 2111.25 -10728.75 {name=p dir=out}
B 5 2137.5 -10622.5 2142.5 -10617.5 {name=p dir=inout goto=0}
B 5 2137.5 -10882.5 2142.5 -10877.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2408.75 -10761.25 2411.25 -10758.75 {name=p dir=in}
B 5 2357.5 -10762.5 2362.5 -10757.5 {name=p dir=inout pinnumber=1}
B 5 2357.5 -10702.5 2362.5 -10697.5 {name=m dir=inout pinnumber=2}
B 5 757.5 -8622.5 762.5 -8617.5 {name=d dir=inout}
B 5 717.5 -8592.5 722.5 -8587.5 {name=g dir=in}
B 5 757.5 -8562.5 762.5 -8557.5 {name=s dir=inout}
B 5 757.5 -8592.5 762.5 -8587.5 {name=b dir=in}
B 5 757.5 -8712.5 762.5 -8707.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -8652.5 762.5 -8647.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 847.5 -8622.5 852.5 -8617.5 {name=p dir=inout pinnumber=1}
B 5 847.5 -8562.5 852.5 -8557.5 {name=m dir=inout pinnumber=2}
B 5 517.5 -8562.5 522.5 -8557.5 {name=p dir=inout}
B 5 517.5 -8502.5 522.5 -8497.5 {name=m dir=inout}
B 5 598.75 -8591.25 601.25 -8588.75 {name=p dir=out}
B 5 627.5 -8482.5 632.5 -8477.5 {name=p dir=inout goto=0}
B 5 627.5 -8742.5 632.5 -8737.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 898.75 -8621.25 901.25 -8618.75 {name=p dir=in}
B 5 1297.5 -8622.5 1302.5 -8617.5 {name=d dir=inout}
B 5 1257.5 -8592.5 1262.5 -8587.5 {name=g dir=in}
B 5 1297.5 -8562.5 1302.5 -8557.5 {name=s dir=inout}
B 5 1297.5 -8592.5 1302.5 -8587.5 {name=b dir=in}
B 5 1297.5 -8712.5 1302.5 -8707.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1297.5 -8652.5 1302.5 -8647.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1387.5 -8622.5 1392.5 -8617.5 {name=p dir=inout pinnumber=1}
B 5 1387.5 -8562.5 1392.5 -8557.5 {name=m dir=inout pinnumber=2}
B 5 1057.5 -8562.5 1062.5 -8557.5 {name=p dir=inout}
B 5 1057.5 -8502.5 1062.5 -8497.5 {name=m dir=inout}
B 5 1138.75 -8591.25 1141.25 -8588.75 {name=p dir=out}
B 5 1167.5 -8482.5 1172.5 -8477.5 {name=p dir=inout goto=0}
B 5 1167.5 -8742.5 1172.5 -8737.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1438.75 -8621.25 1441.25 -8618.75 {name=p dir=in}
B 5 2427.5 -8622.5 2432.5 -8617.5 {name=d dir=inout}
B 5 2387.5 -8592.5 2392.5 -8587.5 {name=g dir=in}
B 5 2427.5 -8562.5 2432.5 -8557.5 {name=s dir=inout}
B 5 2427.5 -8592.5 2432.5 -8587.5 {name=b dir=in}
B 5 2427.5 -8712.5 2432.5 -8707.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -8652.5 2432.5 -8647.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2517.5 -8622.5 2522.5 -8617.5 {name=p dir=inout pinnumber=1}
B 5 2517.5 -8562.5 2522.5 -8557.5 {name=m dir=inout pinnumber=2}
B 5 2187.5 -8562.5 2192.5 -8557.5 {name=p dir=inout}
B 5 2187.5 -8502.5 2192.5 -8497.5 {name=m dir=inout}
B 5 2268.75 -8591.25 2271.25 -8588.75 {name=p dir=out}
B 5 2297.5 -8482.5 2302.5 -8477.5 {name=p dir=inout goto=0}
B 5 2297.5 -8742.5 2302.5 -8737.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2568.75 -8621.25 2571.25 -8618.75 {name=p dir=in}
B 5 817.5 -4532.5 822.5 -4527.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -4472.5 822.5 -4467.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -4472.5 822.5 -4467.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -4412.5 822.5 -4407.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -4412.5 1362.5 -4407.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -4572.5 1902.5 -4567.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -4512.5 1902.5 -4507.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -4472.5 1902.5 -4467.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -4412.5 1902.5 -4407.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -3702.5 712.5 -3697.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -3642.5 712.5 -3637.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -3702.5 822.5 -3697.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -3642.5 822.5 -3637.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -3702.5 932.5 -3697.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -3642.5 932.5 -3637.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -3702.5 1252.5 -3697.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -3642.5 1252.5 -3637.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -3702.5 1362.5 -3697.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -3642.5 1362.5 -3637.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -3702.5 1472.5 -3697.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -3642.5 1472.5 -3637.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -3702.5 1792.5 -3697.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -3642.5 1792.5 -3637.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -3702.5 1902.5 -3697.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -3642.5 1902.5 -3637.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -3702.5 2012.5 -3697.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -3642.5 2012.5 -3637.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2317.5 -3702.5 2322.5 -3697.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2317.5 -3642.5 2322.5 -3637.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2427.5 -3702.5 2432.5 -3697.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -3642.5 2432.5 -3637.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2537.5 -3702.5 2542.5 -3697.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2537.5 -3642.5 2542.5 -3637.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -1772.5 712.5 -1767.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -1712.5 712.5 -1707.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -1772.5 822.5 -1767.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -1712.5 822.5 -1707.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -1772.5 932.5 -1767.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -1712.5 932.5 -1707.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -1682.5 712.5 -1677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -1622.5 712.5 -1617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -1682.5 822.5 -1677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -1622.5 822.5 -1617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -1682.5 932.5 -1677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -1622.5 932.5 -1617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -1682.5 1252.5 -1677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -1622.5 1252.5 -1617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -1682.5 1362.5 -1677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -1622.5 1362.5 -1617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -1682.5 1472.5 -1677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -1622.5 1472.5 -1617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -1682.5 1792.5 -1677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -1622.5 1792.5 -1617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -1682.5 1902.5 -1677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -1622.5 1902.5 -1617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -1682.5 2012.5 -1677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -1622.5 2012.5 -1617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1877.5 -3442.5 1882.5 -3437.5 {name=d dir=inout}
B 5 1837.5 -3412.5 1842.5 -3407.5 {name=g dir=in}
B 5 1877.5 -3382.5 1882.5 -3377.5 {name=s dir=inout}
B 5 1877.5 -3412.5 1882.5 -3407.5 {name=b dir=in}
B 5 1108.75 -10731.25 1111.25 -10728.75 {name=p dir=out}
B 5 1137.5 -10622.5 1142.5 -10617.5 {name=p dir=inout goto=0}
B 5 1137.5 -10882.5 1142.5 -10877.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -10761.25 1411.25 -10758.75 {name=p dir=in}
B 5 1027.5 -10702.5 1032.5 -10697.5 {name=p dir=inout}
B 5 1027.5 -10642.5 1032.5 -10637.5 {name=m dir=inout}
B 5 707.5 -1392.5 712.5 -1387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -1332.5 712.5 -1327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -1392.5 822.5 -1387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -1332.5 822.5 -1327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -1392.5 932.5 -1387.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -1332.5 932.5 -1327.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -1332.5 712.5 -1327.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -1272.5 712.5 -1267.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -1332.5 822.5 -1327.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -1272.5 822.5 -1267.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -1332.5 932.5 -1327.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -1272.5 932.5 -1267.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -1332.5 1252.5 -1327.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -1272.5 1252.5 -1267.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -1332.5 1362.5 -1327.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -1272.5 1362.5 -1267.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -1332.5 1472.5 -1327.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -1272.5 1472.5 -1267.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -1302.5 1792.5 -1297.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -1242.5 1792.5 -1237.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -1302.5 1902.5 -1297.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -1242.5 1902.5 -1237.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -1302.5 2012.5 -1297.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -1242.5 2012.5 -1237.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1757.5 -2082.5 1762.5 -2077.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1757.5 -2022.5 1762.5 -2017.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1877.5 -2082.5 1882.5 -2077.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1877.5 -2022.5 1882.5 -2017.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 797.5 -2152.5 802.5 -2147.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -932.5 822.5 -927.5 {name=d dir=inout}
B 5 777.5 -902.5 782.5 -897.5 {name=g dir=in}
B 5 817.5 -872.5 822.5 -867.5 {name=s dir=inout}
B 5 817.5 -902.5 822.5 -897.5 {name=b dir=in}
B 5 817.5 -1022.5 822.5 -1017.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -962.5 822.5 -957.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 907.5 -932.5 912.5 -927.5 {name=p dir=inout pinnumber=1}
B 5 907.5 -872.5 912.5 -867.5 {name=m dir=inout pinnumber=2}
B 5 577.5 -872.5 582.5 -867.5 {name=p dir=inout}
B 5 577.5 -812.5 582.5 -807.5 {name=m dir=inout}
B 5 658.75 -901.25 661.25 -898.75 {name=p dir=out}
B 5 687.5 -792.5 692.5 -787.5 {name=p dir=inout goto=0}
B 5 687.5 -1052.5 692.5 -1047.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 958.75 -931.25 961.25 -928.75 {name=p dir=in}
B 5 1417.5 -932.5 1422.5 -927.5 {name=d dir=inout}
B 5 1377.5 -902.5 1382.5 -897.5 {name=g dir=in}
B 5 1417.5 -872.5 1422.5 -867.5 {name=s dir=inout}
B 5 1417.5 -902.5 1422.5 -897.5 {name=b dir=in}
B 5 1417.5 -1022.5 1422.5 -1017.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1417.5 -962.5 1422.5 -957.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1177.5 -872.5 1182.5 -867.5 {name=p dir=inout}
B 5 1177.5 -812.5 1182.5 -807.5 {name=m dir=inout}
B 5 1258.75 -901.25 1261.25 -898.75 {name=p dir=out}
B 5 1287.5 -792.5 1292.5 -787.5 {name=p dir=inout goto=0}
B 5 1287.5 -1052.5 1292.5 -1047.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1558.75 -931.25 1561.25 -928.75 {name=p dir=in}
B 5 2027.5 -932.5 2032.5 -927.5 {name=d dir=inout}
B 5 1987.5 -902.5 1992.5 -897.5 {name=g dir=in}
B 5 2027.5 -872.5 2032.5 -867.5 {name=s dir=inout}
B 5 2027.5 -902.5 2032.5 -897.5 {name=b dir=in}
B 5 2027.5 -1022.5 2032.5 -1017.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2027.5 -962.5 2032.5 -957.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -872.5 1792.5 -867.5 {name=p dir=inout}
B 5 1787.5 -812.5 1792.5 -807.5 {name=m dir=inout}
B 5 1868.75 -901.25 1871.25 -898.75 {name=p dir=out}
B 5 1897.5 -792.5 1902.5 -787.5 {name=p dir=inout goto=0}
B 5 1897.5 -1052.5 1902.5 -1047.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2168.75 -931.25 2171.25 -928.75 {name=p dir=in}
B 5 357.5 -8232.5 362.5 -8227.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 557.5 -8232.5 562.5 -8227.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 797.5 -8232.5 802.5 -8227.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1087.5 -8232.5 1092.5 -8227.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1317.5 -8232.5 1322.5 -8227.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 357.5 -8172.5 362.5 -8167.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 557.5 -8172.5 562.5 -8167.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 797.5 -8172.5 802.5 -8167.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1087.5 -8172.5 1092.5 -8167.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1317.5 -8172.5 1322.5 -8167.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1607.5 -8232.5 1612.5 -8227.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1607.5 -8172.5 1612.5 -8167.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1847.5 -8232.5 1852.5 -8227.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1847.5 -8172.5 1852.5 -8167.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2147.5 -8232.5 2152.5 -8227.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2147.5 -8172.5 2152.5 -8167.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -4992.5 762.5 -4987.5 {name=d dir=inout}
B 5 717.5 -4962.5 722.5 -4957.5 {name=g dir=in}
B 5 757.5 -4932.5 762.5 -4927.5 {name=s dir=inout}
B 5 757.5 -4962.5 762.5 -4957.5 {name=b dir=in}
B 5 757.5 -5082.5 762.5 -5077.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -5022.5 762.5 -5017.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 517.5 -4932.5 522.5 -4927.5 {name=p dir=inout}
B 5 517.5 -4872.5 522.5 -4867.5 {name=m dir=inout}
B 5 598.75 -4961.25 601.25 -4958.75 {name=p dir=out}
B 5 627.5 -4852.5 632.5 -4847.5 {name=p dir=inout goto=0}
B 5 627.5 -5112.5 632.5 -5107.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 898.75 -4991.25 901.25 -4988.75 {name=p dir=in}
B 5 1317.5 -4992.5 1322.5 -4987.5 {name=d dir=inout}
B 5 1277.5 -4962.5 1282.5 -4957.5 {name=g dir=in}
B 5 1317.5 -4932.5 1322.5 -4927.5 {name=s dir=inout}
B 5 1317.5 -4962.5 1322.5 -4957.5 {name=b dir=in}
B 5 1317.5 -5082.5 1322.5 -5077.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1317.5 -5022.5 1322.5 -5017.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1077.5 -4932.5 1082.5 -4927.5 {name=p dir=inout}
B 5 1077.5 -4872.5 1082.5 -4867.5 {name=m dir=inout}
B 5 1158.75 -4961.25 1161.25 -4958.75 {name=p dir=out}
B 5 1187.5 -4852.5 1192.5 -4847.5 {name=p dir=inout goto=0}
B 5 1187.5 -5112.5 1192.5 -5107.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1458.75 -4991.25 1461.25 -4988.75 {name=p dir=in}
B 5 702.5 -9042.5 707.5 -9037.5 {name=d dir=inout}
B 5 662.5 -9012.5 667.5 -9007.5 {name=g dir=in}
B 5 702.5 -8982.5 707.5 -8977.5 {name=s dir=inout}
B 5 702.5 -9012.5 707.5 -9007.5 {name=b dir=in}
B 5 702.5 -9132.5 707.5 -9127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 702.5 -9072.5 707.5 -9067.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 792.5 -9042.5 797.5 -9037.5 {name=p dir=inout pinnumber=1}
B 5 792.5 -8982.5 797.5 -8977.5 {name=m dir=inout pinnumber=2}
B 5 462.5 -8982.5 467.5 -8977.5 {name=p dir=inout}
B 5 462.5 -8922.5 467.5 -8917.5 {name=m dir=inout}
B 5 543.75 -9011.25 546.25 -9008.75 {name=p dir=out}
B 5 572.5 -8902.5 577.5 -8897.5 {name=p dir=inout goto=0}
B 5 572.5 -9162.5 577.5 -9157.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 843.75 -9041.25 846.25 -9038.75 {name=p dir=in}
B 5 1267.5 -9042.5 1272.5 -9037.5 {name=d dir=inout}
B 5 1227.5 -9012.5 1232.5 -9007.5 {name=g dir=in}
B 5 1267.5 -8982.5 1272.5 -8977.5 {name=s dir=inout}
B 5 1267.5 -9012.5 1272.5 -9007.5 {name=b dir=in}
B 5 1267.5 -9132.5 1272.5 -9127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1267.5 -9072.5 1272.5 -9067.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -9042.5 1362.5 -9037.5 {name=p dir=inout pinnumber=1}
B 5 1357.5 -8982.5 1362.5 -8977.5 {name=m dir=inout pinnumber=2}
B 5 1027.5 -8982.5 1032.5 -8977.5 {name=p dir=inout}
B 5 1027.5 -8922.5 1032.5 -8917.5 {name=m dir=inout}
B 5 1108.75 -9011.25 1111.25 -9008.75 {name=p dir=out}
B 5 1137.5 -8902.5 1142.5 -8897.5 {name=p dir=inout goto=0}
B 5 1137.5 -9162.5 1142.5 -9157.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -9041.25 1411.25 -9038.75 {name=p dir=in}
B 5 1767.5 -9042.5 1772.5 -9037.5 {name=d dir=inout}
B 5 1727.5 -9012.5 1732.5 -9007.5 {name=g dir=in}
B 5 1767.5 -8982.5 1772.5 -8977.5 {name=s dir=inout}
B 5 1767.5 -9012.5 1772.5 -9007.5 {name=b dir=in}
B 5 1767.5 -9132.5 1772.5 -9127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1767.5 -9072.5 1772.5 -9067.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1857.5 -9042.5 1862.5 -9037.5 {name=p dir=inout pinnumber=1}
B 5 1857.5 -8982.5 1862.5 -8977.5 {name=m dir=inout pinnumber=2}
B 5 1527.5 -8982.5 1532.5 -8977.5 {name=p dir=inout}
B 5 1527.5 -8922.5 1532.5 -8917.5 {name=m dir=inout}
B 5 1608.75 -9011.25 1611.25 -9008.75 {name=p dir=out}
B 5 1637.5 -8902.5 1642.5 -8897.5 {name=p dir=inout goto=0}
B 5 1637.5 -9162.5 1642.5 -9157.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1908.75 -9041.25 1911.25 -9038.75 {name=p dir=in}
B 5 2257.5 -9042.5 2262.5 -9037.5 {name=d dir=inout}
B 5 2217.5 -9012.5 2222.5 -9007.5 {name=g dir=in}
B 5 2257.5 -8982.5 2262.5 -8977.5 {name=s dir=inout}
B 5 2257.5 -9012.5 2262.5 -9007.5 {name=b dir=in}
B 5 2257.5 -9132.5 2262.5 -9127.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2257.5 -9072.5 2262.5 -9067.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2347.5 -9042.5 2352.5 -9037.5 {name=p dir=inout pinnumber=1}
B 5 2347.5 -8982.5 2352.5 -8977.5 {name=m dir=inout pinnumber=2}
B 5 2017.5 -8982.5 2022.5 -8977.5 {name=p dir=inout}
B 5 2017.5 -8922.5 2022.5 -8917.5 {name=m dir=inout}
B 5 2098.75 -9011.25 2101.25 -9008.75 {name=p dir=out}
B 5 2127.5 -8902.5 2132.5 -8897.5 {name=p dir=inout goto=0}
B 5 2127.5 -9162.5 2132.5 -9157.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2398.75 -9041.25 2401.25 -9038.75 {name=p dir=in}
B 5 417.5 -8232.5 422.5 -8227.5 {name=p dir=inout pinnumber=1}
B 5 417.5 -8172.5 422.5 -8167.5 {name=m dir=inout pinnumber=2}
B 5 617.5 -8232.5 622.5 -8227.5 {name=p dir=inout pinnumber=1}
B 5 617.5 -8172.5 622.5 -8167.5 {name=m dir=inout pinnumber=2}
B 5 857.5 -8232.5 862.5 -8227.5 {name=p dir=inout pinnumber=1}
B 5 857.5 -8172.5 862.5 -8167.5 {name=m dir=inout pinnumber=2}
B 5 1147.5 -8232.5 1152.5 -8227.5 {name=p dir=inout pinnumber=1}
B 5 1147.5 -8172.5 1152.5 -8167.5 {name=m dir=inout pinnumber=2}
B 5 1377.5 -8232.5 1382.5 -8227.5 {name=p dir=inout pinnumber=1}
B 5 1377.5 -8172.5 1382.5 -8167.5 {name=m dir=inout pinnumber=2}
B 5 1667.5 -8232.5 1672.5 -8227.5 {name=p dir=inout pinnumber=1}
B 5 1667.5 -8172.5 1672.5 -8167.5 {name=m dir=inout pinnumber=2}
B 5 1907.5 -8232.5 1912.5 -8227.5 {name=p dir=inout pinnumber=1}
B 5 1907.5 -8172.5 1912.5 -8167.5 {name=m dir=inout pinnumber=2}
B 5 2207.5 -8232.5 2212.5 -8227.5 {name=p dir=inout pinnumber=1}
B 5 2207.5 -8172.5 2212.5 -8167.5 {name=m dir=inout pinnumber=2}
B 5 2357.5 -8232.5 2362.5 -8227.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2357.5 -8172.5 2362.5 -8167.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2417.5 -8232.5 2422.5 -8227.5 {name=p dir=inout pinnumber=1}
B 5 2417.5 -8172.5 2422.5 -8167.5 {name=m dir=inout pinnumber=2}
B 5 1667.5 -262.5 1672.5 -257.5 {name=CODE[5:0] dir=out }
B 5 2197.5 -262.5 2202.5 -257.5 {name=CODE[5:0] dir=out }
B 5 1968.75 -261.25 1971.25 -258.75 {name=p dir=in}
B 5 1968.75 -241.25 1971.25 -238.75 {name=p dir=in}
B 5 1968.75 -221.25 1971.25 -218.75 {name=p dir=in}
B 5 1968.75 -201.25 1971.25 -198.75 {name=p dir=in}
A 1 1220 -3070 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1340 -3070 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1850 -3070 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1970 -3070 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1280 -2790 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1910 -2790 5.590169943749475 333.434948822922 360 {fill=1}
A 1 740 -2390 5.590169943749475 333.434948822922 360 {fill=1}
A 2 1570 -10670 15 270 360 {}
A 2 2030 -10670 15 270 360 {}
A 2 530 -7390 15 270 360 {}
A 2 1005 -7390 15 270 360 {}
A 2 1640 -7600 15 180 360 {}
A 2 530 -6960 15 270 360 {}
A 2 980 -6960 15 270 360 {}
A 2 1840 -6960 15 270 360 {}
A 4 1030 -10200 15 270 360 {}
A 4 1570 -10200 15 270 360 {}
A 4 500 -10200 15 270 360 {}
A 4 500 -9740 15 270 360 {}
A 4 1040 -9740 15 270 360 {}
A 4 500 -6150 15 270 360 {}
A 4 1040 -6150 15 270 360 {}
A 4 500 -5750 15 270 360 {}
A 4 1040 -5750 15 270 360 {}
A 4 500 -5310 15 270 360 {}
A 4 1690 -5310 15 270 360 {}
A 4 1060 -5310 15 270 360 {}
A 4 1030 -9370 15 270 360 {}
A 4 500 -9370 15 270 360 {}
A 4 1530 -9370 15 270 360 {}
A 4 445 -10670 15 270 360 {}
A 4 520 -8530 15 270 360 {}
A 4 1060 -8530 15 270 360 {}
A 4 2190 -8530 15 270 360 {}
A 4 1030 -10670 15 270 360 {}
A 4 580 -840 15 270 360 {}
A 4 1180 -840 15 270 360 {}
A 4 1790 -840 15 270 360 {}
A 4 520 -4900 15 270 360 {}
A 4 1080 -4900 15 270 360 {}
A 4 465 -8950 15 270 360 {}
A 4 1030 -8950 15 270 360 {}
A 4 1530 -8950 15 270 360 {}
A 4 2020 -8950 15 270 360 {}
A 5 1360 -4150 5.590169943749475 333.434948822922 360 {fill=1}
P 1 14 920 -10120 942.5 -10120 947.5 -10120 947.5 -10115 947.5 -10072.5 940 -10047.5 935 -10047.5 905 -10047.5 900 -10047.5 892.5 -10072.5 892.5 -10115 892.5 -10120 897.5 -10120 920 -10120 {bezier=1}
P 1 14 935 -10117.5 940 -10117.5 945 -10117.5 945 -10112.5 945 -10092.5 945 -10087.5 940 -10087.5 930 -10087.5 925 -10087.5 925 -10092.5 925 -10112.5 925 -10117.5 930 -10117.5 935 -10117.5 {bezier=1}
P 1 5 917.5 -10115 922.5 -10115 922.5 -10090 917.5 -10090 917.5 -10115 {}
P 1 14 1350 -10120 1372.5 -10120 1377.5 -10120 1377.5 -10115 1377.5 -10072.5 1370 -10047.5 1365 -10047.5 1335 -10047.5 1330 -10047.5 1322.5 -10072.5 1322.5 -10115 1322.5 -10120 1327.5 -10120 1350 -10120 {bezier=1}
P 1 14 1365 -10117.5 1370 -10117.5 1375 -10117.5 1375 -10112.5 1375 -10092.5 1375 -10087.5 1370 -10087.5 1360 -10087.5 1355 -10087.5 1355 -10092.5 1355 -10112.5 1355 -10117.5 1360 -10117.5 1365 -10117.5 {bezier=1}
P 1 5 1347.5 -10115 1352.5 -10115 1352.5 -10090 1347.5 -10090 1347.5 -10115 {}
P 1 14 2120 -10120 2142.5 -10120 2147.5 -10120 2147.5 -10115 2147.5 -10072.5 2140 -10047.5 2135 -10047.5 2105 -10047.5 2100 -10047.5 2092.5 -10072.5 2092.5 -10115 2092.5 -10120 2097.5 -10120 2120 -10120 {bezier=1}
P 1 14 2135 -10117.5 2140 -10117.5 2145 -10117.5 2145 -10112.5 2145 -10092.5 2145 -10087.5 2140 -10087.5 2130 -10087.5 2125 -10087.5 2125 -10092.5 2125 -10112.5 2125 -10117.5 2130 -10117.5 2135 -10117.5 {bezier=1}
P 1 5 2117.5 -10115 2122.5 -10115 2122.5 -10090 2117.5 -10090 2117.5 -10115 {}
P 1 14 1420 -9930 1442.5 -9930 1447.5 -9930 1447.5 -9925 1447.5 -9882.5 1440 -9857.5 1435 -9857.5 1405 -9857.5 1400 -9857.5 1392.5 -9882.5 1392.5 -9925 1392.5 -9930 1397.5 -9930 1420 -9930 {bezier=1}
P 1 14 1435 -9927.5 1440 -9927.5 1445 -9927.5 1445 -9922.5 1445 -9902.5 1445 -9897.5 1440 -9897.5 1430 -9897.5 1425 -9897.5 1425 -9902.5 1425 -9922.5 1425 -9927.5 1430 -9927.5 1435 -9927.5 {bezier=1}
P 1 5 1417.5 -9925 1422.5 -9925 1422.5 -9900 1417.5 -9900 1417.5 -9925 {}
P 1 14 1440 -6350 1462.5 -6350 1467.5 -6350 1467.5 -6345 1467.5 -6302.5 1460 -6277.5 1455 -6277.5 1425 -6277.5 1420 -6277.5 1412.5 -6302.5 1412.5 -6345 1412.5 -6350 1417.5 -6350 1440 -6350 {bezier=1}
P 1 14 1455 -6347.5 1460 -6347.5 1465 -6347.5 1465 -6342.5 1465 -6322.5 1465 -6317.5 1460 -6317.5 1450 -6317.5 1445 -6317.5 1445 -6322.5 1445 -6342.5 1445 -6347.5 1450 -6347.5 1455 -6347.5 {bezier=1}
P 1 5 1437.5 -6345 1442.5 -6345 1442.5 -6320 1437.5 -6320 1437.5 -6345 {}
P 1 10 1520 -6305 1545 -6305 1555 -6295 1555 -6265 1545 -6255 1495 -6255 1485 -6265 1485 -6295 1495 -6305 1520 -6305 {bezier=1}
P 1 10 1520 -6310 1550 -6310 1560 -6300 1560 -6260 1550 -6250 1490 -6250 1480 -6260 1480 -6300 1490 -6310 1520 -6310 {bezier=1}
P 1 14 1440 -5950 1462.5 -5950 1467.5 -5950 1467.5 -5945 1467.5 -5902.5 1460 -5877.5 1455 -5877.5 1425 -5877.5 1420 -5877.5 1412.5 -5902.5 1412.5 -5945 1412.5 -5950 1417.5 -5950 1440 -5950 {bezier=1}
P 1 14 1455 -5947.5 1460 -5947.5 1465 -5947.5 1465 -5942.5 1465 -5922.5 1465 -5917.5 1460 -5917.5 1450 -5917.5 1445 -5917.5 1445 -5922.5 1445 -5942.5 1445 -5947.5 1450 -5947.5 1455 -5947.5 {bezier=1}
P 1 5 1437.5 -5945 1442.5 -5945 1442.5 -5920 1437.5 -5920 1437.5 -5945 {}
P 1 10 1520 -6375 1545 -6375 1555 -6365 1555 -6335 1545 -6325 1495 -6325 1485 -6335 1485 -6365 1495 -6375 1520 -6375 {bezier=1}
P 1 10 1520 -6380 1550 -6380 1560 -6370 1560 -6330 1550 -6320 1490 -6320 1480 -6330 1480 -6370 1490 -6380 1520 -6380 {bezier=1}
P 1 14 950 -5270 972.5 -5270 977.5 -5270 977.5 -5265 977.5 -5222.5 970 -5197.5 965 -5197.5 935 -5197.5 930 -5197.5 922.5 -5222.5 922.5 -5265 922.5 -5270 927.5 -5270 950 -5270 {bezier=1}
P 1 14 965 -5267.5 970 -5267.5 975 -5267.5 975 -5262.5 975 -5242.5 975 -5237.5 970 -5237.5 960 -5237.5 955 -5237.5 955 -5242.5 955 -5262.5 955 -5267.5 960 -5267.5 965 -5267.5 {bezier=1}
P 1 5 947.5 -5265 952.5 -5265 952.5 -5240 947.5 -5240 947.5 -5265 {}
P 1 14 1450 -5280 1472.5 -5280 1477.5 -5280 1477.5 -5275 1477.5 -5232.5 1470 -5207.5 1465 -5207.5 1435 -5207.5 1430 -5207.5 1422.5 -5232.5 1422.5 -5275 1422.5 -5280 1427.5 -5280 1450 -5280 {bezier=1}
P 1 14 1465 -5277.5 1470 -5277.5 1475 -5277.5 1475 -5272.5 1475 -5252.5 1475 -5247.5 1470 -5247.5 1460 -5247.5 1455 -5247.5 1455 -5252.5 1455 -5272.5 1455 -5277.5 1460 -5277.5 1465 -5277.5 {bezier=1}
P 1 5 1447.5 -5275 1452.5 -5275 1452.5 -5250 1447.5 -5250 1447.5 -5275 {}
P 1 10 1540 -5265 1565 -5265 1575 -5255 1575 -5225 1565 -5215 1515 -5215 1505 -5225 1505 -5255 1515 -5265 1540 -5265 {bezier=1}
P 1 10 1540 -5270 1570 -5270 1580 -5260 1580 -5220 1570 -5210 1510 -5210 1500 -5220 1500 -5260 1510 -5270 1540 -5270 {bezier=1}
P 1 14 920 -9290 942.5 -9290 947.5 -9290 947.5 -9285 947.5 -9242.5 940 -9217.5 935 -9217.5 905 -9217.5 900 -9217.5 892.5 -9242.5 892.5 -9285 892.5 -9290 897.5 -9290 920 -9290 {bezier=1}
P 1 14 935 -9287.5 940 -9287.5 945 -9287.5 945 -9282.5 945 -9262.5 945 -9257.5 940 -9257.5 930 -9257.5 925 -9257.5 925 -9262.5 925 -9282.5 925 -9287.5 930 -9287.5 935 -9287.5 {bezier=1}
P 1 5 917.5 -9285 922.5 -9285 922.5 -9260 917.5 -9260 917.5 -9285 {}
P 1 14 1350 -9290 1372.5 -9290 1377.5 -9290 1377.5 -9285 1377.5 -9242.5 1370 -9217.5 1365 -9217.5 1335 -9217.5 1330 -9217.5 1322.5 -9242.5 1322.5 -9285 1322.5 -9290 1327.5 -9290 1350 -9290 {bezier=1}
P 1 14 1365 -9287.5 1370 -9287.5 1375 -9287.5 1375 -9282.5 1375 -9262.5 1375 -9257.5 1370 -9257.5 1360 -9257.5 1355 -9257.5 1355 -9262.5 1355 -9282.5 1355 -9287.5 1360 -9287.5 1365 -9287.5 {bezier=1}
P 1 5 1347.5 -9285 1352.5 -9285 1352.5 -9260 1347.5 -9260 1347.5 -9285 {}
P 1 14 2120 -9290 2142.5 -9290 2147.5 -9290 2147.5 -9285 2147.5 -9242.5 2140 -9217.5 2135 -9217.5 2105 -9217.5 2100 -9217.5 2092.5 -9242.5 2092.5 -9285 2092.5 -9290 2097.5 -9290 2120 -9290 {bezier=1}
P 1 14 2135 -9287.5 2140 -9287.5 2145 -9287.5 2145 -9282.5 2145 -9262.5 2145 -9257.5 2140 -9257.5 2130 -9257.5 2125 -9257.5 2125 -9262.5 2125 -9282.5 2125 -9287.5 2130 -9287.5 2135 -9287.5 {bezier=1}
P 1 5 2117.5 -9285 2122.5 -9285 2122.5 -9260 2117.5 -9260 2117.5 -9285 {}
P 1 10 1270 -9285 1295 -9285 1305 -9275 1305 -9245 1295 -9235 1245 -9235 1235 -9245 1235 -9275 1245 -9285 1270 -9285 {bezier=1}
P 1 10 1270 -9290 1300 -9290 1310 -9280 1310 -9240 1300 -9230 1240 -9230 1230 -9240 1230 -9280 1240 -9290 1270 -9290 {bezier=1}
P 1 14 865 -10590 887.5 -10590 892.5 -10590 892.5 -10585 892.5 -10542.5 885 -10517.5 880 -10517.5 850 -10517.5 845 -10517.5 837.5 -10542.5 837.5 -10585 837.5 -10590 842.5 -10590 865 -10590 {bezier=1}
P 1 14 880 -10587.5 885 -10587.5 890 -10587.5 890 -10582.5 890 -10562.5 890 -10557.5 885 -10557.5 875 -10557.5 870 -10557.5 870 -10562.5 870 -10582.5 870 -10587.5 875 -10587.5 880 -10587.5 {bezier=1}
P 1 5 862.5 -10585 867.5 -10585 867.5 -10560 862.5 -10560 862.5 -10585 {}
P 1 14 1630 -10580 1652.5 -10580 1657.5 -10580 1657.5 -10575 1657.5 -10532.5 1650 -10507.5 1645 -10507.5 1615 -10507.5 1610 -10507.5 1602.5 -10532.5 1602.5 -10575 1602.5 -10580 1607.5 -10580 1630 -10580 {bezier=1}
P 1 14 1645 -10577.5 1650 -10577.5 1655 -10577.5 1655 -10572.5 1655 -10552.5 1655 -10547.5 1650 -10547.5 1640 -10547.5 1635 -10547.5 1635 -10552.5 1635 -10572.5 1635 -10577.5 1640 -10577.5 1645 -10577.5 {bezier=1}
P 1 5 1627.5 -10575 1632.5 -10575 1632.5 -10550 1627.5 -10550 1627.5 -10575 {}
P 1 10 1710 -10565 1735 -10565 1745 -10555 1745 -10525 1735 -10515 1685 -10515 1675 -10525 1675 -10555 1685 -10565 1710 -10565 {bezier=1}
P 1 10 1710 -10570 1740 -10570 1750 -10560 1750 -10520 1740 -10510 1680 -10510 1670 -10520 1670 -10560 1680 -10570 1710 -10570 {bezier=1}
P 1 14 2410 -10570 2432.5 -10570 2437.5 -10570 2437.5 -10565 2437.5 -10522.5 2430 -10497.5 2425 -10497.5 2395 -10497.5 2390 -10497.5 2382.5 -10522.5 2382.5 -10565 2382.5 -10570 2387.5 -10570 2410 -10570 {bezier=1}
P 1 14 2425 -10567.5 2430 -10567.5 2435 -10567.5 2435 -10562.5 2435 -10542.5 2435 -10537.5 2430 -10537.5 2420 -10537.5 2415 -10537.5 2415 -10542.5 2415 -10562.5 2415 -10567.5 2420 -10567.5 2425 -10567.5 {bezier=1}
P 1 5 2407.5 -10565 2412.5 -10565 2412.5 -10540 2407.5 -10540 2407.5 -10565 {}
P 1 10 2490 -10555 2515 -10555 2525 -10545 2525 -10515 2515 -10505 2465 -10505 2455 -10515 2455 -10545 2465 -10555 2490 -10555 {bezier=1}
P 1 10 2490 -10560 2520 -10560 2530 -10550 2530 -10510 2520 -10500 2460 -10500 2450 -10510 2450 -10550 2460 -10560 2490 -10560 {bezier=1}
P 1 14 690 -8710 712.5 -8710 717.5 -8710 717.5 -8705 717.5 -8662.5 710 -8637.5 705 -8637.5 675 -8637.5 670 -8637.5 662.5 -8662.5 662.5 -8705 662.5 -8710 667.5 -8710 690 -8710 {bezier=1}
P 1 14 705 -8707.5 710 -8707.5 715 -8707.5 715 -8702.5 715 -8682.5 715 -8677.5 710 -8677.5 700 -8677.5 695 -8677.5 695 -8682.5 695 -8702.5 695 -8707.5 700 -8707.5 705 -8707.5 {bezier=1}
P 1 5 687.5 -8705 692.5 -8705 692.5 -8680 687.5 -8680 687.5 -8705 {}
P 1 14 1350 -8730 1372.5 -8730 1377.5 -8730 1377.5 -8725 1377.5 -8682.5 1370 -8657.5 1365 -8657.5 1335 -8657.5 1330 -8657.5 1322.5 -8682.5 1322.5 -8725 1322.5 -8730 1327.5 -8730 1350 -8730 {bezier=1}
P 1 14 1365 -8727.5 1370 -8727.5 1375 -8727.5 1375 -8722.5 1375 -8702.5 1375 -8697.5 1370 -8697.5 1360 -8697.5 1355 -8697.5 1355 -8702.5 1355 -8722.5 1355 -8727.5 1360 -8727.5 1365 -8727.5 {bezier=1}
P 1 5 1347.5 -8725 1352.5 -8725 1352.5 -8700 1347.5 -8700 1347.5 -8725 {}
P 1 14 2540 -8780 2562.5 -8780 2567.5 -8780 2567.5 -8775 2567.5 -8732.5 2560 -8707.5 2555 -8707.5 2525 -8707.5 2520 -8707.5 2512.5 -8732.5 2512.5 -8775 2512.5 -8780 2517.5 -8780 2540 -8780 {bezier=1}
P 1 14 2555 -8777.5 2560 -8777.5 2565 -8777.5 2565 -8772.5 2565 -8752.5 2565 -8747.5 2560 -8747.5 2550 -8747.5 2545 -8747.5 2545 -8752.5 2545 -8772.5 2545 -8777.5 2550 -8777.5 2555 -8777.5 {bezier=1}
P 1 5 2537.5 -8775 2542.5 -8775 2542.5 -8750 2537.5 -8750 2537.5 -8775 {}
P 1 14 1430 -4490 1452.5 -4490 1457.5 -4490 1457.5 -4485 1457.5 -4442.5 1450 -4417.5 1445 -4417.5 1415 -4417.5 1410 -4417.5 1402.5 -4442.5 1402.5 -4485 1402.5 -4490 1407.5 -4490 1430 -4490 {bezier=1}
P 1 14 1445 -4487.5 1450 -4487.5 1455 -4487.5 1455 -4482.5 1455 -4462.5 1455 -4457.5 1450 -4457.5 1440 -4457.5 1435 -4457.5 1435 -4462.5 1435 -4482.5 1435 -4487.5 1440 -4487.5 1445 -4487.5 {bezier=1}
P 1 5 1427.5 -4485 1432.5 -4485 1432.5 -4460 1427.5 -4460 1427.5 -4485 {}
P 1 10 1430 -4645 1455 -4645 1465 -4635 1465 -4605 1455 -4595 1405 -4595 1395 -4605 1395 -4635 1405 -4645 1430 -4645 {bezier=1}
P 1 10 1430 -4650 1460 -4650 1470 -4640 1470 -4600 1460 -4590 1400 -4590 1390 -4600 1390 -4640 1400 -4650 1430 -4650 {bezier=1}
P 1 10 1430 -4565 1455 -4565 1465 -4555 1465 -4525 1455 -4515 1405 -4515 1395 -4525 1395 -4555 1405 -4565 1430 -4565 {bezier=1}
P 1 10 1430 -4570 1460 -4570 1470 -4560 1470 -4520 1460 -4510 1400 -4510 1390 -4520 1390 -4560 1400 -4570 1430 -4570 {bezier=1}
P 1 14 2080 -1760 2102.5 -1760 2107.5 -1760 2107.5 -1755 2107.5 -1712.5 2100 -1687.5 2095 -1687.5 2065 -1687.5 2060 -1687.5 2052.5 -1712.5 2052.5 -1755 2052.5 -1760 2057.5 -1760 2080 -1760 {bezier=1}
P 1 14 2095 -1757.5 2100 -1757.5 2105 -1757.5 2105 -1752.5 2105 -1732.5 2105 -1727.5 2100 -1727.5 2090 -1727.5 2085 -1727.5 2085 -1732.5 2085 -1752.5 2085 -1757.5 2090 -1757.5 2095 -1757.5 {bezier=1}
P 1 5 2077.5 -1755 2082.5 -1755 2082.5 -1730 2077.5 -1730 2077.5 -1755 {}
P 1 10 2080 -1825 2105 -1825 2115 -1815 2115 -1785 2105 -1775 2055 -1775 2045 -1785 2045 -1815 2055 -1825 2080 -1825 {bezier=1}
P 1 10 2080 -1830 2110 -1830 2120 -1820 2120 -1780 2110 -1770 2050 -1770 2040 -1780 2040 -1820 2050 -1830 2080 -1830 {bezier=1}
P 1 14 1570 -1730 1592.5 -1730 1597.5 -1730 1597.5 -1725 1597.5 -1682.5 1590 -1657.5 1585 -1657.5 1555 -1657.5 1550 -1657.5 1542.5 -1682.5 1542.5 -1725 1542.5 -1730 1547.5 -1730 1570 -1730 {bezier=1}
P 1 14 1585 -1727.5 1590 -1727.5 1595 -1727.5 1595 -1722.5 1595 -1702.5 1595 -1697.5 1590 -1697.5 1580 -1697.5 1575 -1697.5 1575 -1702.5 1575 -1722.5 1575 -1727.5 1580 -1727.5 1585 -1727.5 {bezier=1}
P 1 5 1567.5 -1725 1572.5 -1725 1572.5 -1700 1567.5 -1700 1567.5 -1725 {}
P 1 14 1430 -4130 1452.5 -4130 1457.5 -4130 1457.5 -4125 1457.5 -4082.5 1450 -4057.5 1445 -4057.5 1415 -4057.5 1410 -4057.5 1402.5 -4082.5 1402.5 -4125 1402.5 -4130 1407.5 -4130 1430 -4130 {bezier=1}
P 1 14 1415 -4127.5 1410 -4127.5 1405 -4127.5 1405 -4122.5 1405 -4102.5 1405 -4097.5 1410 -4097.5 1420 -4097.5 1425 -4097.5 1425 -4102.5 1425 -4122.5 1425 -4127.5 1420 -4127.5 1415 -4127.5 {bezier=1}
P 1 5 1427.5 -4125 1432.5 -4125 1432.5 -4100 1427.5 -4100 1427.5 -4125 {}
P 1 10 1430 -4195 1455 -4195 1465 -4185 1465 -4155 1455 -4145 1405 -4145 1395 -4155 1395 -4185 1405 -4195 1430 -4195 {bezier=1}
P 1 10 1430 -4200 1460 -4200 1470 -4190 1470 -4150 1460 -4140 1400 -4140 1390 -4150 1390 -4190 1400 -4200 1430 -4200 {bezier=1}
P 1 14 1960 -4240 1982.5 -4240 1987.5 -4240 1987.5 -4235 1987.5 -4192.5 1980 -4167.5 1975 -4167.5 1945 -4167.5 1940 -4167.5 1932.5 -4192.5 1932.5 -4235 1932.5 -4240 1937.5 -4240 1960 -4240 {bezier=1}
P 1 14 1975 -4237.5 1980 -4237.5 1985 -4237.5 1985 -4232.5 1985 -4212.5 1985 -4207.5 1980 -4207.5 1970 -4207.5 1965 -4207.5 1965 -4212.5 1965 -4232.5 1965 -4237.5 1970 -4237.5 1975 -4237.5 {bezier=1}
P 1 5 1957.5 -4235 1962.5 -4235 1962.5 -4210 1957.5 -4210 1957.5 -4235 {}
P 1 14 1580 -3720 1602.5 -3720 1607.5 -3720 1607.5 -3715 1607.5 -3672.5 1600 -3647.5 1595 -3647.5 1565 -3647.5 1560 -3647.5 1552.5 -3672.5 1552.5 -3715 1552.5 -3720 1557.5 -3720 1580 -3720 {bezier=1}
P 1 14 1595 -3717.5 1600 -3717.5 1605 -3717.5 1605 -3712.5 1605 -3692.5 1605 -3687.5 1600 -3687.5 1590 -3687.5 1585 -3687.5 1585 -3692.5 1585 -3712.5 1585 -3717.5 1590 -3717.5 1595 -3717.5 {bezier=1}
P 1 5 1577.5 -3715 1582.5 -3715 1582.5 -3690 1577.5 -3690 1577.5 -3715 {}
P 1 10 1580 -3785 1605 -3785 1615 -3775 1615 -3745 1605 -3735 1555 -3735 1545 -3745 1545 -3775 1555 -3785 1580 -3785 {bezier=1}
P 1 10 1580 -3790 1610 -3790 1620 -3780 1620 -3740 1610 -3730 1550 -3730 1540 -3740 1540 -3780 1550 -3790 1580 -3790 {bezier=1}
P 1 14 2070 -3780 2092.5 -3780 2097.5 -3780 2097.5 -3775 2097.5 -3732.5 2090 -3707.5 2085 -3707.5 2055 -3707.5 2050 -3707.5 2042.5 -3732.5 2042.5 -3775 2042.5 -3780 2047.5 -3780 2070 -3780 {bezier=1}
P 1 14 2085 -3777.5 2090 -3777.5 2095 -3777.5 2095 -3772.5 2095 -3752.5 2095 -3747.5 2090 -3747.5 2080 -3747.5 2075 -3747.5 2075 -3752.5 2075 -3772.5 2075 -3777.5 2080 -3777.5 2085 -3777.5 {bezier=1}
P 1 5 2067.5 -3775 2072.5 -3775 2072.5 -3750 2067.5 -3750 2067.5 -3775 {}
P 1 14 2600 -3910 2622.5 -3910 2627.5 -3910 2627.5 -3905 2627.5 -3862.5 2620 -3837.5 2615 -3837.5 2585 -3837.5 2580 -3837.5 2572.5 -3862.5 2572.5 -3905 2572.5 -3910 2577.5 -3910 2600 -3910 {bezier=1}
P 1 14 2615 -3907.5 2620 -3907.5 2625 -3907.5 2625 -3902.5 2625 -3882.5 2625 -3877.5 2620 -3877.5 2610 -3877.5 2605 -3877.5 2605 -3882.5 2605 -3902.5 2605 -3907.5 2610 -3907.5 2615 -3907.5 {bezier=1}
P 1 5 2597.5 -3905 2602.5 -3905 2602.5 -3880 2597.5 -3880 2597.5 -3905 {}
P 1 10 1960 -3485 1985 -3485 1995 -3475 1995 -3445 1985 -3435 1935 -3435 1925 -3445 1925 -3475 1935 -3485 1960 -3485 {bezier=1}
P 1 10 1960 -3490 1990 -3490 2000 -3480 2000 -3440 1990 -3430 1930 -3430 1920 -3440 1920 -3480 1930 -3490 1960 -3490 {bezier=1}
P 1 10 1960 -3405 1985 -3405 1995 -3395 1995 -3365 1985 -3355 1935 -3355 1925 -3365 1925 -3395 1935 -3405 1960 -3405 {bezier=1}
P 1 10 1960 -3410 1990 -3410 2000 -3400 2000 -3360 1990 -3350 1930 -3350 1920 -3360 1920 -3400 1930 -3410 1960 -3410 {bezier=1}
P 1 14 990 -10860 1012.5 -10860 1017.5 -10860 1017.5 -10855 1017.5 -10812.5 1010 -10787.5 1005 -10787.5 975 -10787.5 970 -10787.5 962.5 -10812.5 962.5 -10855 962.5 -10860 967.5 -10860 990 -10860 {bezier=1}
P 1 14 1005 -10857.5 1010 -10857.5 1015 -10857.5 1015 -10852.5 1015 -10832.5 1015 -10827.5 1010 -10827.5 1000 -10827.5 995 -10827.5 995 -10832.5 995 -10852.5 995 -10857.5 1000 -10857.5 1005 -10857.5 {bezier=1}
P 1 5 987.5 -10855 992.5 -10855 992.5 -10830 987.5 -10830 987.5 -10855 {}
P 1 10 1080 -10845 1105 -10845 1115 -10835 1115 -10805 1105 -10795 1055 -10795 1045 -10805 1045 -10835 1055 -10845 1080 -10845 {bezier=1}
P 1 10 1080 -10850 1110 -10850 1120 -10840 1120 -10800 1110 -10790 1050 -10790 1040 -10800 1040 -10840 1050 -10850 1080 -10850 {bezier=1}
P 1 14 1570 -1350 1592.5 -1350 1597.5 -1350 1597.5 -1345 1597.5 -1302.5 1590 -1277.5 1585 -1277.5 1555 -1277.5 1550 -1277.5 1542.5 -1302.5 1542.5 -1345 1542.5 -1350 1547.5 -1350 1570 -1350 {bezier=1}
P 1 14 1585 -1347.5 1590 -1347.5 1595 -1347.5 1595 -1342.5 1595 -1322.5 1595 -1317.5 1590 -1317.5 1580 -1317.5 1575 -1317.5 1575 -1322.5 1575 -1342.5 1575 -1347.5 1580 -1347.5 1585 -1347.5 {bezier=1}
P 1 5 1567.5 -1345 1572.5 -1345 1572.5 -1320 1567.5 -1320 1567.5 -1345 {}
P 1 14 2080 -1300 2102.5 -1300 2107.5 -1300 2107.5 -1295 2107.5 -1252.5 2100 -1227.5 2095 -1227.5 2065 -1227.5 2060 -1227.5 2052.5 -1252.5 2052.5 -1295 2052.5 -1300 2057.5 -1300 2080 -1300 {bezier=1}
P 1 14 2095 -1297.5 2100 -1297.5 2105 -1297.5 2105 -1292.5 2105 -1272.5 2105 -1267.5 2100 -1267.5 2090 -1267.5 2085 -1267.5 2085 -1272.5 2085 -1292.5 2085 -1297.5 2090 -1297.5 2095 -1297.5 {bezier=1}
P 1 5 2077.5 -1295 2082.5 -1295 2082.5 -1270 2077.5 -1270 2077.5 -1295 {}
P 1 10 2080 -1445 2105 -1445 2115 -1435 2115 -1405 2105 -1395 2055 -1395 2045 -1405 2045 -1435 2055 -1445 2080 -1445 {bezier=1}
P 1 10 2080 -1450 2110 -1450 2120 -1440 2120 -1400 2110 -1390 2050 -1390 2040 -1400 2040 -1440 2050 -1450 2080 -1450 {bezier=1}
P 1 10 2080 -1375 2105 -1375 2115 -1365 2115 -1335 2105 -1325 2055 -1325 2045 -1335 2045 -1365 2055 -1375 2080 -1375 {bezier=1}
P 1 10 2080 -1380 2110 -1380 2120 -1370 2120 -1330 2110 -1320 2050 -1320 2040 -1330 2040 -1370 2050 -1380 2080 -1380 {bezier=1}
P 1 10 1920 -3185 1945 -3185 1955 -3175 1955 -3145 1945 -3135 1895 -3135 1885 -3145 1885 -3175 1895 -3185 1920 -3185 {bezier=1}
P 1 10 1920 -3190 1950 -3190 1960 -3180 1960 -3140 1950 -3130 1890 -3130 1880 -3140 1880 -3180 1890 -3190 1920 -3190 {bezier=1}
P 1 10 1830 -2755 1855 -2755 1865 -2745 1865 -2715 1855 -2705 1805 -2705 1795 -2715 1795 -2745 1805 -2755 1830 -2755 {bezier=1}
P 1 10 1830 -2760 1860 -2760 1870 -2750 1870 -2710 1860 -2700 1800 -2700 1790 -2710 1790 -2750 1800 -2760 1830 -2760 {bezier=1}
P 1 14 2500 -4160 2522.5 -4160 2527.5 -4160 2527.5 -4155 2527.5 -4112.5 2520 -4087.5 2515 -4087.5 2485 -4087.5 2480 -4087.5 2472.5 -4112.5 2472.5 -4155 2472.5 -4160 2477.5 -4160 2500 -4160 {bezier=1}
P 1 14 2515 -4157.5 2520 -4157.5 2525 -4157.5 2525 -4152.5 2525 -4132.5 2525 -4127.5 2520 -4127.5 2510 -4127.5 2505 -4127.5 2505 -4132.5 2505 -4152.5 2505 -4157.5 2510 -4157.5 2515 -4157.5 {bezier=1}
P 1 5 2497.5 -4155 2502.5 -4155 2502.5 -4130 2497.5 -4130 2497.5 -4155 {}
P 1 10 1290 -2105 1315 -2105 1325 -2095 1325 -2065 1315 -2055 1265 -2055 1255 -2065 1255 -2095 1265 -2105 1290 -2105 {bezier=1}
P 1 10 1290 -2110 1320 -2110 1330 -2100 1330 -2060 1320 -2050 1260 -2050 1250 -2060 1250 -2100 1260 -2110 1290 -2110 {bezier=1}
P 1 14 1820 -2200 1842.5 -2200 1847.5 -2200 1847.5 -2195 1847.5 -2152.5 1840 -2127.5 1835 -2127.5 1805 -2127.5 1800 -2127.5 1792.5 -2152.5 1792.5 -2195 1792.5 -2200 1797.5 -2200 1820 -2200 {bezier=1}
P 1 14 1835 -2197.5 1840 -2197.5 1845 -2197.5 1845 -2192.5 1845 -2172.5 1845 -2167.5 1840 -2167.5 1830 -2167.5 1825 -2167.5 1825 -2172.5 1825 -2192.5 1825 -2197.5 1830 -2197.5 1835 -2197.5 {bezier=1}
P 1 5 1817.5 -2195 1822.5 -2195 1822.5 -2170 1817.5 -2170 1817.5 -2195 {}
P 1 14 670 -2130 692.5 -2130 697.5 -2130 697.5 -2125 697.5 -2082.5 690 -2057.5 685 -2057.5 655 -2057.5 650 -2057.5 642.5 -2082.5 642.5 -2125 642.5 -2130 647.5 -2130 670 -2130 {bezier=1}
P 1 14 685 -2127.5 690 -2127.5 695 -2127.5 695 -2122.5 695 -2102.5 695 -2097.5 690 -2097.5 680 -2097.5 675 -2097.5 675 -2102.5 675 -2122.5 675 -2127.5 680 -2127.5 685 -2127.5 {bezier=1}
P 1 5 667.5 -2125 672.5 -2125 672.5 -2100 667.5 -2100 667.5 -2125 {}
P 1 14 790 -2130 812.5 -2130 817.5 -2130 817.5 -2125 817.5 -2082.5 810 -2057.5 805 -2057.5 775 -2057.5 770 -2057.5 762.5 -2082.5 762.5 -2125 762.5 -2130 767.5 -2130 790 -2130 {bezier=1}
P 1 14 805 -2127.5 810 -2127.5 815 -2127.5 815 -2122.5 815 -2102.5 815 -2097.5 810 -2097.5 800 -2097.5 795 -2097.5 795 -2102.5 795 -2122.5 795 -2127.5 800 -2127.5 805 -2127.5 {bezier=1}
P 1 5 787.5 -2125 792.5 -2125 792.5 -2100 787.5 -2100 787.5 -2125 {}
P 1 10 790 -2035 815 -2035 825 -2025 825 -1995 815 -1985 765 -1985 755 -1995 755 -2025 765 -2035 790 -2035 {bezier=1}
P 1 10 790 -2040 820 -2040 830 -2030 830 -1990 820 -1980 760 -1980 750 -1990 750 -2030 760 -2040 790 -2040 {bezier=1}
P 1 14 1600 -800 1622.5 -800 1627.5 -800 1627.5 -795 1627.5 -752.5 1620 -727.5 1615 -727.5 1585 -727.5 1580 -727.5 1572.5 -752.5 1572.5 -795 1572.5 -800 1577.5 -800 1600 -800 {bezier=1}
P 1 14 1585 -797.5 1580 -797.5 1575 -797.5 1575 -792.5 1575 -772.5 1575 -767.5 1580 -767.5 1590 -767.5 1595 -767.5 1595 -772.5 1595 -792.5 1595 -797.5 1590 -797.5 1585 -797.5 {bezier=1}
P 1 5 1597.5 -795 1602.5 -795 1602.5 -770 1597.5 -770 1597.5 -795 {}
P 1 10 1600 -875 1625 -875 1635 -865 1635 -835 1625 -825 1575 -825 1565 -835 1565 -865 1575 -875 1600 -875 {bezier=1}
P 1 10 1600 -880 1630 -880 1640 -870 1640 -830 1630 -820 1570 -820 1560 -830 1560 -870 1570 -880 1600 -880 {bezier=1}
P 1 10 1920 -2615 1945 -2615 1955 -2605 1955 -2575 1945 -2565 1895 -2565 1885 -2575 1885 -2605 1895 -2615 1920 -2615 {bezier=1}
P 1 10 1920 -2620 1950 -2620 1960 -2610 1960 -2570 1950 -2560 1890 -2560 1880 -2570 1880 -2610 1890 -2620 1920 -2620 {bezier=1}
P 1 14 2280 -5280 2302.5 -5280 2307.5 -5280 2307.5 -5275 2307.5 -5232.5 2300 -5207.5 2295 -5207.5 2265 -5207.5 2260 -5207.5 2252.5 -5232.5 2252.5 -5275 2252.5 -5280 2257.5 -5280 2280 -5280 {bezier=1}
P 1 14 2295 -5277.5 2300 -5277.5 2305 -5277.5 2305 -5272.5 2305 -5252.5 2305 -5247.5 2300 -5247.5 2290 -5247.5 2285 -5247.5 2285 -5252.5 2285 -5272.5 2285 -5277.5 2290 -5277.5 2295 -5277.5 {bezier=1}
P 1 5 2277.5 -5275 2282.5 -5275 2282.5 -5250 2277.5 -5250 2277.5 -5275 {}
P 1 10 2370 -5265 2395 -5265 2405 -5255 2405 -5225 2395 -5215 2345 -5215 2335 -5225 2335 -5255 2345 -5265 2370 -5265 {bezier=1}
P 1 10 2370 -5270 2400 -5270 2410 -5260 2410 -5220 2400 -5210 2340 -5210 2330 -5220 2330 -5260 2340 -5270 2370 -5270 {bezier=1}
P 1 14 1980 -4490 2002.5 -4490 2007.5 -4490 2007.5 -4485 2007.5 -4442.5 2000 -4417.5 1995 -4417.5 1965 -4417.5 1960 -4417.5 1952.5 -4442.5 1952.5 -4485 1952.5 -4490 1957.5 -4490 1980 -4490 {bezier=1}
P 1 14 1995 -4487.5 2000 -4487.5 2005 -4487.5 2005 -4482.5 2005 -4462.5 2005 -4457.5 2000 -4457.5 1990 -4457.5 1985 -4457.5 1985 -4462.5 1985 -4482.5 1985 -4487.5 1990 -4487.5 1995 -4487.5 {bezier=1}
P 1 5 1977.5 -4485 1982.5 -4485 1982.5 -4460 1977.5 -4460 1977.5 -4485 {}
P 1 10 1980 -4645 2005 -4645 2015 -4635 2015 -4605 2005 -4595 1955 -4595 1945 -4605 1945 -4635 1955 -4645 1980 -4645 {bezier=1}
P 1 10 1980 -4650 2010 -4650 2020 -4640 2020 -4600 2010 -4590 1950 -4590 1940 -4600 1940 -4640 1950 -4650 1980 -4650 {bezier=1}
P 1 10 1980 -4565 2005 -4565 2015 -4555 2015 -4525 2005 -4515 1955 -4515 1945 -4525 1945 -4555 1955 -4565 1980 -4565 {bezier=1}
P 1 10 1980 -4570 2010 -4570 2020 -4560 2020 -4520 2010 -4510 1950 -4510 1940 -4520 1940 -4560 1950 -4570 1980 -4570 {bezier=1}
P 1 14 2340 -2790 2362.5 -2790 2367.5 -2790 2367.5 -2785 2367.5 -2742.5 2360 -2717.5 2355 -2717.5 2325 -2717.5 2320 -2717.5 2312.5 -2742.5 2312.5 -2785 2312.5 -2790 2317.5 -2790 2340 -2790 {bezier=1}
P 1 14 2355 -2787.5 2360 -2787.5 2365 -2787.5 2365 -2782.5 2365 -2762.5 2365 -2757.5 2360 -2757.5 2350 -2757.5 2345 -2757.5 2345 -2762.5 2345 -2782.5 2345 -2787.5 2350 -2787.5 2355 -2787.5 {bezier=1}
P 1 5 2337.5 -2785 2342.5 -2785 2342.5 -2760 2337.5 -2760 2337.5 -2785 {}
P 1 14 810 -2910 832.5 -2910 837.5 -2910 837.5 -2905 837.5 -2862.5 830 -2837.5 825 -2837.5 795 -2837.5 790 -2837.5 782.5 -2862.5 782.5 -2905 782.5 -2910 787.5 -2910 810 -2910 {bezier=1}
P 1 14 825 -2907.5 830 -2907.5 835 -2907.5 835 -2902.5 835 -2882.5 835 -2877.5 830 -2877.5 820 -2877.5 815 -2877.5 815 -2882.5 815 -2902.5 815 -2907.5 820 -2907.5 825 -2907.5 {bezier=1}
P 1 5 807.5 -2905 812.5 -2905 812.5 -2880 807.5 -2880 807.5 -2905 {}
P 1 14 1350 -2890 1372.5 -2890 1377.5 -2890 1377.5 -2885 1377.5 -2842.5 1370 -2817.5 1365 -2817.5 1335 -2817.5 1330 -2817.5 1322.5 -2842.5 1322.5 -2885 1322.5 -2890 1327.5 -2890 1350 -2890 {bezier=1}
P 1 14 1365 -2887.5 1370 -2887.5 1375 -2887.5 1375 -2882.5 1375 -2862.5 1375 -2857.5 1370 -2857.5 1360 -2857.5 1355 -2857.5 1355 -2862.5 1355 -2882.5 1355 -2887.5 1360 -2887.5 1365 -2887.5 {bezier=1}
P 1 5 1347.5 -2885 1352.5 -2885 1352.5 -2860 1347.5 -2860 1347.5 -2885 {}
P 1 14 1260 -2510 1282.5 -2510 1287.5 -2510 1287.5 -2505 1287.5 -2462.5 1280 -2437.5 1275 -2437.5 1245 -2437.5 1240 -2437.5 1232.5 -2462.5 1232.5 -2505 1232.5 -2510 1237.5 -2510 1260 -2510 {bezier=1}
P 1 14 1275 -2507.5 1280 -2507.5 1285 -2507.5 1285 -2502.5 1285 -2482.5 1285 -2477.5 1280 -2477.5 1270 -2477.5 1265 -2477.5 1265 -2482.5 1265 -2502.5 1265 -2507.5 1270 -2507.5 1275 -2507.5 {bezier=1}
P 1 5 1257.5 -2505 1262.5 -2505 1262.5 -2480 1257.5 -2480 1257.5 -2505 {}
P 1 14 2520 -2460 2542.5 -2460 2547.5 -2460 2547.5 -2455 2547.5 -2412.5 2540 -2387.5 2535 -2387.5 2505 -2387.5 2500 -2387.5 2492.5 -2412.5 2492.5 -2455 2492.5 -2460 2497.5 -2460 2520 -2460 {bezier=1}
P 1 14 2535 -2457.5 2540 -2457.5 2545 -2457.5 2545 -2452.5 2545 -2432.5 2545 -2427.5 2540 -2427.5 2530 -2427.5 2525 -2427.5 2525 -2432.5 2525 -2452.5 2525 -2457.5 2530 -2457.5 2535 -2457.5 {bezier=1}
P 1 5 2517.5 -2455 2522.5 -2455 2522.5 -2430 2517.5 -2430 2517.5 -2455 {}
P 1 14 2480 -1050 2502.5 -1050 2507.5 -1050 2507.5 -1045 2507.5 -1002.5 2500 -977.5 2495 -977.5 2465 -977.5 2460 -977.5 2452.5 -1002.5 2452.5 -1045 2452.5 -1050 2457.5 -1050 2480 -1050 {bezier=1}
P 1 14 2495 -1047.5 2490 -1047.5 2485 -1047.5 2485 -1042.5 2485 -1022.5 2485 -1017.5 2490 -1017.5 2500 -1017.5 2505 -1017.5 2505 -1022.5 2505 -1042.5 2505 -1047.5 2500 -1047.5 2495 -1047.5 {bezier=1}
P 1 5 2477.5 -1045 2482.5 -1045 2482.5 -1020 2477.5 -1020 2477.5 -1045 {}
P 1 14 370 -8140 392.5 -8140 397.5 -8140 397.5 -8135 397.5 -8092.5 390 -8067.5 385 -8067.5 355 -8067.5 350 -8067.5 342.5 -8092.5 342.5 -8135 342.5 -8140 347.5 -8140 370 -8140 {bezier=1}
P 1 14 385 -8137.5 390 -8137.5 395 -8137.5 395 -8132.5 395 -8112.5 395 -8107.5 390 -8107.5 380 -8107.5 375 -8107.5 375 -8112.5 375 -8132.5 375 -8137.5 380 -8137.5 385 -8137.5 {bezier=1}
P 1 5 367.5 -8135 372.5 -8135 372.5 -8110 367.5 -8110 367.5 -8135 {}
P 1 14 900 -8310 922.5 -8310 927.5 -8310 927.5 -8305 927.5 -8262.5 920 -8237.5 915 -8237.5 885 -8237.5 880 -8237.5 872.5 -8262.5 872.5 -8305 872.5 -8310 877.5 -8310 900 -8310 {bezier=1}
P 1 14 915 -8307.5 920 -8307.5 925 -8307.5 925 -8302.5 925 -8282.5 925 -8277.5 920 -8277.5 910 -8277.5 905 -8277.5 905 -8282.5 905 -8302.5 905 -8307.5 910 -8307.5 915 -8307.5 {bezier=1}
P 1 5 897.5 -8305 902.5 -8305 902.5 -8280 897.5 -8280 897.5 -8305 {}
P 1 14 1150 -8350 1172.5 -8350 1177.5 -8350 1177.5 -8345 1177.5 -8302.5 1170 -8277.5 1165 -8277.5 1135 -8277.5 1130 -8277.5 1122.5 -8302.5 1122.5 -8345 1122.5 -8350 1127.5 -8350 1150 -8350 {bezier=1}
P 1 14 1165 -8347.5 1170 -8347.5 1175 -8347.5 1175 -8342.5 1175 -8322.5 1175 -8317.5 1170 -8317.5 1160 -8317.5 1155 -8317.5 1155 -8322.5 1155 -8342.5 1155 -8347.5 1160 -8347.5 1165 -8347.5 {bezier=1}
P 1 5 1147.5 -8345 1152.5 -8345 1152.5 -8320 1147.5 -8320 1147.5 -8345 {}
P 1 14 1440 -8350 1462.5 -8350 1467.5 -8350 1467.5 -8345 1467.5 -8302.5 1460 -8277.5 1455 -8277.5 1425 -8277.5 1420 -8277.5 1412.5 -8302.5 1412.5 -8345 1412.5 -8350 1417.5 -8350 1440 -8350 {bezier=1}
P 1 14 1455 -8347.5 1460 -8347.5 1465 -8347.5 1465 -8342.5 1465 -8322.5 1465 -8317.5 1460 -8317.5 1450 -8317.5 1445 -8317.5 1445 -8322.5 1445 -8342.5 1445 -8347.5 1450 -8347.5 1455 -8347.5 {bezier=1}
P 1 5 1437.5 -8345 1442.5 -8345 1442.5 -8320 1437.5 -8320 1437.5 -8345 {}
P 1 14 1900 -8310 1922.5 -8310 1927.5 -8310 1927.5 -8305 1927.5 -8262.5 1920 -8237.5 1915 -8237.5 1885 -8237.5 1880 -8237.5 1872.5 -8262.5 1872.5 -8305 1872.5 -8310 1877.5 -8310 1900 -8310 {bezier=1}
P 1 14 1915 -8307.5 1920 -8307.5 1925 -8307.5 1925 -8302.5 1925 -8282.5 1925 -8277.5 1920 -8277.5 1910 -8277.5 1905 -8277.5 1905 -8282.5 1905 -8302.5 1905 -8307.5 1910 -8307.5 1915 -8307.5 {bezier=1}
P 1 5 1897.5 -8305 1902.5 -8305 1902.5 -8280 1897.5 -8280 1897.5 -8305 {}
P 1 14 930 -4860 952.5 -4860 957.5 -4860 957.5 -4855 957.5 -4812.5 950 -4787.5 945 -4787.5 915 -4787.5 910 -4787.5 902.5 -4812.5 902.5 -4855 902.5 -4860 907.5 -4860 930 -4860 {bezier=1}
P 1 14 945 -4857.5 950 -4857.5 955 -4857.5 955 -4852.5 955 -4832.5 955 -4827.5 950 -4827.5 940 -4827.5 935 -4827.5 935 -4832.5 935 -4852.5 935 -4857.5 940 -4857.5 945 -4857.5 {bezier=1}
P 1 5 927.5 -4855 932.5 -4855 932.5 -4830 927.5 -4830 927.5 -4855 {}
P 1 14 1770 -4910 1792.5 -4910 1797.5 -4910 1797.5 -4905 1797.5 -4862.5 1790 -4837.5 1785 -4837.5 1755 -4837.5 1750 -4837.5 1742.5 -4862.5 1742.5 -4905 1742.5 -4910 1747.5 -4910 1770 -4910 {bezier=1}
P 1 14 1785 -4907.5 1790 -4907.5 1795 -4907.5 1795 -4902.5 1795 -4882.5 1795 -4877.5 1790 -4877.5 1780 -4877.5 1775 -4877.5 1775 -4882.5 1775 -4902.5 1775 -4907.5 1780 -4907.5 1785 -4907.5 {bezier=1}
P 1 5 1767.5 -4905 1772.5 -4905 1772.5 -4880 1767.5 -4880 1767.5 -4905 {}
P 1 14 2530 -4910 2552.5 -4910 2557.5 -4910 2557.5 -4905 2557.5 -4862.5 2550 -4837.5 2545 -4837.5 2515 -4837.5 2510 -4837.5 2502.5 -4862.5 2502.5 -4905 2502.5 -4910 2507.5 -4910 2530 -4910 {bezier=1}
P 1 14 2545 -4907.5 2550 -4907.5 2555 -4907.5 2555 -4902.5 2555 -4882.5 2555 -4877.5 2550 -4877.5 2540 -4877.5 2535 -4877.5 2535 -4882.5 2535 -4902.5 2535 -4907.5 2540 -4907.5 2545 -4907.5 {bezier=1}
P 1 5 2527.5 -4905 2532.5 -4905 2532.5 -4880 2527.5 -4880 2527.5 -4905 {}
P 1 14 905 -9130 927.5 -9130 932.5 -9130 932.5 -9125 932.5 -9082.5 925 -9057.5 920 -9057.5 890 -9057.5 885 -9057.5 877.5 -9082.5 877.5 -9125 877.5 -9130 882.5 -9130 905 -9130 {bezier=1}
P 1 14 920 -9127.5 925 -9127.5 930 -9127.5 930 -9122.5 930 -9102.5 930 -9097.5 925 -9097.5 915 -9097.5 910 -9097.5 910 -9102.5 910 -9122.5 910 -9127.5 915 -9127.5 920 -9127.5 {bezier=1}
P 1 5 902.5 -9125 907.5 -9125 907.5 -9100 902.5 -9100 902.5 -9125 {}
P 1 14 1440 -9010 1462.5 -9010 1467.5 -9010 1467.5 -9005 1467.5 -8962.5 1460 -8937.5 1455 -8937.5 1425 -8937.5 1420 -8937.5 1412.5 -8962.5 1412.5 -9005 1412.5 -9010 1417.5 -9010 1440 -9010 {bezier=1}
P 1 14 1455 -9007.5 1460 -9007.5 1465 -9007.5 1465 -9002.5 1465 -8982.5 1465 -8977.5 1460 -8977.5 1450 -8977.5 1445 -8977.5 1445 -8982.5 1445 -9002.5 1445 -9007.5 1450 -9007.5 1455 -9007.5 {bezier=1}
P 1 5 1437.5 -9005 1442.5 -9005 1442.5 -8980 1437.5 -8980 1437.5 -9005 {}
P 1 14 1810 -9010 1832.5 -9010 1837.5 -9010 1837.5 -9005 1837.5 -8962.5 1830 -8937.5 1825 -8937.5 1795 -8937.5 1790 -8937.5 1782.5 -8962.5 1782.5 -9005 1782.5 -9010 1787.5 -9010 1810 -9010 {bezier=1}
P 1 14 1825 -9007.5 1830 -9007.5 1835 -9007.5 1835 -9002.5 1835 -8982.5 1835 -8977.5 1830 -8977.5 1820 -8977.5 1815 -8977.5 1815 -8982.5 1815 -9002.5 1815 -9007.5 1820 -9007.5 1825 -9007.5 {bezier=1}
P 1 5 1807.5 -9005 1812.5 -9005 1812.5 -8980 1807.5 -8980 1807.5 -9005 {}
P 1 14 2300 -9010 2322.5 -9010 2327.5 -9010 2327.5 -9005 2327.5 -8962.5 2320 -8937.5 2315 -8937.5 2285 -8937.5 2280 -8937.5 2272.5 -8962.5 2272.5 -9005 2272.5 -9010 2277.5 -9010 2300 -9010 {bezier=1}
P 1 14 2315 -9007.5 2320 -9007.5 2325 -9007.5 2325 -9002.5 2325 -8982.5 2325 -8977.5 2320 -8977.5 2310 -8977.5 2305 -8977.5 2305 -8982.5 2305 -9002.5 2305 -9007.5 2310 -9007.5 2315 -9007.5 {bezier=1}
P 1 5 2297.5 -9005 2302.5 -9005 2302.5 -8980 2297.5 -8980 2297.5 -9005 {}
P 1 14 2250 -8160 2272.5 -8160 2277.5 -8160 2277.5 -8155 2277.5 -8112.5 2270 -8087.5 2265 -8087.5 2235 -8087.5 2230 -8087.5 2222.5 -8112.5 2222.5 -8155 2222.5 -8160 2227.5 -8160 2250 -8160 {bezier=1}
P 1 14 2265 -8157.5 2270 -8157.5 2275 -8157.5 2275 -8152.5 2275 -8132.5 2275 -8127.5 2270 -8127.5 2260 -8127.5 2255 -8127.5 2255 -8132.5 2255 -8152.5 2255 -8157.5 2260 -8157.5 2265 -8157.5 {bezier=1}
P 1 5 2247.5 -8155 2252.5 -8155 2252.5 -8130 2247.5 -8130 2247.5 -8155 {}
P 1 10 1980 -8305 2005 -8305 2015 -8295 2015 -8265 2005 -8255 1955 -8255 1945 -8265 1945 -8295 1955 -8305 1980 -8305 {bezier=1}
P 1 10 1980 -8310 2010 -8310 2020 -8300 2020 -8260 2010 -8250 1950 -8250 1940 -8260 1940 -8300 1950 -8310 1980 -8310 {bezier=1}
P 1 10 510 -7815 535 -7815 545 -7805 545 -7775 535 -7765 485 -7765 475 -7775 475 -7805 485 -7815 510 -7815 {bezier=1}
P 1 10 510 -7820 540 -7820 550 -7810 550 -7770 540 -7760 480 -7760 470 -7770 470 -7810 480 -7820 510 -7820 {bezier=1}
P 1 10 510 -7745 535 -7745 545 -7735 545 -7705 535 -7695 485 -7695 475 -7705 475 -7735 485 -7745 510 -7745 {bezier=1}
P 1 10 510 -7750 540 -7750 550 -7740 550 -7700 540 -7690 480 -7690 470 -7700 470 -7740 480 -7750 510 -7750 {bezier=1}
P 1 10 820 -7815 845 -7815 855 -7805 855 -7775 845 -7765 795 -7765 785 -7775 785 -7805 795 -7815 820 -7815 {bezier=1}
P 1 10 820 -7820 850 -7820 860 -7810 860 -7770 850 -7760 790 -7760 780 -7770 780 -7810 790 -7820 820 -7820 {bezier=1}
P 1 10 820 -7745 845 -7745 855 -7735 855 -7705 845 -7695 795 -7695 785 -7705 785 -7735 795 -7745 820 -7745 {bezier=1}
P 1 10 820 -7750 850 -7750 860 -7740 860 -7700 850 -7690 790 -7690 780 -7700 780 -7740 790 -7750 820 -7750 {bezier=1}
P 1 10 1120 -7815 1145 -7815 1155 -7805 1155 -7775 1145 -7765 1095 -7765 1085 -7775 1085 -7805 1095 -7815 1120 -7815 {bezier=1}
P 1 10 1120 -7820 1150 -7820 1160 -7810 1160 -7770 1150 -7760 1090 -7760 1080 -7770 1080 -7810 1090 -7820 1120 -7820 {bezier=1}
P 1 10 1120 -7745 1145 -7745 1155 -7735 1155 -7705 1145 -7695 1095 -7695 1085 -7705 1085 -7735 1095 -7745 1120 -7745 {bezier=1}
P 1 10 1120 -7750 1150 -7750 1160 -7740 1160 -7700 1150 -7690 1090 -7690 1080 -7700 1080 -7740 1090 -7750 1120 -7750 {bezier=1}
P 1 10 1430 -7815 1455 -7815 1465 -7805 1465 -7775 1455 -7765 1405 -7765 1395 -7775 1395 -7805 1405 -7815 1430 -7815 {bezier=1}
P 1 10 1430 -7820 1460 -7820 1470 -7810 1470 -7770 1460 -7760 1400 -7760 1390 -7770 1390 -7810 1400 -7820 1430 -7820 {bezier=1}
P 1 10 1430 -7745 1455 -7745 1465 -7735 1465 -7705 1455 -7695 1405 -7695 1395 -7705 1395 -7735 1405 -7745 1430 -7745 {bezier=1}
P 1 10 1430 -7750 1460 -7750 1470 -7740 1470 -7700 1460 -7690 1400 -7690 1390 -7700 1390 -7740 1400 -7750 1430 -7750 {bezier=1}
P 1 10 1750 -7815 1775 -7815 1785 -7805 1785 -7775 1775 -7765 1725 -7765 1715 -7775 1715 -7805 1725 -7815 1750 -7815 {bezier=1}
P 1 10 1750 -7820 1780 -7820 1790 -7810 1790 -7770 1780 -7760 1720 -7760 1710 -7770 1710 -7810 1720 -7820 1750 -7820 {bezier=1}
P 1 10 1750 -7745 1775 -7745 1785 -7735 1785 -7705 1775 -7695 1725 -7695 1715 -7705 1715 -7735 1725 -7745 1750 -7745 {bezier=1}
P 1 10 1750 -7750 1780 -7750 1790 -7740 1790 -7700 1780 -7690 1720 -7690 1710 -7700 1710 -7740 1720 -7750 1750 -7750 {bezier=1}
P 1 10 2080 -7815 2105 -7815 2115 -7805 2115 -7775 2105 -7765 2055 -7765 2045 -7775 2045 -7805 2055 -7815 2080 -7815 {bezier=1}
P 1 10 2080 -7820 2110 -7820 2120 -7810 2120 -7770 2110 -7760 2050 -7760 2040 -7770 2040 -7810 2050 -7820 2080 -7820 {bezier=1}
P 1 10 2080 -7745 2105 -7745 2115 -7735 2115 -7705 2105 -7695 2055 -7695 2045 -7705 2045 -7735 2055 -7745 2080 -7745 {bezier=1}
P 1 10 2080 -7750 2110 -7750 2120 -7740 2120 -7700 2110 -7690 2050 -7690 2040 -7700 2040 -7740 2050 -7750 2080 -7750 {bezier=1}
P 1 10 1940 -7625 1965 -7625 1975 -7615 1975 -7585 1965 -7575 1915 -7575 1905 -7585 1905 -7615 1915 -7625 1940 -7625 {bezier=1}
P 1 10 1940 -7630 1970 -7630 1980 -7620 1980 -7580 1970 -7570 1910 -7570 1900 -7580 1900 -7620 1910 -7630 1940 -7630 {bezier=1}
P 1 10 1940 -7555 1965 -7555 1975 -7545 1975 -7515 1965 -7505 1915 -7505 1905 -7515 1905 -7545 1915 -7555 1940 -7555 {bezier=1}
P 1 10 1940 -7560 1970 -7560 1980 -7550 1980 -7510 1970 -7500 1910 -7500 1900 -7510 1900 -7550 1910 -7560 1940 -7560 {bezier=1}
P 1 14 2050 -7610 2072.5 -7610 2077.5 -7610 2077.5 -7605 2077.5 -7562.5 2070 -7537.5 2065 -7537.5 2035 -7537.5 2030 -7537.5 2022.5 -7562.5 2022.5 -7605 2022.5 -7610 2027.5 -7610 2050 -7610 {bezier=1}
P 1 14 2065 -7607.5 2070 -7607.5 2075 -7607.5 2075 -7602.5 2075 -7582.5 2075 -7577.5 2070 -7577.5 2060 -7577.5 2055 -7577.5 2055 -7582.5 2055 -7602.5 2055 -7607.5 2060 -7607.5 2065 -7607.5 {bezier=1}
P 1 5 2047.5 -7605 2052.5 -7605 2052.5 -7580 2047.5 -7580 2047.5 -7605 {}
P 1 14 2035 -7607.5 2040 -7607.5 2045 -7607.5 2045 -7602.5 2045 -7582.5 2045 -7577.5 2040 -7577.5 2030 -7577.5 2025 -7577.5 2025 -7582.5 2025 -7602.5 2025 -7607.5 2030 -7607.5 2035 -7607.5 {bezier=1}
P 1 10 1940 -7195 1965 -7195 1975 -7185 1975 -7155 1965 -7145 1915 -7145 1905 -7155 1905 -7185 1915 -7195 1940 -7195 {bezier=1}
P 1 10 1940 -7200 1970 -7200 1980 -7190 1980 -7150 1970 -7140 1910 -7140 1900 -7150 1900 -7190 1910 -7200 1940 -7200 {bezier=1}
P 1 10 1940 -7125 1965 -7125 1975 -7115 1975 -7085 1965 -7075 1915 -7075 1905 -7085 1905 -7115 1915 -7125 1940 -7125 {bezier=1}
P 1 10 1940 -7130 1970 -7130 1980 -7120 1980 -7080 1970 -7070 1910 -7070 1900 -7080 1900 -7120 1910 -7130 1940 -7130 {bezier=1}
P 1 14 2050 -7180 2072.5 -7180 2077.5 -7180 2077.5 -7175 2077.5 -7132.5 2070 -7107.5 2065 -7107.5 2035 -7107.5 2030 -7107.5 2022.5 -7132.5 2022.5 -7175 2022.5 -7180 2027.5 -7180 2050 -7180 {bezier=1}
P 1 14 2065 -7177.5 2070 -7177.5 2075 -7177.5 2075 -7172.5 2075 -7152.5 2075 -7147.5 2070 -7147.5 2060 -7147.5 2055 -7147.5 2055 -7152.5 2055 -7172.5 2055 -7177.5 2060 -7177.5 2065 -7177.5 {bezier=1}
P 1 5 2047.5 -7175 2052.5 -7175 2052.5 -7150 2047.5 -7150 2047.5 -7175 {}
P 1 14 2035 -7177.5 2040 -7177.5 2045 -7177.5 2045 -7172.5 2045 -7152.5 2045 -7147.5 2040 -7147.5 2030 -7147.5 2025 -7147.5 2025 -7152.5 2025 -7172.5 2025 -7177.5 2030 -7177.5 2035 -7177.5 {bezier=1}
P 1 10 1050 -6715 1075 -6715 1085 -6705 1085 -6675 1075 -6665 1025 -6665 1015 -6675 1015 -6705 1025 -6715 1050 -6715 {bezier=1}
P 1 10 1050 -6720 1080 -6720 1090 -6710 1090 -6670 1080 -6660 1020 -6660 1010 -6670 1010 -6710 1020 -6720 1050 -6720 {bezier=1}
P 1 10 1050 -6645 1075 -6645 1085 -6635 1085 -6605 1075 -6595 1025 -6595 1015 -6605 1015 -6635 1025 -6645 1050 -6645 {bezier=1}
P 1 10 1050 -6650 1080 -6650 1090 -6640 1090 -6600 1080 -6590 1020 -6590 1010 -6600 1010 -6640 1020 -6650 1050 -6650 {bezier=1}
P 1 14 1160 -6700 1182.5 -6700 1187.5 -6700 1187.5 -6695 1187.5 -6652.5 1180 -6627.5 1175 -6627.5 1145 -6627.5 1140 -6627.5 1132.5 -6652.5 1132.5 -6695 1132.5 -6700 1137.5 -6700 1160 -6700 {bezier=1}
P 1 14 1175 -6697.5 1180 -6697.5 1185 -6697.5 1185 -6692.5 1185 -6672.5 1185 -6667.5 1180 -6667.5 1170 -6667.5 1165 -6667.5 1165 -6672.5 1165 -6692.5 1165 -6697.5 1170 -6697.5 1175 -6697.5 {bezier=1}
P 1 5 1157.5 -6695 1162.5 -6695 1162.5 -6670 1157.5 -6670 1157.5 -6695 {}
P 1 14 1145 -6697.5 1150 -6697.5 1155 -6697.5 1155 -6692.5 1155 -6672.5 1155 -6667.5 1150 -6667.5 1140 -6667.5 1135 -6667.5 1135 -6672.5 1135 -6692.5 1135 -6697.5 1140 -6697.5 1145 -6697.5 {bezier=1}
P 1 14 2480 -8220 2502.5 -8220 2507.5 -8220 2507.5 -8215 2507.5 -8172.5 2500 -8147.5 2495 -8147.5 2465 -8147.5 2460 -8147.5 2452.5 -8172.5 2452.5 -8215 2452.5 -8220 2457.5 -8220 2480 -8220 {bezier=1}
P 1 14 2495 -8217.5 2500 -8217.5 2505 -8217.5 2505 -8212.5 2505 -8192.5 2505 -8187.5 2500 -8187.5 2490 -8187.5 2485 -8187.5 2485 -8192.5 2485 -8212.5 2485 -8217.5 2490 -8217.5 2495 -8217.5 {bezier=1}
P 1 5 2477.5 -8215 2482.5 -8215 2482.5 -8190 2477.5 -8190 2477.5 -8215 {}
P 1 10 1520 -5945 1545 -5945 1555 -5935 1555 -5905 1545 -5895 1495 -5895 1485 -5905 1485 -5935 1495 -5945 1520 -5945 {bezier=1}
P 1 10 1520 -5950 1550 -5950 1560 -5940 1560 -5900 1550 -5890 1490 -5890 1480 -5900 1480 -5940 1490 -5950 1520 -5950 {bezier=1}
P 1 14 620 -8350 642.5 -8350 647.5 -8350 647.5 -8345 647.5 -8302.5 640 -8277.5 635 -8277.5 605 -8277.5 600 -8277.5 592.5 -8302.5 592.5 -8345 592.5 -8350 597.5 -8350 620 -8350 {bezier=1}
P 1 14 635 -8347.5 640 -8347.5 645 -8347.5 645 -8342.5 645 -8322.5 645 -8317.5 640 -8317.5 630 -8317.5 625 -8317.5 625 -8322.5 625 -8342.5 625 -8347.5 630 -8347.5 635 -8347.5 {bezier=1}
P 1 5 617.5 -8345 622.5 -8345 622.5 -8320 617.5 -8320 617.5 -8345 {}
P 1 10 1430 -465 1455 -465 1465 -455 1465 -425 1455 -415 1405 -415 1395 -425 1395 -455 1405 -465 1430 -465 {bezier=1}
P 1 10 1430 -470 1460 -470 1470 -460 1470 -420 1460 -410 1400 -410 1390 -420 1390 -460 1400 -470 1430 -470 {bezier=1}
P 1 10 1430 -395 1455 -395 1465 -385 1465 -355 1455 -345 1405 -345 1395 -355 1395 -385 1405 -395 1430 -395 {bezier=1}
P 1 10 1430 -400 1460 -400 1470 -390 1470 -350 1460 -340 1400 -340 1390 -350 1390 -390 1400 -400 1430 -400 {bezier=1}
P 1 10 2310 -465 2335 -465 2345 -455 2345 -425 2335 -415 2285 -415 2275 -425 2275 -455 2285 -465 2310 -465 {bezier=1}
P 1 10 2310 -470 2340 -470 2350 -460 2350 -420 2340 -410 2280 -410 2270 -420 2270 -460 2280 -470 2310 -470 {bezier=1}
P 1 10 2310 -395 2335 -395 2345 -385 2345 -355 2335 -345 2285 -345 2275 -355 2275 -385 2285 -395 2310 -395 {bezier=1}
P 1 10 2310 -400 2340 -400 2350 -390 2350 -350 2340 -340 2280 -340 2270 -350 2270 -390 2280 -400 2310 -400 {bezier=1}
P 1 10 1010 -155 1035 -155 1045 -145 1045 -115 1035 -105 985 -105 975 -115 975 -145 985 -155 1010 -155 {bezier=1}
P 1 10 1010 -160 1040 -160 1050 -150 1050 -110 1040 -100 980 -100 970 -110 970 -150 980 -160 1010 -160 {bezier=1}
P 1 10 1010 -85 1035 -85 1045 -75 1045 -45 1035 -35 985 -35 975 -45 975 -75 985 -85 1010 -85 {bezier=1}
P 1 10 1010 -90 1040 -90 1050 -80 1050 -40 1040 -30 980 -30 970 -40 970 -80 980 -90 1010 -90 {bezier=1}
P 1 10 1440 -155 1465 -155 1475 -145 1475 -115 1465 -105 1415 -105 1405 -115 1405 -145 1415 -155 1440 -155 {bezier=1}
P 1 10 1440 -160 1470 -160 1480 -150 1480 -110 1470 -100 1410 -100 1400 -110 1400 -150 1410 -160 1440 -160 {bezier=1}
P 1 10 1440 -85 1465 -85 1475 -75 1475 -45 1465 -35 1415 -35 1405 -45 1405 -75 1415 -85 1440 -85 {bezier=1}
P 1 10 1440 -90 1470 -90 1480 -80 1480 -40 1470 -30 1410 -30 1400 -40 1400 -80 1410 -90 1440 -90 {bezier=1}
P 1 10 2370 -215 2395 -215 2405 -205 2405 -175 2395 -165 2345 -165 2335 -175 2335 -205 2345 -215 2370 -215 {bezier=1}
P 1 10 2370 -220 2400 -220 2410 -210 2410 -170 2400 -160 2340 -160 2330 -170 2330 -210 2340 -220 2370 -220 {bezier=1}
P 1 10 2370 -145 2395 -145 2405 -135 2405 -105 2395 -95 2345 -95 2335 -105 2335 -135 2345 -145 2370 -145 {bezier=1}
P 1 10 2370 -150 2400 -150 2410 -140 2410 -100 2400 -90 2340 -90 2330 -100 2330 -140 2340 -150 2370 -150 {bezier=1}
P 1 14 650 -170 672.5 -170 677.5 -170 677.5 -165 677.5 -122.5 670 -97.5 665 -97.5 635 -97.5 630 -97.5 622.5 -122.5 622.5 -165 622.5 -170 627.5 -170 650 -170 {bezier=1}
P 1 14 665 -167.5 670 -167.5 675 -167.5 675 -162.5 675 -142.5 675 -137.5 670 -137.5 660 -137.5 655 -137.5 655 -142.5 655 -162.5 655 -167.5 660 -167.5 665 -167.5 {bezier=1}
P 1 5 647.5 -165 652.5 -165 652.5 -140 647.5 -140 647.5 -165 {}
P 1 14 1100 -170 1122.5 -170 1127.5 -170 1127.5 -165 1127.5 -122.5 1120 -97.5 1115 -97.5 1085 -97.5 1080 -97.5 1072.5 -122.5 1072.5 -165 1072.5 -170 1077.5 -170 1100 -170 {bezier=1}
P 1 14 1115 -167.5 1120 -167.5 1125 -167.5 1125 -162.5 1125 -142.5 1125 -137.5 1120 -137.5 1110 -137.5 1105 -137.5 1105 -142.5 1105 -162.5 1105 -167.5 1110 -167.5 1115 -167.5 {bezier=1}
P 1 5 1097.5 -165 1102.5 -165 1102.5 -140 1097.5 -140 1097.5 -165 {}
P 1 14 1085 -167.5 1090 -167.5 1095 -167.5 1095 -162.5 1095 -142.5 1095 -137.5 1090 -137.5 1080 -137.5 1075 -137.5 1075 -142.5 1075 -162.5 1075 -167.5 1080 -167.5 1085 -167.5 {bezier=1}
P 1 14 1520 -140 1542.5 -140 1547.5 -140 1547.5 -135 1547.5 -92.5 1540 -67.5 1535 -67.5 1505 -67.5 1500 -67.5 1492.5 -92.5 1492.5 -135 1492.5 -140 1497.5 -140 1520 -140 {bezier=1}
P 1 14 1535 -137.5 1540 -137.5 1545 -137.5 1545 -132.5 1545 -112.5 1545 -107.5 1540 -107.5 1530 -107.5 1525 -107.5 1525 -112.5 1525 -132.5 1525 -137.5 1530 -137.5 1535 -137.5 {bezier=1}
P 1 5 1517.5 -135 1522.5 -135 1522.5 -110 1517.5 -110 1517.5 -135 {}
P 1 14 2450 -200 2472.5 -200 2477.5 -200 2477.5 -195 2477.5 -152.5 2470 -127.5 2465 -127.5 2435 -127.5 2430 -127.5 2422.5 -152.5 2422.5 -195 2422.5 -200 2427.5 -200 2450 -200 {bezier=1}
P 1 14 2465 -197.5 2470 -197.5 2475 -197.5 2475 -192.5 2475 -172.5 2475 -167.5 2470 -167.5 2460 -167.5 2455 -167.5 2455 -172.5 2455 -192.5 2455 -197.5 2460 -197.5 2465 -197.5 {bezier=1}
P 1 5 2447.5 -195 2452.5 -195 2452.5 -170 2447.5 -170 2447.5 -195 {}
P 1 14 2210 -11250 2232.5 -11250 2237.5 -11250 2237.5 -11245 2237.5 -11202.5 2230 -11177.5 2225 -11177.5 2195 -11177.5 2190 -11177.5 2182.5 -11202.5 2182.5 -11245 2182.5 -11250 2187.5 -11250 2210 -11250 {bezier=1}
P 1 14 2225 -11247.5 2230 -11247.5 2235 -11247.5 2235 -11242.5 2235 -11222.5 2235 -11217.5 2230 -11217.5 2220 -11217.5 2215 -11217.5 2215 -11222.5 2215 -11242.5 2215 -11247.5 2220 -11247.5 2225 -11247.5 {bezier=1}
P 1 5 2207.5 -11245 2212.5 -11245 2212.5 -11220 2207.5 -11220 2207.5 -11245 {}
P 1 10 2210 -11145 2235 -11145 2245 -11135 2245 -11105 2235 -11095 2185 -11095 2175 -11105 2175 -11135 2185 -11145 2210 -11145 {bezier=1}
P 1 10 2210 -11150 2240 -11150 2250 -11140 2250 -11100 2240 -11090 2180 -11090 2170 -11100 2170 -11140 2180 -11150 2210 -11150 {bezier=1}
P 1 10 2210 -11065 2235 -11065 2245 -11055 2245 -11025 2235 -11015 2185 -11015 2175 -11025 2175 -11055 2185 -11065 2210 -11065 {bezier=1}
P 1 10 2210 -11070 2240 -11070 2250 -11060 2250 -11020 2240 -11010 2180 -11010 2170 -11020 2170 -11060 2180 -11070 2210 -11070 {bezier=1}
P 2 7 897.5 -5400 893.75 -5405 885 -5405 888.75 -5400 885 -5395 893.75 -5395 897.5 -5400 {fill=true}
P 2 7 1457.5 -5400 1453.75 -5405 1445 -5405 1448.75 -5400 1445 -5395 1453.75 -5395 1457.5 -5400 {fill=true}
P 2 7 2277.5 -5400 2273.75 -5405 2265 -5405 2268.75 -5400 2265 -5395 2273.75 -5395 2277.5 -5400 {fill=true}
P 2 7 2030 -1780 2020 -1790 2030 -1790 2030 -1790 2010 -1800 2020 -1780 2020 -1790 {}
P 2 7 1520 -1680 1510 -1690 1520 -1690 1520 -1690 1500 -1700 1510 -1680 1510 -1690 {}
P 2 7 2030 -1400 2020 -1410 2030 -1410 2030 -1410 2010 -1420 2020 -1400 2020 -1410 {}
P 2 7 1520 -1300 1510 -1310 1520 -1310 1520 -1310 1500 -1320 1510 -1300 1510 -1310 {}
P 2 7 455 -7950 451.25 -7955 442.5 -7955 446.25 -7950 442.5 -7945 451.25 -7945 455 -7950 {fill=true}
P 2 7 820 -7955 825 -7958.75 825 -7967.5 820 -7963.75 815 -7967.5 815 -7958.75 820 -7955 {fill=true}
P 2 7 1175 -7880 1178.75 -7875 1187.5 -7875 1183.75 -7880 1187.5 -7885 1178.75 -7885 1175 -7880 {fill=true}
P 2 7 1410 -7885 1405 -7881.25 1405 -7872.5 1410 -7876.25 1415 -7872.5 1415 -7881.25 1410 -7885 {fill=true}
P 2 7 1750 -7885 1755 -7881.25 1755 -7872.5 1750 -7876.25 1745 -7872.5 1745 -7881.25 1750 -7885 {fill=true}
P 2 7 2080 -7965 2085 -7968.75 2085 -7977.5 2080 -7973.75 2075 -7977.5 2075 -7968.75 2080 -7965 {fill=true}
P 2 7 605 -7450 601.25 -7455 592.5 -7455 596.25 -7450 592.5 -7445 601.25 -7445 605 -7450 {fill=true}
P 2 7 1080 -7450 1076.25 -7455 1067.5 -7455 1071.25 -7450 1067.5 -7445 1076.25 -7445 1080 -7450 {fill=true}
P 2 7 1700 -7525 1705 -7528.75 1705 -7537.5 1700 -7533.75 1695 -7537.5 1695 -7528.75 1700 -7525 {fill=true}
P 2 7 605 -7020 601.25 -7025 592.5 -7025 596.25 -7020 592.5 -7015 601.25 -7015 605 -7020 {fill=true}
P 2 7 1055 -7020 1051.25 -7025 1042.5 -7025 1046.25 -7020 1042.5 -7015 1051.25 -7015 1055 -7020 {fill=true}
P 2 7 1765 -7020 1768.75 -7025 1777.5 -7025 1773.75 -7020 1777.5 -7015 1768.75 -7015 1765 -7020 {fill=true}
P 3 6 1280 -2360 1280 -2370 1270 -2370 1280 -2390 1290 -2370 1280 -2370 {}
P 3 6 740 -2360 740 -2370 730 -2370 740 -2390 750 -2370 740 -2370 {}
P 3 6 1750 -4960 1860 -4960 1860 -4970 1900 -4960 1860 -4950 1860 -4960 {}
P 3 6 1680 -4960 1570 -4960 1570 -4970 1530 -4960 1570 -4950 1570 -4960 {}
P 3 6 2420 -4960 2420 -4850 2430 -4850 2420 -4810 2410 -4850 2420 -4850 {}
P 3 6 2420 -4980 2420 -5090 2430 -5090 2420 -5130 2410 -5090 2420 -5090 {}
P 4 4 1115 -7580 1185 -7550 1185 -7440 1125 -7410 {bezier=1}
P 4 4 1122.5 -7415 1127.5 -7405 1105 -7402.5 1122.5 -7415 {fill=1}
P 4 7 1120 -7090 1170 -7090 1170 -7095 1190 -7090 1170 -7085 1170 -7090 1120 -7090 {fill=1}
P 4 7 1120 -7090 1070 -7090 1070 -7095 1050 -7090 1070 -7085 1070 -7090 1120 -7090 {fill=1}
P 5 7 1105 -10260 1101.25 -10265 1092.5 -10265 1096.25 -10260 1092.5 -10255 1101.25 -10255 1105 -10260 {fill=true}
P 5 7 1427.5 -10290 1423.75 -10295 1415 -10295 1418.75 -10290 1415 -10285 1423.75 -10285 1427.5 -10290 {fill=true}
P 5 7 1645 -10260 1641.25 -10265 1632.5 -10265 1636.25 -10260 1632.5 -10255 1641.25 -10255 1645 -10260 {fill=true}
P 5 7 1967.5 -10290 1963.75 -10295 1955 -10295 1958.75 -10290 1955 -10285 1963.75 -10285 1967.5 -10290 {fill=true}
P 5 7 575 -10260 571.25 -10265 562.5 -10265 566.25 -10260 562.5 -10255 571.25 -10255 575 -10260 {fill=true}
P 5 7 897.5 -10290 893.75 -10295 885 -10295 888.75 -10290 885 -10285 893.75 -10285 897.5 -10290 {fill=true}
P 5 7 575 -9800 571.25 -9805 562.5 -9805 566.25 -9800 562.5 -9795 571.25 -9795 575 -9800 {fill=true}
P 5 7 897.5 -9830 893.75 -9835 885 -9835 888.75 -9830 885 -9825 893.75 -9825 897.5 -9830 {fill=true}
P 5 7 1115 -9800 1111.25 -9805 1102.5 -9805 1106.25 -9800 1102.5 -9795 1111.25 -9795 1115 -9800 {fill=true}
P 5 7 1437.5 -9830 1433.75 -9835 1425 -9835 1428.75 -9830 1425 -9825 1433.75 -9825 1437.5 -9830 {fill=true}
P 5 7 575 -6210 571.25 -6215 562.5 -6215 566.25 -6210 562.5 -6205 571.25 -6205 575 -6210 {fill=true}
P 5 7 897.5 -6240 893.75 -6245 885 -6245 888.75 -6240 885 -6235 893.75 -6235 897.5 -6240 {fill=true}
P 5 7 1115 -6210 1111.25 -6215 1102.5 -6215 1106.25 -6210 1102.5 -6205 1111.25 -6205 1115 -6210 {fill=true}
P 5 7 1437.5 -6240 1433.75 -6245 1425 -6245 1428.75 -6240 1425 -6235 1433.75 -6235 1437.5 -6240 {fill=true}
P 5 7 575 -5810 571.25 -5815 562.5 -5815 566.25 -5810 562.5 -5805 571.25 -5805 575 -5810 {fill=true}
P 5 7 897.5 -5840 893.75 -5845 885 -5845 888.75 -5840 885 -5835 893.75 -5835 897.5 -5840 {fill=true}
P 5 7 1115 -5810 1111.25 -5815 1102.5 -5815 1106.25 -5810 1102.5 -5805 1111.25 -5805 1115 -5810 {fill=true}
P 5 7 1437.5 -5840 1433.75 -5845 1425 -5845 1428.75 -5840 1425 -5835 1433.75 -5835 1437.5 -5840 {fill=true}
P 5 7 575 -5370 571.25 -5375 562.5 -5375 566.25 -5370 562.5 -5365 571.25 -5365 575 -5370 {fill=true}
P 5 7 1765 -5370 1761.25 -5375 1752.5 -5375 1756.25 -5370 1752.5 -5365 1761.25 -5365 1765 -5370 {fill=true}
P 5 7 1135 -5370 1131.25 -5375 1122.5 -5375 1126.25 -5370 1122.5 -5365 1131.25 -5365 1135 -5370 {fill=true}
P 5 7 1105 -9430 1101.25 -9435 1092.5 -9435 1096.25 -9430 1092.5 -9425 1101.25 -9425 1105 -9430 {fill=true}
P 5 7 1427.5 -9460 1423.75 -9465 1415 -9465 1418.75 -9460 1415 -9455 1423.75 -9455 1427.5 -9460 {fill=true}
P 5 7 575 -9430 571.25 -9435 562.5 -9435 566.25 -9430 562.5 -9425 571.25 -9425 575 -9430 {fill=true}
P 5 7 897.5 -9460 893.75 -9465 885 -9465 888.75 -9460 885 -9455 893.75 -9455 897.5 -9460 {fill=true}
P 5 7 1605 -9430 1601.25 -9435 1592.5 -9435 1596.25 -9430 1592.5 -9425 1601.25 -9425 1605 -9430 {fill=true}
P 5 7 1927.5 -9460 1923.75 -9465 1915 -9465 1918.75 -9460 1915 -9455 1923.75 -9455 1927.5 -9460 {fill=true}
P 5 7 1645 -10730 1641.25 -10735 1632.5 -10735 1636.25 -10730 1632.5 -10725 1641.25 -10725 1645 -10730 {fill=true}
P 5 7 1967.5 -10760 1963.75 -10765 1955 -10765 1958.75 -10760 1955 -10755 1963.75 -10755 1967.5 -10760 {fill=true}
P 5 7 520 -10730 516.25 -10735 507.5 -10735 511.25 -10730 507.5 -10725 516.25 -10725 520 -10730 {fill=true}
P 5 7 842.5 -10760 838.75 -10765 830 -10765 833.75 -10760 830 -10755 838.75 -10755 842.5 -10760 {fill=true}
P 5 7 2105 -10730 2101.25 -10735 2092.5 -10735 2096.25 -10730 2092.5 -10725 2101.25 -10725 2105 -10730 {fill=true}
P 5 7 2427.5 -10760 2423.75 -10765 2415 -10765 2418.75 -10760 2415 -10755 2423.75 -10755 2427.5 -10760 {fill=true}
P 5 7 595 -8590 591.25 -8595 582.5 -8595 586.25 -8590 582.5 -8585 591.25 -8585 595 -8590 {fill=true}
P 5 7 917.5 -8620 913.75 -8625 905 -8625 908.75 -8620 905 -8615 913.75 -8615 917.5 -8620 {fill=true}
P 5 7 1135 -8590 1131.25 -8595 1122.5 -8595 1126.25 -8590 1122.5 -8585 1131.25 -8585 1135 -8590 {fill=true}
P 5 7 1457.5 -8620 1453.75 -8625 1445 -8625 1448.75 -8620 1445 -8615 1453.75 -8615 1457.5 -8620 {fill=true}
P 5 7 2265 -8590 2261.25 -8595 2252.5 -8595 2256.25 -8590 2252.5 -8585 2261.25 -8585 2265 -8590 {fill=true}
P 5 7 2587.5 -8620 2583.75 -8625 2575 -8625 2578.75 -8620 2575 -8615 2583.75 -8615 2587.5 -8620 {fill=true}
P 5 7 1105 -10730 1101.25 -10735 1092.5 -10735 1096.25 -10730 1092.5 -10725 1101.25 -10725 1105 -10730 {fill=true}
P 5 7 1427.5 -10760 1423.75 -10765 1415 -10765 1418.75 -10760 1415 -10755 1423.75 -10755 1427.5 -10760 {fill=true}
P 5 7 655 -900 651.25 -905 642.5 -905 646.25 -900 642.5 -895 651.25 -895 655 -900 {fill=true}
P 5 7 977.5 -930 973.75 -935 965 -935 968.75 -930 965 -925 973.75 -925 977.5 -930 {fill=true}
P 5 7 1255 -900 1251.25 -905 1242.5 -905 1246.25 -900 1242.5 -895 1251.25 -895 1255 -900 {fill=true}
P 5 7 1577.5 -930 1573.75 -935 1565 -935 1568.75 -930 1565 -925 1573.75 -925 1577.5 -930 {fill=true}
P 5 7 1865 -900 1861.25 -905 1852.5 -905 1856.25 -900 1852.5 -895 1861.25 -895 1865 -900 {fill=true}
P 5 7 2187.5 -930 2183.75 -935 2175 -935 2178.75 -930 2175 -925 2183.75 -925 2187.5 -930 {fill=true}
P 5 7 595 -4960 591.25 -4965 582.5 -4965 586.25 -4960 582.5 -4955 591.25 -4955 595 -4960 {fill=true}
P 5 7 917.5 -4990 913.75 -4995 905 -4995 908.75 -4990 905 -4985 913.75 -4985 917.5 -4990 {fill=true}
P 5 7 1155 -4960 1151.25 -4965 1142.5 -4965 1146.25 -4960 1142.5 -4955 1151.25 -4955 1155 -4960 {fill=true}
P 5 7 1477.5 -4990 1473.75 -4995 1465 -4995 1468.75 -4990 1465 -4985 1473.75 -4985 1477.5 -4990 {fill=true}
P 5 7 540 -9010 536.25 -9015 527.5 -9015 531.25 -9010 527.5 -9005 536.25 -9005 540 -9010 {fill=true}
P 5 7 862.5 -9040 858.75 -9045 850 -9045 853.75 -9040 850 -9035 858.75 -9035 862.5 -9040 {fill=true}
P 5 7 1105 -9010 1101.25 -9015 1092.5 -9015 1096.25 -9010 1092.5 -9005 1101.25 -9005 1105 -9010 {fill=true}
P 5 7 1427.5 -9040 1423.75 -9045 1415 -9045 1418.75 -9040 1415 -9035 1423.75 -9035 1427.5 -9040 {fill=true}
P 5 7 1605 -9010 1601.25 -9015 1592.5 -9015 1596.25 -9010 1592.5 -9005 1601.25 -9005 1605 -9010 {fill=true}
P 5 7 1927.5 -9040 1923.75 -9045 1915 -9045 1918.75 -9040 1915 -9035 1923.75 -9035 1927.5 -9040 {fill=true}
P 5 7 2095 -9010 2091.25 -9015 2082.5 -9015 2086.25 -9010 2082.5 -9005 2091.25 -9005 2095 -9010 {fill=true}
P 5 7 2417.5 -9040 2413.75 -9045 2405 -9045 2408.75 -9040 2405 -9035 2413.75 -9035 2417.5 -9040 {fill=true}
P 7 14 905 -10117.5 910 -10117.5 915 -10117.5 915 -10112.5 915 -10092.5 915 -10087.5 910 -10087.5 900 -10087.5 895 -10087.5 895 -10092.5 895 -10112.5 895 -10117.5 900 -10117.5 905 -10117.5 {fill=1
bezier=1}
P 7 14 1335 -10117.5 1340 -10117.5 1345 -10117.5 1345 -10112.5 1345 -10092.5 1345 -10087.5 1340 -10087.5 1330 -10087.5 1325 -10087.5 1325 -10092.5 1325 -10112.5 1325 -10117.5 1330 -10117.5 1335 -10117.5 {fill=1
bezier=1}
P 7 14 1405 -9927.5 1410 -9927.5 1415 -9927.5 1415 -9922.5 1415 -9902.5 1415 -9897.5 1410 -9897.5 1400 -9897.5 1395 -9897.5 1395 -9902.5 1395 -9922.5 1395 -9927.5 1400 -9927.5 1405 -9927.5 {fill=1
bezier=1}
P 7 14 1425 -6347.5 1430 -6347.5 1435 -6347.5 1435 -6342.5 1435 -6322.5 1435 -6317.5 1430 -6317.5 1420 -6317.5 1415 -6317.5 1415 -6322.5 1415 -6342.5 1415 -6347.5 1420 -6347.5 1425 -6347.5 {fill=1
bezier=1}
P 7 14 1425 -5947.5 1430 -5947.5 1435 -5947.5 1435 -5942.5 1435 -5922.5 1435 -5917.5 1430 -5917.5 1420 -5917.5 1415 -5917.5 1415 -5922.5 1415 -5942.5 1415 -5947.5 1420 -5947.5 1425 -5947.5 {fill=1
bezier=1}
P 7 14 935 -5267.5 940 -5267.5 945 -5267.5 945 -5262.5 945 -5242.5 945 -5237.5 940 -5237.5 930 -5237.5 925 -5237.5 925 -5242.5 925 -5262.5 925 -5267.5 930 -5267.5 935 -5267.5 {fill=1
bezier=1}
P 7 14 1435 -5277.5 1440 -5277.5 1445 -5277.5 1445 -5272.5 1445 -5252.5 1445 -5247.5 1440 -5247.5 1430 -5247.5 1425 -5247.5 1425 -5252.5 1425 -5272.5 1425 -5277.5 1430 -5277.5 1435 -5277.5 {fill=1
bezier=1}
P 7 14 905 -9287.5 910 -9287.5 915 -9287.5 915 -9282.5 915 -9262.5 915 -9257.5 910 -9257.5 900 -9257.5 895 -9257.5 895 -9262.5 895 -9282.5 895 -9287.5 900 -9287.5 905 -9287.5 {fill=1
bezier=1}
P 7 14 850 -10587.5 855 -10587.5 860 -10587.5 860 -10582.5 860 -10562.5 860 -10557.5 855 -10557.5 845 -10557.5 840 -10557.5 840 -10562.5 840 -10582.5 840 -10587.5 845 -10587.5 850 -10587.5 {fill=1
bezier=1}
P 7 14 1615 -10577.5 1620 -10577.5 1625 -10577.5 1625 -10572.5 1625 -10552.5 1625 -10547.5 1620 -10547.5 1610 -10547.5 1605 -10547.5 1605 -10552.5 1605 -10572.5 1605 -10577.5 1610 -10577.5 1615 -10577.5 {fill=1
bezier=1}
P 7 14 2395 -10567.5 2400 -10567.5 2405 -10567.5 2405 -10562.5 2405 -10542.5 2405 -10537.5 2400 -10537.5 2390 -10537.5 2385 -10537.5 2385 -10542.5 2385 -10562.5 2385 -10567.5 2390 -10567.5 2395 -10567.5 {fill=1
bezier=1}
P 7 14 675 -8707.5 680 -8707.5 685 -8707.5 685 -8702.5 685 -8682.5 685 -8677.5 680 -8677.5 670 -8677.5 665 -8677.5 665 -8682.5 665 -8702.5 665 -8707.5 670 -8707.5 675 -8707.5 {fill=1
bezier=1}
P 7 14 1335 -8727.5 1340 -8727.5 1345 -8727.5 1345 -8722.5 1345 -8702.5 1345 -8697.5 1340 -8697.5 1330 -8697.5 1325 -8697.5 1325 -8702.5 1325 -8722.5 1325 -8727.5 1330 -8727.5 1335 -8727.5 {fill=1
bezier=1}
P 7 14 1415 -4487.5 1420 -4487.5 1425 -4487.5 1425 -4482.5 1425 -4462.5 1425 -4457.5 1420 -4457.5 1410 -4457.5 1405 -4457.5 1405 -4462.5 1405 -4482.5 1405 -4487.5 1410 -4487.5 1415 -4487.5 {fill=1
bezier=1}
P 7 14 2065 -1757.5 2070 -1757.5 2075 -1757.5 2075 -1752.5 2075 -1732.5 2075 -1727.5 2070 -1727.5 2060 -1727.5 2055 -1727.5 2055 -1732.5 2055 -1752.5 2055 -1757.5 2060 -1757.5 2065 -1757.5 {fill=1
bezier=1}
P 7 14 1555 -1727.5 1560 -1727.5 1565 -1727.5 1565 -1722.5 1565 -1702.5 1565 -1697.5 1560 -1697.5 1550 -1697.5 1545 -1697.5 1545 -1702.5 1545 -1722.5 1545 -1727.5 1550 -1727.5 1555 -1727.5 {fill=1
bezier=1}
P 7 14 1445 -4127.5 1440 -4127.5 1435 -4127.5 1435 -4122.5 1435 -4102.5 1435 -4097.5 1440 -4097.5 1450 -4097.5 1455 -4097.5 1455 -4102.5 1455 -4122.5 1455 -4127.5 1450 -4127.5 1445 -4127.5 {fill=1
bezier=1}
P 7 14 1945 -4237.5 1950 -4237.5 1955 -4237.5 1955 -4232.5 1955 -4212.5 1955 -4207.5 1950 -4207.5 1940 -4207.5 1935 -4207.5 1935 -4212.5 1935 -4232.5 1935 -4237.5 1940 -4237.5 1945 -4237.5 {fill=1
bezier=1}
P 7 14 1565 -3717.5 1570 -3717.5 1575 -3717.5 1575 -3712.5 1575 -3692.5 1575 -3687.5 1570 -3687.5 1560 -3687.5 1555 -3687.5 1555 -3692.5 1555 -3712.5 1555 -3717.5 1560 -3717.5 1565 -3717.5 {fill=1
bezier=1}
P 7 14 2055 -3777.5 2060 -3777.5 2065 -3777.5 2065 -3772.5 2065 -3752.5 2065 -3747.5 2060 -3747.5 2050 -3747.5 2045 -3747.5 2045 -3752.5 2045 -3772.5 2045 -3777.5 2050 -3777.5 2055 -3777.5 {fill=1
bezier=1}
P 7 14 975 -10857.5 980 -10857.5 985 -10857.5 985 -10852.5 985 -10832.5 985 -10827.5 980 -10827.5 970 -10827.5 965 -10827.5 965 -10832.5 965 -10852.5 965 -10857.5 970 -10857.5 975 -10857.5 {fill=1
bezier=1}
P 7 14 1555 -1347.5 1560 -1347.5 1565 -1347.5 1565 -1342.5 1565 -1322.5 1565 -1317.5 1560 -1317.5 1550 -1317.5 1545 -1317.5 1545 -1322.5 1545 -1342.5 1545 -1347.5 1550 -1347.5 1555 -1347.5 {fill=1
bezier=1}
P 7 14 2065 -1297.5 2070 -1297.5 2075 -1297.5 2075 -1292.5 2075 -1272.5 2075 -1267.5 2070 -1267.5 2060 -1267.5 2055 -1267.5 2055 -1272.5 2055 -1292.5 2055 -1297.5 2060 -1297.5 2065 -1297.5 {fill=1
bezier=1}
P 7 14 2485 -4157.5 2490 -4157.5 2495 -4157.5 2495 -4152.5 2495 -4132.5 2495 -4127.5 2490 -4127.5 2480 -4127.5 2475 -4127.5 2475 -4132.5 2475 -4152.5 2475 -4157.5 2480 -4157.5 2485 -4157.5 {fill=1
bezier=1}
P 7 14 1805 -2197.5 1810 -2197.5 1815 -2197.5 1815 -2192.5 1815 -2172.5 1815 -2167.5 1810 -2167.5 1800 -2167.5 1795 -2167.5 1795 -2172.5 1795 -2192.5 1795 -2197.5 1800 -2197.5 1805 -2197.5 {fill=1
bezier=1}
P 7 14 655 -2127.5 660 -2127.5 665 -2127.5 665 -2122.5 665 -2102.5 665 -2097.5 660 -2097.5 650 -2097.5 645 -2097.5 645 -2102.5 645 -2122.5 645 -2127.5 650 -2127.5 655 -2127.5 {fill=1
bezier=1}
P 7 14 775 -2127.5 780 -2127.5 785 -2127.5 785 -2122.5 785 -2102.5 785 -2097.5 780 -2097.5 770 -2097.5 765 -2097.5 765 -2102.5 765 -2122.5 765 -2127.5 770 -2127.5 775 -2127.5 {fill=1
bezier=1}
P 7 14 1615 -797.5 1610 -797.5 1605 -797.5 1605 -792.5 1605 -772.5 1605 -767.5 1610 -767.5 1620 -767.5 1625 -767.5 1625 -772.5 1625 -792.5 1625 -797.5 1620 -797.5 1615 -797.5 {fill=1
bezier=1}
P 7 14 2265 -5277.5 2270 -5277.5 2275 -5277.5 2275 -5272.5 2275 -5252.5 2275 -5247.5 2270 -5247.5 2260 -5247.5 2255 -5247.5 2255 -5252.5 2255 -5272.5 2255 -5277.5 2260 -5277.5 2265 -5277.5 {fill=1
bezier=1}
P 7 14 1965 -4487.5 1970 -4487.5 1975 -4487.5 1975 -4482.5 1975 -4462.5 1975 -4457.5 1970 -4457.5 1960 -4457.5 1955 -4457.5 1955 -4462.5 1955 -4482.5 1955 -4487.5 1960 -4487.5 1965 -4487.5 {fill=1
bezier=1}
P 7 14 2325 -2787.5 2330 -2787.5 2335 -2787.5 2335 -2782.5 2335 -2762.5 2335 -2757.5 2330 -2757.5 2320 -2757.5 2315 -2757.5 2315 -2762.5 2315 -2782.5 2315 -2787.5 2320 -2787.5 2325 -2787.5 {fill=1
bezier=1}
P 7 14 795 -2907.5 800 -2907.5 805 -2907.5 805 -2902.5 805 -2882.5 805 -2877.5 800 -2877.5 790 -2877.5 785 -2877.5 785 -2882.5 785 -2902.5 785 -2907.5 790 -2907.5 795 -2907.5 {fill=1
bezier=1}
P 7 14 1335 -2887.5 1340 -2887.5 1345 -2887.5 1345 -2882.5 1345 -2862.5 1345 -2857.5 1340 -2857.5 1330 -2857.5 1325 -2857.5 1325 -2862.5 1325 -2882.5 1325 -2887.5 1330 -2887.5 1335 -2887.5 {fill=1
bezier=1}
P 7 14 1245 -2507.5 1250 -2507.5 1255 -2507.5 1255 -2502.5 1255 -2482.5 1255 -2477.5 1250 -2477.5 1240 -2477.5 1235 -2477.5 1235 -2482.5 1235 -2502.5 1235 -2507.5 1240 -2507.5 1245 -2507.5 {fill=1
bezier=1}
P 7 14 2505 -2457.5 2510 -2457.5 2515 -2457.5 2515 -2452.5 2515 -2432.5 2515 -2427.5 2510 -2427.5 2500 -2427.5 2495 -2427.5 2495 -2432.5 2495 -2452.5 2495 -2457.5 2500 -2457.5 2505 -2457.5 {fill=1
bezier=1}
P 7 14 2465 -1047.5 2460 -1047.5 2455 -1047.5 2455 -1042.5 2455 -1022.5 2455 -1017.5 2460 -1017.5 2470 -1017.5 2475 -1017.5 2475 -1022.5 2475 -1042.5 2475 -1047.5 2470 -1047.5 2465 -1047.5 {fill=1
bezier=1}
P 7 14 2525 -8777.5 2530 -8777.5 2535 -8777.5 2535 -8772.5 2535 -8752.5 2535 -8747.5 2530 -8747.5 2520 -8747.5 2515 -8747.5 2515 -8752.5 2515 -8772.5 2515 -8777.5 2520 -8777.5 2525 -8777.5 {fill=1
bezier=1}
P 7 14 1335 -9287.5 1340 -9287.5 1345 -9287.5 1345 -9282.5 1345 -9262.5 1345 -9257.5 1340 -9257.5 1330 -9257.5 1325 -9257.5 1325 -9262.5 1325 -9282.5 1325 -9287.5 1330 -9287.5 1335 -9287.5 {fill=1
bezier=1}
P 7 14 2105 -9287.5 2110 -9287.5 2115 -9287.5 2115 -9282.5 2115 -9262.5 2115 -9257.5 2110 -9257.5 2100 -9257.5 2095 -9257.5 2095 -9262.5 2095 -9282.5 2095 -9287.5 2100 -9287.5 2105 -9287.5 {fill=1
bezier=1}
P 7 14 355 -8137.5 360 -8137.5 365 -8137.5 365 -8132.5 365 -8112.5 365 -8107.5 360 -8107.5 350 -8107.5 345 -8107.5 345 -8112.5 345 -8132.5 345 -8137.5 350 -8137.5 355 -8137.5 {fill=1
bezier=1}
P 7 14 885 -8307.5 890 -8307.5 895 -8307.5 895 -8302.5 895 -8282.5 895 -8277.5 890 -8277.5 880 -8277.5 875 -8277.5 875 -8282.5 875 -8302.5 875 -8307.5 880 -8307.5 885 -8307.5 {fill=1
bezier=1}
P 7 14 1135 -8347.5 1140 -8347.5 1145 -8347.5 1145 -8342.5 1145 -8322.5 1145 -8317.5 1140 -8317.5 1130 -8317.5 1125 -8317.5 1125 -8322.5 1125 -8342.5 1125 -8347.5 1130 -8347.5 1135 -8347.5 {fill=1
bezier=1}
P 7 14 1425 -8347.5 1430 -8347.5 1435 -8347.5 1435 -8342.5 1435 -8322.5 1435 -8317.5 1430 -8317.5 1420 -8317.5 1415 -8317.5 1415 -8322.5 1415 -8342.5 1415 -8347.5 1420 -8347.5 1425 -8347.5 {fill=1
bezier=1}
P 7 14 1885 -8307.5 1890 -8307.5 1895 -8307.5 1895 -8302.5 1895 -8282.5 1895 -8277.5 1890 -8277.5 1880 -8277.5 1875 -8277.5 1875 -8282.5 1875 -8302.5 1875 -8307.5 1880 -8307.5 1885 -8307.5 {fill=1
bezier=1}
P 7 14 2105 -10117.5 2110 -10117.5 2115 -10117.5 2115 -10112.5 2115 -10092.5 2115 -10087.5 2110 -10087.5 2100 -10087.5 2095 -10087.5 2095 -10092.5 2095 -10112.5 2095 -10117.5 2100 -10117.5 2105 -10117.5 {fill=1
bezier=1}
P 7 14 2585 -3907.5 2590 -3907.5 2595 -3907.5 2595 -3902.5 2595 -3882.5 2595 -3877.5 2590 -3877.5 2580 -3877.5 2575 -3877.5 2575 -3882.5 2575 -3902.5 2575 -3907.5 2580 -3907.5 2585 -3907.5 {fill=1
bezier=1}
P 7 14 915 -4857.5 920 -4857.5 925 -4857.5 925 -4852.5 925 -4832.5 925 -4827.5 920 -4827.5 910 -4827.5 905 -4827.5 905 -4832.5 905 -4852.5 905 -4857.5 910 -4857.5 915 -4857.5 {fill=1
bezier=1}
P 7 14 1755 -4907.5 1760 -4907.5 1765 -4907.5 1765 -4902.5 1765 -4882.5 1765 -4877.5 1760 -4877.5 1750 -4877.5 1745 -4877.5 1745 -4882.5 1745 -4902.5 1745 -4907.5 1750 -4907.5 1755 -4907.5 {fill=1
bezier=1}
P 7 14 2515 -4907.5 2520 -4907.5 2525 -4907.5 2525 -4902.5 2525 -4882.5 2525 -4877.5 2520 -4877.5 2510 -4877.5 2505 -4877.5 2505 -4882.5 2505 -4902.5 2505 -4907.5 2510 -4907.5 2515 -4907.5 {fill=1
bezier=1}
P 7 14 890 -9127.5 895 -9127.5 900 -9127.5 900 -9122.5 900 -9102.5 900 -9097.5 895 -9097.5 885 -9097.5 880 -9097.5 880 -9102.5 880 -9122.5 880 -9127.5 885 -9127.5 890 -9127.5 {fill=1
bezier=1}
P 7 14 1425 -9007.5 1430 -9007.5 1435 -9007.5 1435 -9002.5 1435 -8982.5 1435 -8977.5 1430 -8977.5 1420 -8977.5 1415 -8977.5 1415 -8982.5 1415 -9002.5 1415 -9007.5 1420 -9007.5 1425 -9007.5 {fill=1
bezier=1}
P 7 14 1795 -9007.5 1800 -9007.5 1805 -9007.5 1805 -9002.5 1805 -8982.5 1805 -8977.5 1800 -8977.5 1790 -8977.5 1785 -8977.5 1785 -8982.5 1785 -9002.5 1785 -9007.5 1790 -9007.5 1795 -9007.5 {fill=1
bezier=1}
P 7 14 2285 -9007.5 2290 -9007.5 2295 -9007.5 2295 -9002.5 2295 -8982.5 2295 -8977.5 2290 -8977.5 2280 -8977.5 2275 -8977.5 2275 -8982.5 2275 -9002.5 2275 -9007.5 2280 -9007.5 2285 -9007.5 {fill=1
bezier=1}
P 7 14 2235 -8157.5 2240 -8157.5 2245 -8157.5 2245 -8152.5 2245 -8132.5 2245 -8127.5 2240 -8127.5 2230 -8127.5 2225 -8127.5 2225 -8132.5 2225 -8152.5 2225 -8157.5 2230 -8157.5 2235 -8157.5 {fill=1
bezier=1}
P 7 14 2465 -8217.5 2470 -8217.5 2475 -8217.5 2475 -8212.5 2475 -8192.5 2475 -8187.5 2470 -8187.5 2460 -8187.5 2455 -8187.5 2455 -8192.5 2455 -8212.5 2455 -8217.5 2460 -8217.5 2465 -8217.5 {fill=1
bezier=1}
P 7 14 605 -8347.5 610 -8347.5 615 -8347.5 615 -8342.5 615 -8322.5 615 -8317.5 610 -8317.5 600 -8317.5 595 -8317.5 595 -8322.5 595 -8342.5 595 -8347.5 600 -8347.5 605 -8347.5 {fill=1
bezier=1}
P 7 14 635 -167.5 640 -167.5 645 -167.5 645 -162.5 645 -142.5 645 -137.5 640 -137.5 630 -137.5 625 -137.5 625 -142.5 625 -162.5 625 -167.5 630 -167.5 635 -167.5 {fill=1
bezier=1}
P 7 14 1505 -137.5 1510 -137.5 1515 -137.5 1515 -132.5 1515 -112.5 1515 -107.5 1510 -107.5 1500 -107.5 1495 -107.5 1495 -112.5 1495 -132.5 1495 -137.5 1500 -137.5 1505 -137.5 {fill=1
bezier=1}
P 7 14 2435 -197.5 2440 -197.5 2445 -197.5 2445 -192.5 2445 -172.5 2445 -167.5 2440 -167.5 2430 -167.5 2425 -167.5 2425 -172.5 2425 -192.5 2425 -197.5 2430 -197.5 2435 -197.5 {fill=1
bezier=1}
P 7 14 2195 -11247.5 2200 -11247.5 2205 -11247.5 2205 -11242.5 2205 -11222.5 2205 -11217.5 2200 -11217.5 2190 -11217.5 2185 -11217.5 2185 -11222.5 2185 -11242.5 2185 -11247.5 2190 -11247.5 2195 -11247.5 {fill=1
bezier=1}
P 9 8 1770 -8670 1912.5 -8642.5 1890 -8610 1980 -8550 1960 -8520 1870 -8580 1845 -8545 1770 -8670 {fill=0}
P 10 7 880 -10090 872.5 -10097.5 877.5 -10102.5 862.5 -10107.5 867.5 -10092.5 872.5 -10097.5 880 -10090 {fill=1}
P 10 7 2110 -10140 2102.5 -10147.5 2107.5 -10152.5 2092.5 -10157.5 2097.5 -10142.5 2102.5 -10147.5 2110 -10140 {fill=1}
P 10 7 1330 -10130 1322.5 -10137.5 1327.5 -10142.5 1312.5 -10147.5 1317.5 -10132.5 1322.5 -10137.5 1330 -10130 {fill=1}
P 10 7 760 -9870 752.5 -9877.5 757.5 -9882.5 742.5 -9887.5 747.5 -9872.5 752.5 -9877.5 760 -9870 {fill=1}
P 10 7 1380 -9870 1372.5 -9877.5 1377.5 -9882.5 1362.5 -9887.5 1367.5 -9872.5 1372.5 -9877.5 1380 -9870 {fill=1}
P 10 7 760 -6280 752.5 -6287.5 757.5 -6292.5 742.5 -6297.5 747.5 -6282.5 752.5 -6287.5 760 -6280 {fill=1}
P 10 7 1380 -6280 1372.5 -6287.5 1377.5 -6292.5 1362.5 -6297.5 1367.5 -6282.5 1372.5 -6287.5 1380 -6280 {fill=1}
P 10 7 760 -5880 752.5 -5887.5 757.5 -5892.5 742.5 -5897.5 747.5 -5882.5 752.5 -5887.5 760 -5880 {fill=1}
P 10 7 1380 -5880 1372.5 -5887.5 1377.5 -5892.5 1362.5 -5897.5 1367.5 -5882.5 1372.5 -5887.5 1380 -5880 {fill=1}
P 10 7 920 -5210 912.5 -5217.5 917.5 -5222.5 902.5 -5227.5 907.5 -5212.5 912.5 -5217.5 920 -5210 {fill=1}
P 10 7 1410 -5270 1402.5 -5277.5 1407.5 -5282.5 1392.5 -5287.5 1397.5 -5272.5 1402.5 -5277.5 1410 -5270 {fill=1}
P 10 7 2230 -5270 2222.5 -5277.5 2227.5 -5282.5 2212.5 -5287.5 2217.5 -5272.5 2222.5 -5277.5 2230 -5270 {fill=1}
P 10 7 880 -9260 872.5 -9267.5 877.5 -9272.5 862.5 -9277.5 867.5 -9262.5 872.5 -9267.5 880 -9260 {fill=1}
P 10 7 2110 -9310 2102.5 -9317.5 2107.5 -9322.5 2092.5 -9327.5 2097.5 -9312.5 2102.5 -9317.5 2110 -9310 {fill=1}
P 10 7 1330 -9300 1322.5 -9307.5 1327.5 -9312.5 1312.5 -9317.5 1317.5 -9302.5 1322.5 -9307.5 1330 -9300 {fill=1}
P 10 7 825 -10560 817.5 -10567.5 822.5 -10572.5 807.5 -10577.5 812.5 -10562.5 817.5 -10567.5 825 -10560 {fill=1}
P 10 7 1630 -10590 1622.5 -10597.5 1627.5 -10602.5 1612.5 -10607.5 1617.5 -10592.5 1622.5 -10597.5 1630 -10590 {fill=1}
P 10 7 2410 -10580 2402.5 -10587.5 2407.5 -10592.5 2392.5 -10597.5 2397.5 -10582.5 2402.5 -10587.5 2410 -10580 {fill=1}
P 10 7 730 -8720 722.5 -8727.5 727.5 -8732.5 712.5 -8737.5 717.5 -8722.5 722.5 -8727.5 730 -8720 {fill=1}
P 10 7 1310 -8720 1302.5 -8727.5 1307.5 -8732.5 1292.5 -8737.5 1297.5 -8722.5 1302.5 -8727.5 1310 -8720 {fill=1}
P 10 7 2520 -8790 2512.5 -8797.5 2517.5 -8802.5 2502.5 -8807.5 2507.5 -8792.5 2512.5 -8797.5 2520 -8790 {fill=1}
P 10 7 1380 -4480 1372.5 -4487.5 1377.5 -4492.5 1362.5 -4497.5 1367.5 -4482.5 1372.5 -4487.5 1380 -4480 {fill=1}
P 10 7 1920 -4520 1912.5 -4527.5 1917.5 -4532.5 1902.5 -4537.5 1907.5 -4522.5 1912.5 -4527.5 1920 -4520 {fill=1}
P 10 7 660 -3380 652.5 -3387.5 657.5 -3392.5 642.5 -3397.5 647.5 -3382.5 652.5 -3387.5 660 -3380 {fill=1}
P 10 7 1240 -3380 1232.5 -3387.5 1237.5 -3392.5 1222.5 -3397.5 1227.5 -3382.5 1232.5 -3387.5 1240 -3380 {fill=1}
P 10 7 1010 -10870 1002.5 -10877.5 1007.5 -10882.5 992.5 -10887.5 997.5 -10872.5 1002.5 -10877.5 1010 -10870 {fill=1}
P 10 7 680 -3140 672.5 -3147.5 677.5 -3152.5 662.5 -3157.5 667.5 -3142.5 672.5 -3147.5 680 -3140 {fill=1}
P 10 7 1300 -3050 1292.5 -3057.5 1297.5 -3062.5 1282.5 -3067.5 1287.5 -3052.5 1292.5 -3057.5 1300 -3050 {fill=1}
P 10 7 760 -2870 752.5 -2877.5 757.5 -2882.5 742.5 -2887.5 747.5 -2872.5 752.5 -2877.5 760 -2870 {fill=1}
P 10 7 1300 -2840 1292.5 -2847.5 1297.5 -2852.5 1282.5 -2857.5 1287.5 -2842.5 1292.5 -2847.5 1300 -2840 {fill=1}
P 10 7 2350 -2810 2342.5 -2817.5 2347.5 -2822.5 2332.5 -2827.5 2337.5 -2812.5 2342.5 -2817.5 2350 -2810 {fill=1}
P 10 7 1830 -2090 1822.5 -2097.5 1827.5 -2102.5 1812.5 -2107.5 1817.5 -2092.5 1822.5 -2097.5 1830 -2090 {fill=1}
P 10 7 700 -2160 692.5 -2167.5 697.5 -2172.5 682.5 -2177.5 687.5 -2162.5 692.5 -2167.5 700 -2160 {fill=1}
P 10 7 820 -2160 812.5 -2167.5 817.5 -2172.5 802.5 -2177.5 807.5 -2162.5 812.5 -2167.5 820 -2160 {fill=1}
P 10 7 930 -880 922.5 -887.5 927.5 -892.5 912.5 -897.5 917.5 -882.5 922.5 -887.5 930 -880 {fill=1}
P 10 7 1530 -880 1522.5 -887.5 1527.5 -892.5 1512.5 -897.5 1517.5 -882.5 1522.5 -887.5 1530 -880 {fill=1}
P 10 7 760 -2440 752.5 -2447.5 757.5 -2452.5 742.5 -2457.5 747.5 -2442.5 752.5 -2447.5 760 -2440 {fill=1}
P 10 7 1220 -2490 1212.5 -2497.5 1217.5 -2502.5 1202.5 -2507.5 1207.5 -2492.5 1212.5 -2497.5 1220 -2490 {fill=1}
P 10 7 840 -4130 832.5 -4137.5 837.5 -4142.5 822.5 -4147.5 827.5 -4132.5 832.5 -4137.5 840 -4130 {fill=1}
P 10 7 1380 -4130 1372.5 -4137.5 1377.5 -4142.5 1362.5 -4147.5 1367.5 -4132.5 1372.5 -4137.5 1380 -4130 {fill=1}
P 10 7 1920 -4210 1912.5 -4217.5 1917.5 -4222.5 1902.5 -4227.5 1907.5 -4212.5 1912.5 -4217.5 1920 -4210 {fill=1}
P 10 7 2460 -4130 2452.5 -4137.5 2457.5 -4142.5 2442.5 -4147.5 2447.5 -4132.5 2452.5 -4137.5 2460 -4130 {fill=1}
P 10 7 2560 -3880 2552.5 -3887.5 2557.5 -3892.5 2542.5 -3897.5 2547.5 -3882.5 2552.5 -3887.5 2560 -3880 {fill=1}
P 10 7 2030 -3780 2022.5 -3787.5 2027.5 -3792.5 2012.5 -3797.5 2017.5 -3782.5 2022.5 -3787.5 2030 -3780 {fill=1}
P 10 7 1520 -3770 1512.5 -3777.5 1517.5 -3782.5 1502.5 -3787.5 1507.5 -3772.5 1512.5 -3777.5 1520 -3770 {fill=1}
P 10 8 1770 -8670 1912.5 -8642.5 1890 -8610 1980 -8550 1960 -8520 1870 -8580 1845 -8545 1770 -8670 {fill=1}
P 10 7 2470 -2450 2462.5 -2457.5 2467.5 -2462.5 2452.5 -2467.5 2457.5 -2452.5 2462.5 -2457.5 2470 -2450 {fill=1}
P 10 7 2450 -1060 2442.5 -1067.5 2447.5 -1072.5 2432.5 -1077.5 2437.5 -1062.5 2442.5 -1067.5 2450 -1060 {fill=1}
P 10 7 380 -8210 372.5 -8217.5 377.5 -8222.5 362.5 -8227.5 367.5 -8212.5 372.5 -8217.5 380 -8210 {fill=1}
P 10 7 860 -8280 852.5 -8287.5 857.5 -8292.5 842.5 -8297.5 847.5 -8282.5 852.5 -8287.5 860 -8280 {fill=1}
P 10 7 1110 -8320 1102.5 -8327.5 1107.5 -8332.5 1092.5 -8337.5 1097.5 -8322.5 1102.5 -8327.5 1110 -8320 {fill=1}
P 10 7 1400 -8320 1392.5 -8327.5 1397.5 -8332.5 1382.5 -8337.5 1387.5 -8322.5 1392.5 -8327.5 1400 -8320 {fill=1}
P 10 7 1900 -8320 1892.5 -8327.5 1897.5 -8332.5 1882.5 -8337.5 1887.5 -8322.5 1892.5 -8327.5 1900 -8320 {fill=1}
P 10 7 890 -4810 882.5 -4817.5 887.5 -4822.5 872.5 -4827.5 877.5 -4812.5 882.5 -4817.5 890 -4810 {fill=1}
P 10 7 1730 -4860 1722.5 -4867.5 1727.5 -4872.5 1712.5 -4877.5 1717.5 -4862.5 1722.5 -4867.5 1730 -4860 {fill=1}
P 10 7 2490 -4860 2482.5 -4867.5 2487.5 -4872.5 2472.5 -4877.5 2477.5 -4862.5 2482.5 -4867.5 2490 -4860 {fill=1}
P 10 7 875 -9130 867.5 -9137.5 872.5 -9142.5 857.5 -9147.5 862.5 -9132.5 867.5 -9137.5 875 -9130 {fill=1}
P 10 7 1400 -9020 1392.5 -9027.5 1397.5 -9032.5 1382.5 -9037.5 1387.5 -9022.5 1392.5 -9027.5 1400 -9020 {fill=1}
P 10 7 1850 -9020 1842.5 -9027.5 1847.5 -9032.5 1832.5 -9037.5 1837.5 -9022.5 1842.5 -9027.5 1850 -9020 {fill=1}
P 10 7 2280 -9020 2272.5 -9027.5 2277.5 -9032.5 2262.5 -9037.5 2267.5 -9022.5 2272.5 -9027.5 2280 -9020 {fill=1}
P 10 7 2200 -8150 2192.5 -8157.5 2197.5 -8162.5 2182.5 -8167.5 2187.5 -8152.5 2192.5 -8157.5 2200 -8150 {fill=1}
P 10 7 1025 -7580 1017.5 -7587.5 1022.5 -7592.5 1007.5 -7597.5 1012.5 -7582.5 1017.5 -7587.5 1025 -7580 {fill=1}
P 10 7 1870 -7580 1862.5 -7587.5 1867.5 -7592.5 1852.5 -7597.5 1857.5 -7582.5 1862.5 -7587.5 1870 -7580 {fill=1}
P 10 7 1000 -7150 992.5 -7157.5 997.5 -7162.5 982.5 -7167.5 987.5 -7152.5 992.5 -7157.5 1000 -7150 {fill=1}
P 10 7 1860 -7150 1852.5 -7157.5 1857.5 -7162.5 1842.5 -7167.5 1847.5 -7152.5 1852.5 -7157.5 1860 -7150 {fill=1}
P 10 7 2440 -8210 2432.5 -8217.5 2437.5 -8222.5 2422.5 -8227.5 2427.5 -8212.5 2432.5 -8217.5 2440 -8210 {fill=1}
P 10 7 580 -8320 572.5 -8327.5 577.5 -8332.5 562.5 -8337.5 567.5 -8322.5 572.5 -8327.5 580 -8320 {fill=1}
P 10 7 740 -510 732.5 -517.5 737.5 -522.5 722.5 -527.5 727.5 -512.5 732.5 -517.5 740 -510 {fill=1}
P 10 7 2320 -510 2312.5 -517.5 2317.5 -522.5 2302.5 -527.5 2307.5 -512.5 2312.5 -517.5 2320 -510 {fill=1}
P 10 7 1430 -175 1422.5 -182.5 1427.5 -187.5 1412.5 -192.5 1417.5 -177.5 1422.5 -182.5 1430 -175 {fill=1}
P 10 7 2360 -235 2352.5 -242.5 2357.5 -247.5 2342.5 -252.5 2347.5 -237.5 2352.5 -242.5 2360 -235 {fill=1}
P 10 7 640 -175 632.5 -182.5 637.5 -187.5 622.5 -192.5 627.5 -177.5 632.5 -182.5 640 -175 {fill=1}
P 10 7 2210 -10960 2202.5 -10967.5 2207.5 -10972.5 2192.5 -10977.5 2197.5 -10962.5 2202.5 -10967.5 2210 -10960 {fill=1}
T {INTUITIVE_INTERFACE CHEAT SHEET} 1110 -11310 0 0 2 2 {hcenter=1}
T {D} 1275 -10287.5 0 0 0.15 0.15 { layer=2}
T {D} 2055 -10297.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -10287.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -9827.5 0 0 0.15 0.15 {}
T {D} 1285 -9827.5 0 0 0.15 0.15 {}
T {D} 745 -6237.5 0 0 0.15 0.15 {}
T {D} 1285 -6237.5 0 0 0.15 0.15 {}
T {D} 745 -5837.5 0 0 0.15 0.15 {}
T {D} 1285 -5837.5 0 0 0.15 0.15 {}
T {D} 745 -5397.5 0 0 0.15 0.15 { layer=2}
T {D} 2125 -5397.5 0 0 0.15 0.15 { layer=2}
T {D} 1305 -5397.5 0 0 0.15 0.15 { layer=2}
T {(Enable Options → Intuitive Click & Drag interface
or add: `set intuitive_interface 1` in xschemrc file).} 1090 -11170 0 0 1 1 {hcenter=1 layer=1}
T {Move objects} 0 -10360 0 0 1 1 {}
T {Move objects} 0 -9950 0 0 1 1 {}
T {Move objects,
create wires} 0 -6360 0 0 1 1 {}
T {Move objects,
keep attached
wires
} 0 -5960 0 0 1 1 {}
T {Move objects,
keep attached
wires / stretch
circuit
} 0 -5560 0 0 1 1 {}
T {Shift} 1520 -6295 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1520 -6365 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1540 -5255 0 0 0.5 0.5 {hcenter=1}
T {Duplicate objects} 0 -9510 0 0 1 1 {}
T {D} 1275 -9457.5 0 0 0.15 0.15 { layer=2}
T {D} 2055 -9467.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -9457.5 0 0 0.15 0.15 { layer=2}
T {D} 1775 -9457.5 0 0 0.15 0.15 {}
T {Shift} 1270 -9275 0 0 0.5 0.5 {hcenter=1}
T {D} 1815 -10757.5 0 0 0.15 0.15 { layer=2}
T {D} 690 -10757.5 0 0 0.15 0.15 { layer=2}
T {Select
and unselect
objects} 0 -10810 0 0 1 1 {}
T {Shift} 1710 -10555 0 0 0.5 0.5 {hcenter=1}
T {D} 2275 -10757.5 0 0 0.15 0.15 { layer=2}
T {Alt} 2490 -10545 0 0 0.5 0.5 {hcenter=1}
T {Select} 695 -10560 0 0 0.5 0.5 {}
T {Add
Selection} 1770 -10570 0 0 0.5 0.5 {}
T {Remove
Selection} 2220 -10570 0 0 0.5 0.5 {}
T {D} 765 -8617.5 0 0 0.15 0.15 {}
T {D} 1305 -8617.5 0 0 0.15 0.15 {}
T {D} 2435 -8617.5 0 0 0.15 0.15 {}
T {Resize wires} 0 -8740 0 0 1 1 {}
T {Constrained move
horizontal / 
vertical} 0 -5090 0 0 1 1 {}
T {Move components, 
create wires,
resize wires} 0 -4630 0 0 1 1 {}
T {Cut wires} 0 -4280 0 0 1 1 {}
T {Stretch multiple
shapes} 0 -3860 0 0 1 1 {}
T {Ctrl} 1430 -4635 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1430 -4555 0 0 0.5 0.5 {hcenter=1}
T {Accurately position closer
to the wire end to be moved
so it will not be unselected} 1610 -8830 0 0 0.5 0.5 {}
T {Move multiple
objects keeping
connections} 0 -1840 0 0 1 1 {}
T {Ctrl} 2080 -1815 0 0 0.5 0.5 {hcenter=1}
T {Alt} 1430 -4185 0 0 0.5 0.5 {hcenter=1}
T {Click to select wire, release button
click wire endpoint and drag it away} 660 -8830 0 0 0.5 0.5 {}
T {Ctrl} 1580 -3775 0 0 0.5 0.5 {hcenter=1}
T {D} 655 -3437.5 0 0 0.15 0.15 { layer=2}
T {D} 1235 -3437.5 0 0 0.15 0.15 { layer=2}
T {D} 1885 -3437.5 0 0 0.15 0.15 {}
T {Ctrl} 1960 -3475 0 0 0.5 0.5 {hcenter=1}
T {!} 1960 -3395 0 0 0.5 0.5 {hcenter=1}
T {Remove wires
under component
} 0 -3510 0 0 1 1 {}
T {If Shift key is needed for ! 
use also Shift} 2020 -3450 0 0 0.5 0.5 {}
T {D} 1275 -10757.5 0 0 0.15 0.15 { layer=2}
T {Add
Selection} 1090 -10580 0 0 0.5 0.5 {}
T {Shift} 1080 -10835 0 0 0.5 0.5 {hcenter=1}
T {Move multiple
objects keeping
connections,
adding wires} 0 -1460 0 0 1 1 {}
T {Ctrl} 2080 -1435 0 0 0.5 0.5 {hcenter=1}
T {Shift} 2080 -1365 0 0 0.5 0.5 {hcenter=1}
T {Join / Trim wires} 0 -3170 0 0 1 1 {}
T {&} 1920 -3175 0 0 0.5 0.5 {hcenter=1}
T {This wire will not be broken} 1120 -2760 0 0 0.5 0.5 {}
T {&} 1830 -2745 0 0 0.5 0.5 {hcenter=1}
T {This wire is now 
broken} 1890 -2760 0 0 0.5 0.5 {}
T {break wires
at instance
pins} 0 -2240 0 0 1 1 {}
T {!} 1290 -2095 0 0 0.5 0.5 {hcenter=1}
T {Shift} 790 -2025 0 0 0.5 0.5 {hcenter=1}
T {+} 720 -2100 0 0 0.5 0.5 {}
T {The single wire line will be
broken at selected instance pins} 1640 -2270 0 0 0.5 0.5 {}
T {Single wire line} 640 -2260 0 0 0.5 0.5 {}
T {D} 825 -927.5 0 0 0.15 0.15 {}
T {D} 1425 -927.5 0 0 0.15 0.15 {}
T {Shift} 1600 -865 0 0 0.5 0.5 {hcenter=1}
T {Select instance
and all connected
wires} 0 -1060 0 0 1 1 {}
T {Join / Trim wires} 0 -2890 0 0 1 1 {}
T {Options->Auto join / trim wires to perform this function automatically} 840 -2990 0 0 0.5 0.5 {}
T {Join / Trim wires} 0 -2500 0 0 1 1 {}
T {This wire is broken} 630 -2360 0 0 0.5 0.5 {}
T {This wire is still broken} 1170 -2360 0 0 0.5 0.5 {}
T {This wire is now joined} 1800 -2360 0 0 0.5 0.5 {}
T {&} 1920 -2605 0 0 0.5 0.5 {hcenter=1}
T {Options->Auto join / trim wires to perform this function automatically} 840 -2620 0 0 0.5 0.5 {}
T {Options->Auto join / trim wires to perform this function automatically} 840 -3230 0 0 0.5 0.5 {}
T {multiple overlayed wires create
unneeded connecting dots} 1110 -3150 0 0 0.5 0.5 {}
T {overlayed wires are removed} 2270 -3130 0 0 0.5 0.5 {}
T {Ctrl} 2370 -5255 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1980 -4635 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1980 -4555 0 0 0.5 0.5 {hcenter=1}
T {you can now 
select one of
the cut segments...} 1930 -4150 0 0 0.4 0.4 {}
T {... and move it.} 2420 -4070 0 0 0.4 0.4 {}
T {D} 2035 -927.5 0 0 0.15 0.15 {}
T {Component
wiring} 0 -8260 0 0 1 1 {}
T {Click to
unselect} 850 -8380 0 0 0.5 0.5 {}
T {Click to select} 1810 -8380 0 0 0.5 0.5 {}
T {Click one of the
selected objects
and drag it away.} 2330 -960 0 0 0.4 0.4 {}
T {This command will work also on multiple selected objects.} 1710 -3300 0 0 0.5 0.5 {}
T {D} 765 -4987.5 0 0 0.15 0.15 {}
T {D} 1325 -4987.5 0 0 0.15 0.15 {}
T {Press and release 'h'
while keeping left mouse
button pressed.
move will be horizontal only} 1550 -5140 0 0 0.5 0.5 {}
T {Press and release 'v'
while keeping left mouse
button pressed.
move will be vertical only} 2050 -5010 0 0 0.5 0.5 {}
T {D} 710 -9037.5 0 0 0.15 0.15 {}
T {Move and
extend
wires} 0 -9130 0 0 1 1 {}
T {D} 1275 -9037.5 0 0 0.15 0.15 {}
T {D} 1775 -9037.5 0 0 0.15 0.15 {}
T {D} 2265 -9037.5 0 0 0.15 0.15 {}
T {Shift} 1980 -8295 0 0 0.5 0.5 {hcenter=1}
T {Rotate / Flip} 0 -7920 0 0 1 1 {}
T {Shift} 510 -7805 0 0 0.5 0.5 {hcenter=1}
T {R} 510 -7735 0 0 0.5 0.5 {hcenter=1}
T {Shift} 820 -7805 0 0 0.5 0.5 {hcenter=1}
T {R} 820 -7735 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1120 -7805 0 0 0.5 0.5 {hcenter=1}
T {R} 1120 -7735 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1430 -7805 0 0 0.5 0.5 {hcenter=1}
T {R} 1430 -7735 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1750 -7805 0 0 0.5 0.5 {hcenter=1}
T {F} 1750 -7735 0 0 0.5 0.5 {hcenter=1}
T {Shift} 2080 -7805 0 0 0.5 0.5 {hcenter=1}
T {V} 2080 -7735 0 0 0.5 0.5 {hcenter=1}
T {D} 775 -7477.5 0 0 0.15 0.15 { layer=2}
T {D} 1727.5 -7355 1 0 0.15 0.15 { layer=2}
T {D} 1250 -7477.5 0 0 0.15 0.15 { layer=2}
T {Shift} 1940 -7615 0 0 0.5 0.5 {hcenter=1}
T {R} 1940 -7545 0 0 0.5 0.5 {hcenter=1}
T {Selected shapes rotate around mouse pointer} 1920 -7470 0 0 0.5 0.5 {}
T {Rotate} 0 -7500 0 0 1 1 {}
T {D} 775 -7047.5 0 0 0.15 0.15 { layer=2}
T {D} 1225 -7047.5 0 0 0.15 0.15 { layer=2}
T {Shift} 1940 -7185 0 0 0.5 0.5 {hcenter=1}
T {F} 1940 -7115 0 0 0.5 0.5 {hcenter=1}
T {Selected shapes flip around mouse pointer} 1920 -7040 0 0 0.5 0.5 {}
T {Flip} 0 -7070 0 0 1 1 {}
T {D} 1595 -7047.5 0 1 0.15 0.15 { layer=2}
T {Rotate around
center point} 0 -6670 0 0 1 1 {}
T {Alt} 1050 -6705 0 0 0.5 0.5 {hcenter=1}
T {R} 1050 -6635 0 0 0.5 0.5 {hcenter=1}
T {Same commands are available for
vertical flip (Alt-v) and
horizontal flip (Alt-f)} 1350 -6680 0 0 0.5 0.5 {}
T {get existing wire} 750 -9195 0 0 0.5 0.5 {}
T {move} 1335 -9085 0 0 0.5 0.5 {}
T {extend} 2310 -9090 0 0 0.5 0.5 {}
T {duplicated} 2070 -8100 0 0 0.5 0.5 {}
T {Ctrl} 1520 -5935 0 0 0.5 0.5 {hcenter=1}
T {Toggle mouse vs 
crosshair display} 0 -600 0 0 1 1 {}
T {Alt} 1430 -455 0 0 0.5 0.5 {hcenter=1}
T {x} 1430 -385 0 0 0.5 0.5 {hcenter=1}
T {Alt} 2310 -455 0 0 0.5 0.5 {hcenter=1}
T {x} 2310 -385 0 0 0.5 0.5 {hcenter=1}
T {X1} 1085 -282 0 0 0.2 0.2 { layer=2}
T {CODE[5:0]} 1075 -264 0 1 0.2 0.2 { layer=2}
T {SIG_IN} 965 -264 0 0 0.2 0.2 { layer=2}
T {VREF} 965 -244 0 0 0.2 0.2 { layer=2}
T {CK} 965 -224 0 0 0.2 0.2 { layer=2}
T {RST} 965 -204 0 0 0.2 0.2 { layer=2}
T {adc} 1009.75 -228.5 0 0 0.2 0.2 { layer=2}
T {Auto-wiring
of components} 0 -200 0 0 1 1 {}
T {X1} 1655 -282 0 0 0.2 0.2 {}
T {CODE[5:0]} 1645 -264 0 1 0.2 0.2 {}
T {SIG_IN} 1535 -264 0 0 0.2 0.2 {}
T {VREF} 1535 -244 0 0 0.2 0.2 {}
T {CK} 1535 -224 0 0 0.2 0.2 {}
T {RST} 1535 -204 0 0 0.2 0.2 {}
T {adc} 1579.75 -228.5 0 0 0.2 0.2 {}
T {SIG_IN} 932.5 -268.125 0 1 0.33 0.33 { layer=1}
T {VREF} 932.5 -248.125 0 1 0.33 0.33 { layer=1}
T {CK} 932.5 -228.125 0 1 0.33 0.33 { layer=1}
T {RST} 932.5 -208.125 0 1 0.33 0.33 { layer=1}
T {CODE[5:0]} 1107.5 -268.125 0 0 0.33 0.33 { layer=1}
T {Shift} 1010 -145 0 0 0.5 0.5 {hcenter=1}
T {H} 1010 -75 0 0 0.5 0.5 {hcenter=1}
T {SIG_IN} 1432.5 -268.125 0 1 0.33 0.33 { layer=2}
T {VREF} 1432.5 -248.125 0 1 0.33 0.33 { layer=2}
T {CK} 1432.5 -228.125 0 1 0.33 0.33 { layer=2}
T {RST} 1432.5 -208.125 0 1 0.33 0.33 { layer=2}
T {Ctrl} 1440 -145 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1440 -75 0 0 0.5 0.5 {hcenter=1}
T {CODE[5:0]} 1677.5 -268.125 0 0 0.33 0.33 { layer=1}
T {X1} 2185 -282 0 0 0.2 0.2 {}
T {CODE[5:0]} 2175 -264 0 1 0.2 0.2 {}
T {SIG_IN} 2065 -264 0 0 0.2 0.2 {}
T {VREF} 2065 -244 0 0 0.2 0.2 {}
T {CK} 2065 -224 0 0 0.2 0.2 {}
T {RST} 2065 -204 0 0 0.2 0.2 {}
T {adc} 2109.75 -228.5 0 0 0.2 0.2 {}
T {SIG_IN} 1962.5 -268.125 0 1 0.33 0.33 { layer=1}
T {VREF} 1962.5 -248.125 0 1 0.33 0.33 { layer=1}
T {CK} 1962.5 -228.125 0 1 0.33 0.33 { layer=1}
T {RST} 1962.5 -208.125 0 1 0.33 0.33 { layer=1}
T {CODE[5:0]} 2297.5 -268.125 0 0 0.33 0.33 { layer=2}
T {Ctrl} 2370 -205 0 0 0.5 0.5 {hcenter=1}
T {Shift} 2370 -135 0 0 0.5 0.5 {hcenter=1}
T {X1} 665 -282 0 0 0.2 0.2 { layer=2}
T {CODE[5:0]} 655 -264 0 1 0.2 0.2 { layer=2}
T {SIG_IN} 545 -264 0 0 0.2 0.2 { layer=2}
T {VREF} 545 -244 0 0 0.2 0.2 { layer=2}
T {CK} 545 -224 0 0 0.2 0.2 { layer=2}
T {RST} 545 -204 0 0 0.2 0.2 { layer=2}
T {adc} 589.75 -228.5 0 0 0.2 0.2 { layer=2}
T {This represents the mouse
device. Red rectangle
indicates a pressed button} 2265 -11260 0 0 0.5 0.5 {}
T {Alt} 2210 -11135 0 0 0.5 0.5 {hcenter=1}
T {This represents 
a pressed modifier key} 2265 -11150 0 0 0.5 0.5 {}
T {R} 2210 -11055 0 0 0.5 0.5 {hcenter=1}
T {This represents 
a pressed key} 2265 -11070 0 0 0.5 0.5 {}
T {This represents the
mouse pointer} 2265 -11000 0 0 0.5 0.5 {}
