v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 1 917.5 -9402.5 922.5 -9402.5 {}
L 1 917.5 -9400 922.5 -9400 {}
L 1 917.5 -9397.5 922.5 -9397.5 {}
L 1 917.5 -9395 922.5 -9395 {}
L 1 917.5 -9392.5 922.5 -9392.5 {}
L 1 917.5 -9390 922.5 -9390 {}
L 1 917.5 -9387.5 922.5 -9387.5 {}
L 1 917.5 -9385 922.5 -9385 {}
L 1 917.5 -9382.5 922.5 -9382.5 {}
L 1 1347.5 -9402.5 1352.5 -9402.5 {}
L 1 1347.5 -9400 1352.5 -9400 {}
L 1 1347.5 -9397.5 1352.5 -9397.5 {}
L 1 1347.5 -9395 1352.5 -9395 {}
L 1 1347.5 -9392.5 1352.5 -9392.5 {}
L 1 1347.5 -9390 1352.5 -9390 {}
L 1 1347.5 -9387.5 1352.5 -9387.5 {}
L 1 1347.5 -9385 1352.5 -9385 {}
L 1 1347.5 -9382.5 1352.5 -9382.5 {}
L 1 2117.5 -9402.5 2122.5 -9402.5 {}
L 1 2117.5 -9400 2122.5 -9400 {}
L 1 2117.5 -9397.5 2122.5 -9397.5 {}
L 1 2117.5 -9395 2122.5 -9395 {}
L 1 2117.5 -9392.5 2122.5 -9392.5 {}
L 1 2117.5 -9390 2122.5 -9390 {}
L 1 2117.5 -9387.5 2122.5 -9387.5 {}
L 1 2117.5 -9385 2122.5 -9385 {}
L 1 2117.5 -9382.5 2122.5 -9382.5 {}
L 1 1417.5 -9212.5 1422.5 -9212.5 {}
L 1 1417.5 -9210 1422.5 -9210 {}
L 1 1417.5 -9207.5 1422.5 -9207.5 {}
L 1 1417.5 -9205 1422.5 -9205 {}
L 1 1417.5 -9202.5 1422.5 -9202.5 {}
L 1 1417.5 -9200 1422.5 -9200 {}
L 1 1417.5 -9197.5 1422.5 -9197.5 {}
L 1 1417.5 -9195 1422.5 -9195 {}
L 1 1417.5 -9192.5 1422.5 -9192.5 {}
L 1 1437.5 -5632.5 1442.5 -5632.5 {}
L 1 1437.5 -5630 1442.5 -5630 {}
L 1 1437.5 -5627.5 1442.5 -5627.5 {}
L 1 1437.5 -5625 1442.5 -5625 {}
L 1 1437.5 -5622.5 1442.5 -5622.5 {}
L 1 1437.5 -5620 1442.5 -5620 {}
L 1 1437.5 -5617.5 1442.5 -5617.5 {}
L 1 1437.5 -5615 1442.5 -5615 {}
L 1 1437.5 -5612.5 1442.5 -5612.5 {}
L 1 1437.5 -5232.5 1442.5 -5232.5 {}
L 1 1437.5 -5230 1442.5 -5230 {}
L 1 1437.5 -5227.5 1442.5 -5227.5 {}
L 1 1437.5 -5225 1442.5 -5225 {}
L 1 1437.5 -5222.5 1442.5 -5222.5 {}
L 1 1437.5 -5220 1442.5 -5220 {}
L 1 1437.5 -5217.5 1442.5 -5217.5 {}
L 1 1437.5 -5215 1442.5 -5215 {}
L 1 1437.5 -5212.5 1442.5 -5212.5 {}
L 1 947.5 -4552.5 952.5 -4552.5 {}
L 1 947.5 -4550 952.5 -4550 {}
L 1 947.5 -4547.5 952.5 -4547.5 {}
L 1 947.5 -4545 952.5 -4545 {}
L 1 947.5 -4542.5 952.5 -4542.5 {}
L 1 947.5 -4540 952.5 -4540 {}
L 1 947.5 -4537.5 952.5 -4537.5 {}
L 1 947.5 -4535 952.5 -4535 {}
L 1 947.5 -4532.5 952.5 -4532.5 {}
L 1 1060 -4810 1300 -4810 {}
L 1 1060 -4550 1300 -4550 {}
L 1 1447.5 -4562.5 1452.5 -4562.5 {}
L 1 1447.5 -4560 1452.5 -4560 {}
L 1 1447.5 -4557.5 1452.5 -4557.5 {}
L 1 1447.5 -4555 1452.5 -4555 {}
L 1 1447.5 -4552.5 1452.5 -4552.5 {}
L 1 1447.5 -4550 1452.5 -4550 {}
L 1 1447.5 -4547.5 1452.5 -4547.5 {}
L 1 1447.5 -4545 1452.5 -4545 {}
L 1 1447.5 -4542.5 1452.5 -4542.5 {}
L 1 917.5 -8572.5 922.5 -8572.5 {}
L 1 917.5 -8570 922.5 -8570 {}
L 1 917.5 -8567.5 922.5 -8567.5 {}
L 1 917.5 -8565 922.5 -8565 {}
L 1 917.5 -8562.5 922.5 -8562.5 {}
L 1 917.5 -8560 922.5 -8560 {}
L 1 917.5 -8557.5 922.5 -8557.5 {}
L 1 917.5 -8555 922.5 -8555 {}
L 1 917.5 -8552.5 922.5 -8552.5 {}
L 1 1347.5 -8572.5 1352.5 -8572.5 {}
L 1 1347.5 -8570 1352.5 -8570 {}
L 1 1347.5 -8567.5 1352.5 -8567.5 {}
L 1 1347.5 -8565 1352.5 -8565 {}
L 1 1347.5 -8562.5 1352.5 -8562.5 {}
L 1 1347.5 -8560 1352.5 -8560 {}
L 1 1347.5 -8557.5 1352.5 -8557.5 {}
L 1 1347.5 -8555 1352.5 -8555 {}
L 1 1347.5 -8552.5 1352.5 -8552.5 {}
L 1 2117.5 -8572.5 2122.5 -8572.5 {}
L 1 2117.5 -8570 2122.5 -8570 {}
L 1 2117.5 -8567.5 2122.5 -8567.5 {}
L 1 2117.5 -8565 2122.5 -8565 {}
L 1 2117.5 -8562.5 2122.5 -8562.5 {}
L 1 2117.5 -8560 2122.5 -8560 {}
L 1 2117.5 -8557.5 2122.5 -8557.5 {}
L 1 2117.5 -8555 2122.5 -8555 {}
L 1 2117.5 -8552.5 2122.5 -8552.5 {}
L 1 862.5 -9872.5 867.5 -9872.5 {}
L 1 862.5 -9870 867.5 -9870 {}
L 1 862.5 -9867.5 867.5 -9867.5 {}
L 1 862.5 -9865 867.5 -9865 {}
L 1 862.5 -9862.5 867.5 -9862.5 {}
L 1 862.5 -9860 867.5 -9860 {}
L 1 862.5 -9857.5 867.5 -9857.5 {}
L 1 862.5 -9855 867.5 -9855 {}
L 1 862.5 -9852.5 867.5 -9852.5 {}
L 1 1627.5 -9862.5 1632.5 -9862.5 {}
L 1 1627.5 -9860 1632.5 -9860 {}
L 1 1627.5 -9857.5 1632.5 -9857.5 {}
L 1 1627.5 -9855 1632.5 -9855 {}
L 1 1627.5 -9852.5 1632.5 -9852.5 {}
L 1 1627.5 -9850 1632.5 -9850 {}
L 1 1627.5 -9847.5 1632.5 -9847.5 {}
L 1 1627.5 -9845 1632.5 -9845 {}
L 1 1627.5 -9842.5 1632.5 -9842.5 {}
L 1 2407.5 -9852.5 2412.5 -9852.5 {}
L 1 2407.5 -9850 2412.5 -9850 {}
L 1 2407.5 -9847.5 2412.5 -9847.5 {}
L 1 2407.5 -9845 2412.5 -9845 {}
L 1 2407.5 -9842.5 2412.5 -9842.5 {}
L 1 2407.5 -9840 2412.5 -9840 {}
L 1 2407.5 -9837.5 2412.5 -9837.5 {}
L 1 2407.5 -9835 2412.5 -9835 {}
L 1 2407.5 -9832.5 2412.5 -9832.5 {}
L 1 820 -3610 820 -3280 {}
L 1 1360 -3610 1360 -3280 {}
L 1 1900 -3440 1900 -3280 {}
L 1 820 -3090 820 -2990 {}
L 1 710 -3090 710 -2990 {}
L 1 930 -3090 930 -2990 {}
L 1 820 -3970 820 -3820 {}
L 1 1360 -3970 1360 -3820 {}
L 1 1900 -3970 1900 -3860 {}
L 1 687.5 -7992.5 692.5 -7992.5 {}
L 1 687.5 -7990 692.5 -7990 {}
L 1 687.5 -7987.5 692.5 -7987.5 {}
L 1 687.5 -7985 692.5 -7985 {}
L 1 687.5 -7982.5 692.5 -7982.5 {}
L 1 687.5 -7980 692.5 -7980 {}
L 1 687.5 -7977.5 692.5 -7977.5 {}
L 1 687.5 -7975 692.5 -7975 {}
L 1 687.5 -7972.5 692.5 -7972.5 {}
L 1 1347.5 -8012.5 1352.5 -8012.5 {}
L 1 1347.5 -8010 1352.5 -8010 {}
L 1 1347.5 -8007.5 1352.5 -8007.5 {}
L 1 1347.5 -8005 1352.5 -8005 {}
L 1 1347.5 -8002.5 1352.5 -8002.5 {}
L 1 1347.5 -8000 1352.5 -8000 {}
L 1 1347.5 -7997.5 1352.5 -7997.5 {}
L 1 1347.5 -7995 1352.5 -7995 {}
L 1 1347.5 -7992.5 1352.5 -7992.5 {}
L 1 2537.5 -8062.5 2542.5 -8062.5 {}
L 1 2537.5 -8060 2542.5 -8060 {}
L 1 2537.5 -8057.5 2542.5 -8057.5 {}
L 1 2537.5 -8055 2542.5 -8055 {}
L 1 2537.5 -8052.5 2542.5 -8052.5 {}
L 1 2537.5 -8050 2542.5 -8050 {}
L 1 2537.5 -8047.5 2542.5 -8047.5 {}
L 1 2537.5 -8045 2542.5 -8045 {}
L 1 2537.5 -8042.5 2542.5 -8042.5 {}
L 1 1427.5 -3772.5 1432.5 -3772.5 {}
L 1 1427.5 -3770 1432.5 -3770 {}
L 1 1427.5 -3767.5 1432.5 -3767.5 {}
L 1 1427.5 -3765 1432.5 -3765 {}
L 1 1427.5 -3762.5 1432.5 -3762.5 {}
L 1 1427.5 -3760 1432.5 -3760 {}
L 1 1427.5 -3757.5 1432.5 -3757.5 {}
L 1 1427.5 -3755 1432.5 -3755 {}
L 1 1427.5 -3752.5 1432.5 -3752.5 {}
L 1 820 -1160 820 -1060 {}
L 1 710 -1160 710 -1060 {}
L 1 930 -1160 930 -1060 {}
L 1 820 -1000 820 -970 {}
L 1 710 -1000 710 -970 {}
L 1 930 -1000 930 -970 {}
L 1 2077.5 -1042.5 2082.5 -1042.5 {}
L 1 2077.5 -1040 2082.5 -1040 {}
L 1 2077.5 -1037.5 2082.5 -1037.5 {}
L 1 2077.5 -1035 2082.5 -1035 {}
L 1 2077.5 -1032.5 2082.5 -1032.5 {}
L 1 2077.5 -1030 2082.5 -1030 {}
L 1 2077.5 -1027.5 2082.5 -1027.5 {}
L 1 2077.5 -1025 2082.5 -1025 {}
L 1 2077.5 -1022.5 2082.5 -1022.5 {}
L 1 1567.5 -1012.5 1572.5 -1012.5 {}
L 1 1567.5 -1010 1572.5 -1010 {}
L 1 1567.5 -1007.5 1572.5 -1007.5 {}
L 1 1567.5 -1005 1572.5 -1005 {}
L 1 1567.5 -1002.5 1572.5 -1002.5 {}
L 1 1567.5 -1000 1572.5 -1000 {}
L 1 1567.5 -997.5 1572.5 -997.5 {}
L 1 1567.5 -995 1572.5 -995 {}
L 1 1567.5 -992.5 1572.5 -992.5 {}
L 1 1427.5 -3412.5 1432.5 -3412.5 {}
L 1 1427.5 -3410 1432.5 -3410 {}
L 1 1427.5 -3407.5 1432.5 -3407.5 {}
L 1 1427.5 -3405 1432.5 -3405 {}
L 1 1427.5 -3402.5 1432.5 -3402.5 {}
L 1 1427.5 -3400 1432.5 -3400 {}
L 1 1427.5 -3397.5 1432.5 -3397.5 {}
L 1 1427.5 -3395 1432.5 -3395 {}
L 1 1427.5 -3392.5 1432.5 -3392.5 {}
L 1 1957.5 -3522.5 1962.5 -3522.5 {}
L 1 1957.5 -3520 1962.5 -3520 {}
L 1 1957.5 -3517.5 1962.5 -3517.5 {}
L 1 1957.5 -3515 1962.5 -3515 {}
L 1 1957.5 -3512.5 1962.5 -3512.5 {}
L 1 1957.5 -3510 1962.5 -3510 {}
L 1 1957.5 -3507.5 1962.5 -3507.5 {}
L 1 1957.5 -3505 1962.5 -3505 {}
L 1 1957.5 -3502.5 1962.5 -3502.5 {}
L 1 1577.5 -3002.5 1582.5 -3002.5 {}
L 1 1577.5 -3000 1582.5 -3000 {}
L 1 1577.5 -2997.5 1582.5 -2997.5 {}
L 1 1577.5 -2995 1582.5 -2995 {}
L 1 1577.5 -2992.5 1582.5 -2992.5 {}
L 1 1577.5 -2990 1582.5 -2990 {}
L 1 1577.5 -2987.5 1582.5 -2987.5 {}
L 1 1577.5 -2985 1582.5 -2985 {}
L 1 1577.5 -2982.5 1582.5 -2982.5 {}
L 1 2067.5 -3062.5 2072.5 -3062.5 {}
L 1 2067.5 -3060 2072.5 -3060 {}
L 1 2067.5 -3057.5 2072.5 -3057.5 {}
L 1 2067.5 -3055 2072.5 -3055 {}
L 1 2067.5 -3052.5 2072.5 -3052.5 {}
L 1 2067.5 -3050 2072.5 -3050 {}
L 1 2067.5 -3047.5 2072.5 -3047.5 {}
L 1 2067.5 -3045 2072.5 -3045 {}
L 1 2067.5 -3042.5 2072.5 -3042.5 {}
L 1 2597.5 -3192.5 2602.5 -3192.5 {}
L 1 2597.5 -3190 2602.5 -3190 {}
L 1 2597.5 -3187.5 2602.5 -3187.5 {}
L 1 2597.5 -3185 2602.5 -3185 {}
L 1 2597.5 -3182.5 2602.5 -3182.5 {}
L 1 2597.5 -3180 2602.5 -3180 {}
L 1 2597.5 -3177.5 2602.5 -3177.5 {}
L 1 2597.5 -3175 2602.5 -3175 {}
L 1 2597.5 -3172.5 2602.5 -3172.5 {}
L 1 987.5 -10142.5 992.5 -10142.5 {}
L 1 987.5 -10140 992.5 -10140 {}
L 1 987.5 -10137.5 992.5 -10137.5 {}
L 1 987.5 -10135 992.5 -10135 {}
L 1 987.5 -10132.5 992.5 -10132.5 {}
L 1 987.5 -10130 992.5 -10130 {}
L 1 987.5 -10127.5 992.5 -10127.5 {}
L 1 987.5 -10125 992.5 -10125 {}
L 1 987.5 -10122.5 992.5 -10122.5 {}
L 1 820 -780 820 -680 {}
L 1 710 -780 710 -680 {}
L 1 930 -780 930 -680 {}
L 1 1567.5 -632.5 1572.5 -632.5 {}
L 1 1567.5 -630 1572.5 -630 {}
L 1 1567.5 -627.5 1572.5 -627.5 {}
L 1 1567.5 -625 1572.5 -625 {}
L 1 1567.5 -622.5 1572.5 -622.5 {}
L 1 1567.5 -620 1572.5 -620 {}
L 1 1567.5 -617.5 1572.5 -617.5 {}
L 1 1567.5 -615 1572.5 -615 {}
L 1 1567.5 -612.5 1572.5 -612.5 {}
L 1 2077.5 -582.5 2082.5 -582.5 {}
L 1 2077.5 -580 2082.5 -580 {}
L 1 2077.5 -577.5 2082.5 -577.5 {}
L 1 2077.5 -575 2082.5 -575 {}
L 1 2077.5 -572.5 2082.5 -572.5 {}
L 1 2077.5 -570 2082.5 -570 {}
L 1 2077.5 -567.5 2082.5 -567.5 {}
L 1 2077.5 -565 2082.5 -565 {}
L 1 2077.5 -562.5 2082.5 -562.5 {}
L 1 620 -2360 870 -2360 {}
L 1 1340 -2360 1410 -2360 {}
L 1 1160 -2360 1220 -2360 {}
L 1 1790 -2360 2040 -2360 {}
L 1 2340 -2360 2590 -2360 {}
L 1 620 -2080 870 -2080 {}
L 1 1160 -2080 1410 -2080 {}
L 1 1790 -2080 2040 -2080 {}
L 1 1910 -2200 1910 -2080 {}
L 1 2460 -2080 2590 -2080 {}
L 1 2460 -2200 2460 -2080 {}
L 1 2360 -3440 2360 -3280 {}
L 1 2497.5 -3442.5 2502.5 -3442.5 {}
L 1 2497.5 -3440 2502.5 -3440 {}
L 1 2497.5 -3437.5 2502.5 -3437.5 {}
L 1 2497.5 -3435 2502.5 -3435 {}
L 1 2497.5 -3432.5 2502.5 -3432.5 {}
L 1 2497.5 -3430 2502.5 -3430 {}
L 1 2497.5 -3427.5 2502.5 -3427.5 {}
L 1 2497.5 -3425 2502.5 -3425 {}
L 1 2497.5 -3422.5 2502.5 -3422.5 {}
L 1 1160 -1500 1410 -1500 {}
L 1 1880 -1370 1950 -1370 {}
L 1 1700 -1370 1760 -1370 {}
L 1 1817.5 -1482.5 1822.5 -1482.5 {}
L 1 1817.5 -1480 1822.5 -1480 {}
L 1 1817.5 -1477.5 1822.5 -1477.5 {}
L 1 1817.5 -1475 1822.5 -1475 {}
L 1 1817.5 -1472.5 1822.5 -1472.5 {}
L 1 1817.5 -1470 1822.5 -1470 {}
L 1 1817.5 -1467.5 1822.5 -1467.5 {}
L 1 1817.5 -1465 1822.5 -1465 {}
L 1 1817.5 -1462.5 1822.5 -1462.5 {}
L 1 620 -1500 870 -1500 {}
L 1 667.5 -1412.5 672.5 -1412.5 {}
L 1 667.5 -1410 672.5 -1410 {}
L 1 667.5 -1407.5 672.5 -1407.5 {}
L 1 667.5 -1405 672.5 -1405 {}
L 1 667.5 -1402.5 672.5 -1402.5 {}
L 1 667.5 -1400 672.5 -1400 {}
L 1 667.5 -1397.5 672.5 -1397.5 {}
L 1 667.5 -1395 672.5 -1395 {}
L 1 667.5 -1392.5 672.5 -1392.5 {}
L 1 787.5 -1412.5 792.5 -1412.5 {}
L 1 787.5 -1410 792.5 -1410 {}
L 1 787.5 -1407.5 792.5 -1407.5 {}
L 1 787.5 -1405 792.5 -1405 {}
L 1 787.5 -1402.5 792.5 -1402.5 {}
L 1 787.5 -1400 792.5 -1400 {}
L 1 787.5 -1397.5 792.5 -1397.5 {}
L 1 787.5 -1395 792.5 -1395 {}
L 1 787.5 -1392.5 792.5 -1392.5 {}
L 1 1597.5 -82.5 1602.5 -82.5 {}
L 1 1597.5 -80 1602.5 -80 {}
L 1 1597.5 -77.5 1602.5 -77.5 {}
L 1 1597.5 -75 1602.5 -75 {}
L 1 1597.5 -72.5 1602.5 -72.5 {}
L 1 1597.5 -70 1602.5 -70 {}
L 1 1597.5 -67.5 1602.5 -67.5 {}
L 1 1597.5 -65 1602.5 -65 {}
L 1 1597.5 -62.5 1602.5 -62.5 {}
L 1 620 -1680 870 -1680 {}
L 1 1160 -1680 1410 -1680 {}
L 1 1790 -1680 2040 -1680 {}
L 1 1830 -1850 1830 -1730 {}
L 1 2277.5 -4562.5 2282.5 -4562.5 {}
L 1 2277.5 -4560 2282.5 -4560 {}
L 1 2277.5 -4557.5 2282.5 -4557.5 {}
L 1 2277.5 -4555 2282.5 -4555 {}
L 1 2277.5 -4552.5 2282.5 -4552.5 {}
L 1 2277.5 -4550 2282.5 -4550 {}
L 1 2277.5 -4547.5 2282.5 -4547.5 {}
L 1 2277.5 -4545 2282.5 -4545 {}
L 1 2277.5 -4542.5 2282.5 -4542.5 {}
L 1 1977.5 -3772.5 1982.5 -3772.5 {}
L 1 1977.5 -3770 1982.5 -3770 {}
L 1 1977.5 -3767.5 1982.5 -3767.5 {}
L 1 1977.5 -3765 1982.5 -3765 {}
L 1 1977.5 -3762.5 1982.5 -3762.5 {}
L 1 1977.5 -3760 1982.5 -3760 {}
L 1 1977.5 -3757.5 1982.5 -3757.5 {}
L 1 1977.5 -3755 1982.5 -3755 {}
L 1 1977.5 -3752.5 1982.5 -3752.5 {}
L 1 2337.5 -2072.5 2342.5 -2072.5 {}
L 1 2337.5 -2070 2342.5 -2070 {}
L 1 2337.5 -2067.5 2342.5 -2067.5 {}
L 1 2337.5 -2065 2342.5 -2065 {}
L 1 2337.5 -2062.5 2342.5 -2062.5 {}
L 1 2337.5 -2060 2342.5 -2060 {}
L 1 2337.5 -2057.5 2342.5 -2057.5 {}
L 1 2337.5 -2055 2342.5 -2055 {}
L 1 2337.5 -2052.5 2342.5 -2052.5 {}
L 1 807.5 -2192.5 812.5 -2192.5 {}
L 1 807.5 -2190 812.5 -2190 {}
L 1 807.5 -2187.5 812.5 -2187.5 {}
L 1 807.5 -2185 812.5 -2185 {}
L 1 807.5 -2182.5 812.5 -2182.5 {}
L 1 807.5 -2180 812.5 -2180 {}
L 1 807.5 -2177.5 812.5 -2177.5 {}
L 1 807.5 -2175 812.5 -2175 {}
L 1 807.5 -2172.5 812.5 -2172.5 {}
L 1 1347.5 -2172.5 1352.5 -2172.5 {}
L 1 1347.5 -2170 1352.5 -2170 {}
L 1 1347.5 -2167.5 1352.5 -2167.5 {}
L 1 1347.5 -2165 1352.5 -2165 {}
L 1 1347.5 -2162.5 1352.5 -2162.5 {}
L 1 1347.5 -2160 1352.5 -2160 {}
L 1 1347.5 -2157.5 1352.5 -2157.5 {}
L 1 1347.5 -2155 1352.5 -2155 {}
L 1 1347.5 -2152.5 1352.5 -2152.5 {}
L 1 2320 -1850 2320 -1730 {}
L 1 1257.5 -1792.5 1262.5 -1792.5 {}
L 1 1257.5 -1790 1262.5 -1790 {}
L 1 1257.5 -1787.5 1262.5 -1787.5 {}
L 1 1257.5 -1785 1262.5 -1785 {}
L 1 1257.5 -1782.5 1262.5 -1782.5 {}
L 1 1257.5 -1780 1262.5 -1780 {}
L 1 1257.5 -1777.5 1262.5 -1777.5 {}
L 1 1257.5 -1775 1262.5 -1775 {}
L 1 1257.5 -1772.5 1262.5 -1772.5 {}
L 1 2517.5 -1742.5 2522.5 -1742.5 {}
L 1 2517.5 -1740 2522.5 -1740 {}
L 1 2517.5 -1737.5 2522.5 -1737.5 {}
L 1 2517.5 -1735 2522.5 -1735 {}
L 1 2517.5 -1732.5 2522.5 -1732.5 {}
L 1 2517.5 -1730 2522.5 -1730 {}
L 1 2517.5 -1727.5 2522.5 -1727.5 {}
L 1 2517.5 -1725 2522.5 -1725 {}
L 1 2517.5 -1722.5 2522.5 -1722.5 {}
L 1 2477.5 -332.5 2482.5 -332.5 {}
L 1 2477.5 -330 2482.5 -330 {}
L 1 2477.5 -327.5 2482.5 -327.5 {}
L 1 2477.5 -325 2482.5 -325 {}
L 1 2477.5 -322.5 2482.5 -322.5 {}
L 1 2477.5 -320 2482.5 -320 {}
L 1 2477.5 -317.5 2482.5 -317.5 {}
L 1 2477.5 -315 2482.5 -315 {}
L 1 2477.5 -312.5 2482.5 -312.5 {}
L 1 367.5 -7422.5 372.5 -7422.5 {}
L 1 367.5 -7420 372.5 -7420 {}
L 1 367.5 -7417.5 372.5 -7417.5 {}
L 1 367.5 -7415 372.5 -7415 {}
L 1 367.5 -7412.5 372.5 -7412.5 {}
L 1 367.5 -7410 372.5 -7410 {}
L 1 367.5 -7407.5 372.5 -7407.5 {}
L 1 367.5 -7405 372.5 -7405 {}
L 1 367.5 -7402.5 372.5 -7402.5 {}
L 1 897.5 -7592.5 902.5 -7592.5 {}
L 1 897.5 -7590 902.5 -7590 {}
L 1 897.5 -7587.5 902.5 -7587.5 {}
L 1 897.5 -7585 902.5 -7585 {}
L 1 897.5 -7582.5 902.5 -7582.5 {}
L 1 897.5 -7580 902.5 -7580 {}
L 1 897.5 -7577.5 902.5 -7577.5 {}
L 1 897.5 -7575 902.5 -7575 {}
L 1 897.5 -7572.5 902.5 -7572.5 {}
L 1 800 -7630 800 -7520 {}
L 1 1147.5 -7632.5 1152.5 -7632.5 {}
L 1 1147.5 -7630 1152.5 -7630 {}
L 1 1147.5 -7627.5 1152.5 -7627.5 {}
L 1 1147.5 -7625 1152.5 -7625 {}
L 1 1147.5 -7622.5 1152.5 -7622.5 {}
L 1 1147.5 -7620 1152.5 -7620 {}
L 1 1147.5 -7617.5 1152.5 -7617.5 {}
L 1 1147.5 -7615 1152.5 -7615 {}
L 1 1147.5 -7612.5 1152.5 -7612.5 {}
L 1 1090 -7630 1090 -7520 {}
L 1 1437.5 -7632.5 1442.5 -7632.5 {}
L 1 1437.5 -7630 1442.5 -7630 {}
L 1 1437.5 -7627.5 1442.5 -7627.5 {}
L 1 1437.5 -7625 1442.5 -7625 {}
L 1 1437.5 -7622.5 1442.5 -7622.5 {}
L 1 1437.5 -7620 1442.5 -7620 {}
L 1 1437.5 -7617.5 1442.5 -7617.5 {}
L 1 1437.5 -7615 1442.5 -7615 {}
L 1 1437.5 -7612.5 1442.5 -7612.5 {}
L 1 1320 -7630 1320 -7520 {}
L 1 1610 -7630 1610 -7520 {}
L 1 1897.5 -7592.5 1902.5 -7592.5 {}
L 1 1897.5 -7590 1902.5 -7590 {}
L 1 1897.5 -7587.5 1902.5 -7587.5 {}
L 1 1897.5 -7585 1902.5 -7585 {}
L 1 1897.5 -7582.5 1902.5 -7582.5 {}
L 1 1897.5 -7580 1902.5 -7580 {}
L 1 1897.5 -7577.5 1902.5 -7577.5 {}
L 1 1897.5 -7575 1902.5 -7575 {}
L 1 1897.5 -7572.5 1902.5 -7572.5 {}
L 1 1850 -7630 1850 -7520 {}
L 1 2150 -7630 2150 -7520 {}
L 1 927.5 -4142.5 932.5 -4142.5 {}
L 1 927.5 -4140 932.5 -4140 {}
L 1 927.5 -4137.5 932.5 -4137.5 {}
L 1 927.5 -4135 932.5 -4135 {}
L 1 927.5 -4132.5 932.5 -4132.5 {}
L 1 927.5 -4130 932.5 -4130 {}
L 1 927.5 -4127.5 932.5 -4127.5 {}
L 1 927.5 -4125 932.5 -4125 {}
L 1 927.5 -4122.5 932.5 -4122.5 {}
L 1 1767.5 -4192.5 1772.5 -4192.5 {}
L 1 1767.5 -4190 1772.5 -4190 {}
L 1 1767.5 -4187.5 1772.5 -4187.5 {}
L 1 1767.5 -4185 1772.5 -4185 {}
L 1 1767.5 -4182.5 1772.5 -4182.5 {}
L 1 1767.5 -4180 1772.5 -4180 {}
L 1 1767.5 -4177.5 1772.5 -4177.5 {}
L 1 1767.5 -4175 1772.5 -4175 {}
L 1 1767.5 -4172.5 1772.5 -4172.5 {}
L 1 2527.5 -4192.5 2532.5 -4192.5 {}
L 1 2527.5 -4190 2532.5 -4190 {}
L 1 2527.5 -4187.5 2532.5 -4187.5 {}
L 1 2527.5 -4185 2532.5 -4185 {}
L 1 2527.5 -4182.5 2532.5 -4182.5 {}
L 1 2527.5 -4180 2532.5 -4180 {}
L 1 2527.5 -4177.5 2532.5 -4177.5 {}
L 1 2527.5 -4175 2532.5 -4175 {}
L 1 2527.5 -4172.5 2532.5 -4172.5 {}
L 1 902.5 -8412.5 907.5 -8412.5 {}
L 1 902.5 -8410 907.5 -8410 {}
L 1 902.5 -8407.5 907.5 -8407.5 {}
L 1 902.5 -8405 907.5 -8405 {}
L 1 902.5 -8402.5 907.5 -8402.5 {}
L 1 902.5 -8400 907.5 -8400 {}
L 1 902.5 -8397.5 907.5 -8397.5 {}
L 1 902.5 -8395 907.5 -8395 {}
L 1 902.5 -8392.5 907.5 -8392.5 {}
L 1 1437.5 -8292.5 1442.5 -8292.5 {}
L 1 1437.5 -8290 1442.5 -8290 {}
L 1 1437.5 -8287.5 1442.5 -8287.5 {}
L 1 1437.5 -8285 1442.5 -8285 {}
L 1 1437.5 -8282.5 1442.5 -8282.5 {}
L 1 1437.5 -8280 1442.5 -8280 {}
L 1 1437.5 -8277.5 1442.5 -8277.5 {}
L 1 1437.5 -8275 1442.5 -8275 {}
L 1 1437.5 -8272.5 1442.5 -8272.5 {}
L 1 465 -8450 705 -8450 {}
L 1 1030 -8450 1270 -8450 {}
L 1 1807.5 -8292.5 1812.5 -8292.5 {}
L 1 1807.5 -8290 1812.5 -8290 {}
L 1 1807.5 -8287.5 1812.5 -8287.5 {}
L 1 1807.5 -8285 1812.5 -8285 {}
L 1 1807.5 -8282.5 1812.5 -8282.5 {}
L 1 1807.5 -8280 1812.5 -8280 {}
L 1 1807.5 -8277.5 1812.5 -8277.5 {}
L 1 1807.5 -8275 1812.5 -8275 {}
L 1 1807.5 -8272.5 1812.5 -8272.5 {}
L 1 1530 -8450 1770 -8450 {}
L 1 2297.5 -8292.5 2302.5 -8292.5 {}
L 1 2297.5 -8290 2302.5 -8290 {}
L 1 2297.5 -8287.5 2302.5 -8287.5 {}
L 1 2297.5 -8285 2302.5 -8285 {}
L 1 2297.5 -8282.5 2302.5 -8282.5 {}
L 1 2297.5 -8280 2302.5 -8280 {}
L 1 2297.5 -8277.5 2302.5 -8277.5 {}
L 1 2297.5 -8275 2302.5 -8275 {}
L 1 2297.5 -8272.5 2302.5 -8272.5 {}
L 1 2020 -8450 2260 -8450 {}
L 1 1610 -7630 1670 -7630 {}
L 1 2247.5 -7442.5 2252.5 -7442.5 {}
L 1 2247.5 -7440 2252.5 -7440 {}
L 1 2247.5 -7437.5 2252.5 -7437.5 {}
L 1 2247.5 -7435 2252.5 -7435 {}
L 1 2247.5 -7432.5 2252.5 -7432.5 {}
L 1 2247.5 -7430 2252.5 -7430 {}
L 1 2247.5 -7427.5 2252.5 -7427.5 {}
L 1 2247.5 -7425 2252.5 -7425 {}
L 1 2247.5 -7422.5 2252.5 -7422.5 {}
L 1 2150 -7630 2210 -7630 {}
L 1 2047.5 -6892.5 2052.5 -6892.5 {}
L 1 2047.5 -6890 2052.5 -6890 {}
L 1 2047.5 -6887.5 2052.5 -6887.5 {}
L 1 2047.5 -6885 2052.5 -6885 {}
L 1 2047.5 -6882.5 2052.5 -6882.5 {}
L 1 2047.5 -6880 2052.5 -6880 {}
L 1 2047.5 -6877.5 2052.5 -6877.5 {}
L 1 2047.5 -6875 2052.5 -6875 {}
L 1 2047.5 -6872.5 2052.5 -6872.5 {}
L 1 2047.5 -6462.5 2052.5 -6462.5 {}
L 1 2047.5 -6460 2052.5 -6460 {}
L 1 2047.5 -6457.5 2052.5 -6457.5 {}
L 1 2047.5 -6455 2052.5 -6455 {}
L 1 2047.5 -6452.5 2052.5 -6452.5 {}
L 1 2047.5 -6450 2052.5 -6450 {}
L 1 2047.5 -6447.5 2052.5 -6447.5 {}
L 1 2047.5 -6445 2052.5 -6445 {}
L 1 2047.5 -6442.5 2052.5 -6442.5 {}
L 1 1157.5 -5982.5 1162.5 -5982.5 {}
L 1 1157.5 -5980 1162.5 -5980 {}
L 1 1157.5 -5977.5 1162.5 -5977.5 {}
L 1 1157.5 -5975 1162.5 -5975 {}
L 1 1157.5 -5972.5 1162.5 -5972.5 {}
L 1 1157.5 -5970 1162.5 -5970 {}
L 1 1157.5 -5967.5 1162.5 -5967.5 {}
L 1 1157.5 -5965 1162.5 -5965 {}
L 1 1157.5 -5962.5 1162.5 -5962.5 {}
L 1 2360 -7630 2360 -7520 {}
L 1 2477.5 -7502.5 2482.5 -7502.5 {}
L 1 2477.5 -7500 2482.5 -7500 {}
L 1 2477.5 -7497.5 2482.5 -7497.5 {}
L 1 2477.5 -7495 2482.5 -7495 {}
L 1 2477.5 -7492.5 2482.5 -7492.5 {}
L 1 2477.5 -7490 2482.5 -7490 {}
L 1 2477.5 -7487.5 2482.5 -7487.5 {}
L 1 2477.5 -7485 2482.5 -7485 {}
L 1 2477.5 -7482.5 2482.5 -7482.5 {}
L 1 2360 -7630 2420 -7630 {}
L 1 617.5 -7632.5 622.5 -7632.5 {}
L 1 617.5 -7630 622.5 -7630 {}
L 1 617.5 -7627.5 622.5 -7627.5 {}
L 1 617.5 -7625 622.5 -7625 {}
L 1 617.5 -7622.5 622.5 -7622.5 {}
L 1 617.5 -7620 622.5 -7620 {}
L 1 617.5 -7617.5 622.5 -7617.5 {}
L 1 617.5 -7615 622.5 -7615 {}
L 1 617.5 -7612.5 622.5 -7612.5 {}
L 2 1255 -9580 1255 -9520 {}
L 2 1255 -9570 1270 -9570 {}
L 2 1270 -9580 1270 -9570 {}
L 2 1255 -9530 1270 -9530 {}
L 2 1270 -9530 1270 -9520 {}
L 2 1245 -9565 1245 -9535 {}
L 2 1245 -9550 1245 -9545 {}
L 2 1230 -9550 1237.5 -9550 {}
L 2 1230 -9550 1245 -9550 {}
L 2 1260 -9550 1270 -9550 {}
L 2 1255 -9555 1260 -9550 {}
L 2 1255 -9545 1260 -9550 {}
L 2 1270 -9620 1270 -9610 {}
L 2 1270 -9620 1277.5 -9622.5 {}
L 2 1262.5 -9627.5 1277.5 -9622.5 {}
L 2 1262.5 -9627.5 1277.5 -9632.5 {}
L 2 1262.5 -9637.5 1277.5 -9632.5 {}
L 2 1262.5 -9637.5 1277.5 -9642.5 {}
L 2 1262.5 -9647.5 1277.5 -9642.5 {}
L 2 1262.5 -9647.5 1277.5 -9652.5 {}
L 2 1262.5 -9657.5 1277.5 -9652.5 {}
L 2 1262.5 -9657.5 1270 -9660 {}
L 2 1270 -9670 1270 -9660 {}
L 2 1272.5 -9662.5 1277.5 -9662.5 {}
L 2 1275 -9665 1275 -9660 {}
L 2 1360 -9545 1360 -9520 {}
L 2 1360 -9580 1360 -9555 {}
L 2 1350 -9555 1370 -9555 {}
L 2 1350 -9545 1370 -9545 {}
L 2 1362.5 -9572.5 1367.5 -9572.5 {}
L 2 1365 -9575 1365 -9570 {}
L 2 1270 -9610 1270 -9580 {}
L 2 1270 -9700 1270 -9670 {}
L 2 1360 -9520 1360 -9440 {}
L 2 1270 -9550 1270 -9440 {}
L 2 1270 -9440 1360 -9440 {}
L 2 2035 -9590 2035 -9530 {}
L 2 2035 -9580 2050 -9580 {}
L 2 2050 -9590 2050 -9580 {}
L 2 2035 -9540 2050 -9540 {}
L 2 2050 -9540 2050 -9530 {}
L 2 2025 -9575 2025 -9545 {}
L 2 2025 -9560 2025 -9555 {}
L 2 2010 -9560 2017.5 -9560 {}
L 2 2010 -9560 2025 -9560 {}
L 2 2040 -9560 2050 -9560 {}
L 2 2035 -9565 2040 -9560 {}
L 2 2035 -9555 2040 -9560 {}
L 2 2050 -9630 2050 -9620 {}
L 2 2050 -9630 2057.5 -9632.5 {}
L 2 2042.5 -9637.5 2057.5 -9632.5 {}
L 2 2042.5 -9637.5 2057.5 -9642.5 {}
L 2 2042.5 -9647.5 2057.5 -9642.5 {}
L 2 2042.5 -9647.5 2057.5 -9652.5 {}
L 2 2042.5 -9657.5 2057.5 -9652.5 {}
L 2 2042.5 -9657.5 2057.5 -9662.5 {}
L 2 2042.5 -9667.5 2057.5 -9662.5 {}
L 2 2042.5 -9667.5 2050 -9670 {}
L 2 2050 -9680 2050 -9670 {}
L 2 2052.5 -9672.5 2057.5 -9672.5 {}
L 2 2055 -9675 2055 -9670 {}
L 2 2140 -9555 2140 -9530 {}
L 2 2140 -9590 2140 -9565 {}
L 2 2130 -9565 2150 -9565 {}
L 2 2130 -9555 2150 -9555 {}
L 2 2142.5 -9582.5 2147.5 -9582.5 {}
L 2 2145 -9585 2145 -9580 {}
L 2 2050 -9620 2050 -9590 {}
L 2 2050 -9710 2050 -9680 {}
L 2 2140 -9530 2140 -9450 {}
L 2 2050 -9560 2050 -9450 {}
L 2 2050 -9450 2140 -9450 {}
L 2 1360 -9160 1360 -9150 {}
L 2 1360 -9160 1367.5 -9162.5 {}
L 2 1352.5 -9167.5 1367.5 -9162.5 {}
L 2 1352.5 -9167.5 1367.5 -9172.5 {}
L 2 1352.5 -9177.5 1367.5 -9172.5 {}
L 2 1352.5 -9177.5 1367.5 -9182.5 {}
L 2 1352.5 -9187.5 1367.5 -9182.5 {}
L 2 1352.5 -9187.5 1367.5 -9192.5 {}
L 2 1352.5 -9197.5 1367.5 -9192.5 {}
L 2 1352.5 -9197.5 1360 -9200 {}
L 2 1360 -9210 1360 -9200 {}
L 2 1362.5 -9202.5 1367.5 -9202.5 {}
L 2 1365 -9205 1365 -9200 {}
L 2 1360 -5570 1360 -5560 {}
L 2 1360 -5570 1367.5 -5572.5 {}
L 2 1352.5 -5577.5 1367.5 -5572.5 {}
L 2 1352.5 -5577.5 1367.5 -5582.5 {}
L 2 1352.5 -5587.5 1367.5 -5582.5 {}
L 2 1352.5 -5587.5 1367.5 -5592.5 {}
L 2 1352.5 -5597.5 1367.5 -5592.5 {}
L 2 1352.5 -5597.5 1367.5 -5602.5 {}
L 2 1352.5 -5607.5 1367.5 -5602.5 {}
L 2 1352.5 -5607.5 1360 -5610 {}
L 2 1360 -5620 1360 -5610 {}
L 2 1362.5 -5612.5 1367.5 -5612.5 {}
L 2 1365 -5615 1365 -5610 {}
L 2 1280 -5620 1360 -5620 {}
L 2 1280 -5560 1360 -5560 {}
L 2 1360 -5170 1360 -5160 {}
L 2 1360 -5170 1367.5 -5172.5 {}
L 2 1352.5 -5177.5 1367.5 -5172.5 {}
L 2 1352.5 -5177.5 1367.5 -5182.5 {}
L 2 1352.5 -5187.5 1367.5 -5182.5 {}
L 2 1352.5 -5187.5 1367.5 -5192.5 {}
L 2 1352.5 -5197.5 1367.5 -5192.5 {}
L 2 1352.5 -5197.5 1367.5 -5202.5 {}
L 2 1352.5 -5207.5 1367.5 -5202.5 {}
L 2 1352.5 -5207.5 1360 -5210 {}
L 2 1360 -5220 1360 -5210 {}
L 2 1362.5 -5212.5 1367.5 -5212.5 {}
L 2 1365 -5215 1365 -5210 {}
L 2 1280 -5130 1360 -5160 {}
L 2 1280 -5250 1360 -5220 {}
L 2 725 -9580 725 -9520 {}
L 2 725 -9570 740 -9570 {}
L 2 740 -9580 740 -9570 {}
L 2 725 -9530 740 -9530 {}
L 2 740 -9530 740 -9520 {}
L 2 715 -9565 715 -9535 {}
L 2 715 -9550 715 -9545 {}
L 2 700 -9550 707.5 -9550 {}
L 2 700 -9550 715 -9550 {}
L 2 730 -9550 740 -9550 {}
L 2 725 -9555 730 -9550 {}
L 2 725 -9545 730 -9550 {}
L 2 740 -9620 740 -9610 {}
L 2 740 -9620 747.5 -9622.5 {}
L 2 732.5 -9627.5 747.5 -9622.5 {}
L 2 732.5 -9627.5 747.5 -9632.5 {}
L 2 732.5 -9637.5 747.5 -9632.5 {}
L 2 732.5 -9637.5 747.5 -9642.5 {}
L 2 732.5 -9647.5 747.5 -9642.5 {}
L 2 732.5 -9647.5 747.5 -9652.5 {}
L 2 732.5 -9657.5 747.5 -9652.5 {}
L 2 732.5 -9657.5 740 -9660 {}
L 2 740 -9670 740 -9660 {}
L 2 742.5 -9662.5 747.5 -9662.5 {}
L 2 745 -9665 745 -9660 {}
L 2 830 -9545 830 -9520 {}
L 2 830 -9580 830 -9555 {}
L 2 820 -9555 840 -9555 {}
L 2 820 -9545 840 -9545 {}
L 2 832.5 -9572.5 837.5 -9572.5 {}
L 2 835 -9575 835 -9570 {}
L 2 740 -9610 740 -9580 {}
L 2 740 -9700 740 -9670 {}
L 2 830 -9520 830 -9440 {}
L 2 740 -9550 740 -9440 {}
L 2 740 -9440 830 -9440 {}
L 2 725 -4690 725 -4630 {}
L 2 725 -4680 740 -4680 {}
L 2 740 -4690 740 -4680 {}
L 2 725 -4640 740 -4640 {}
L 2 740 -4640 740 -4630 {}
L 2 715 -4675 715 -4645 {}
L 2 715 -4660 715 -4655 {}
L 2 700 -4660 707.5 -4660 {}
L 2 700 -4660 715 -4660 {}
L 2 730 -4660 740 -4660 {}
L 2 725 -4665 730 -4660 {}
L 2 725 -4655 730 -4660 {}
L 2 740 -4730 740 -4720 {}
L 2 740 -4730 747.5 -4732.5 {}
L 2 732.5 -4737.5 747.5 -4732.5 {}
L 2 732.5 -4737.5 747.5 -4742.5 {}
L 2 732.5 -4747.5 747.5 -4742.5 {}
L 2 732.5 -4747.5 747.5 -4752.5 {}
L 2 732.5 -4757.5 747.5 -4752.5 {}
L 2 732.5 -4757.5 747.5 -4762.5 {}
L 2 732.5 -4767.5 747.5 -4762.5 {}
L 2 732.5 -4767.5 740 -4770 {}
L 2 740 -4780 740 -4770 {}
L 2 742.5 -4772.5 747.5 -4772.5 {}
L 2 745 -4775 745 -4770 {}
L 2 830 -4655 830 -4630 {}
L 2 830 -4690 830 -4665 {}
L 2 820 -4665 840 -4665 {}
L 2 820 -4655 840 -4655 {}
L 2 832.5 -4682.5 837.5 -4682.5 {}
L 2 835 -4685 835 -4680 {}
L 2 740 -4720 740 -4690 {}
L 2 740 -4810 740 -4780 {}
L 2 830 -4630 830 -4550 {}
L 2 740 -4660 740 -4550 {}
L 2 740 -4550 830 -4550 {}
L 2 880 -4690 888.75 -4690 {}
L 2 740 -4690 880 -4690 {}
L 2 1285 -4690 1285 -4630 {}
L 2 1285 -4680 1300 -4680 {}
L 2 1300 -4690 1300 -4680 {}
L 2 1285 -4640 1300 -4640 {}
L 2 1300 -4640 1300 -4630 {}
L 2 1275 -4675 1275 -4645 {}
L 2 1275 -4660 1275 -4655 {}
L 2 1260 -4660 1267.5 -4660 {}
L 2 1260 -4660 1275 -4660 {}
L 2 1290 -4660 1300 -4660 {}
L 2 1285 -4665 1290 -4660 {}
L 2 1285 -4655 1290 -4660 {}
L 2 1300 -4730 1300 -4720 {}
L 2 1300 -4730 1307.5 -4732.5 {}
L 2 1292.5 -4737.5 1307.5 -4732.5 {}
L 2 1292.5 -4737.5 1307.5 -4742.5 {}
L 2 1292.5 -4747.5 1307.5 -4742.5 {}
L 2 1292.5 -4747.5 1307.5 -4752.5 {}
L 2 1292.5 -4757.5 1307.5 -4752.5 {}
L 2 1292.5 -4757.5 1307.5 -4762.5 {}
L 2 1292.5 -4767.5 1307.5 -4762.5 {}
L 2 1292.5 -4767.5 1300 -4770 {}
L 2 1300 -4780 1300 -4770 {}
L 2 1302.5 -4772.5 1307.5 -4772.5 {}
L 2 1305 -4775 1305 -4770 {}
L 2 1390 -4655 1390 -4630 {}
L 2 1390 -4690 1390 -4665 {}
L 2 1380 -4665 1400 -4665 {}
L 2 1380 -4655 1400 -4655 {}
L 2 1392.5 -4682.5 1397.5 -4682.5 {}
L 2 1395 -4685 1395 -4680 {}
L 2 1440 -4690 1448.75 -4690 {}
L 2 1300 -4720 1300 -4690 {}
L 2 1300 -4810 1300 -4780 {}
L 2 1300 -4690 1440 -4690 {}
L 2 1390 -4630 1390 -4550 {}
L 2 1300 -4660 1300 -4550 {}
L 2 1300 -4550 1390 -4550 {}
L 2 2105 -4690 2105 -4630 {}
L 2 2105 -4680 2120 -4680 {}
L 2 2120 -4690 2120 -4680 {}
L 2 2105 -4640 2120 -4640 {}
L 2 2120 -4640 2120 -4630 {}
L 2 2095 -4675 2095 -4645 {}
L 2 2095 -4660 2095 -4655 {}
L 2 2080 -4660 2087.5 -4660 {}
L 2 2080 -4660 2095 -4660 {}
L 2 2110 -4660 2120 -4660 {}
L 2 2105 -4665 2110 -4660 {}
L 2 2105 -4655 2110 -4660 {}
L 2 2120 -4730 2120 -4720 {}
L 2 2120 -4730 2127.5 -4732.5 {}
L 2 2112.5 -4737.5 2127.5 -4732.5 {}
L 2 2112.5 -4737.5 2127.5 -4742.5 {}
L 2 2112.5 -4747.5 2127.5 -4742.5 {}
L 2 2112.5 -4747.5 2127.5 -4752.5 {}
L 2 2112.5 -4757.5 2127.5 -4752.5 {}
L 2 2112.5 -4757.5 2127.5 -4762.5 {}
L 2 2112.5 -4767.5 2127.5 -4762.5 {}
L 2 2112.5 -4767.5 2120 -4770 {}
L 2 2120 -4780 2120 -4770 {}
L 2 2122.5 -4772.5 2127.5 -4772.5 {}
L 2 2125 -4775 2125 -4770 {}
L 2 2210 -4655 2210 -4630 {}
L 2 2210 -4690 2210 -4665 {}
L 2 2200 -4665 2220 -4665 {}
L 2 2200 -4655 2220 -4655 {}
L 2 2212.5 -4682.5 2217.5 -4682.5 {}
L 2 2215 -4685 2215 -4680 {}
L 2 2260 -4690 2268.75 -4690 {}
L 2 2120 -4720 2120 -4690 {}
L 2 2120 -4810 2120 -4780 {}
L 2 2120 -4690 2260 -4690 {}
L 2 2210 -4630 2210 -4550 {}
L 2 2120 -4660 2120 -4550 {}
L 2 2120 -4550 2210 -4550 {}
L 2 1770 -4660 2080 -4660 {}
L 2 1690 -4810 2120 -4810 {}
L 2 1690 -4550 2120 -4550 {}
L 2 1255 -8750 1255 -8690 {}
L 2 1255 -8740 1270 -8740 {}
L 2 1270 -8750 1270 -8740 {}
L 2 1255 -8700 1270 -8700 {}
L 2 1270 -8700 1270 -8690 {}
L 2 1245 -8735 1245 -8705 {}
L 2 1245 -8720 1245 -8715 {}
L 2 1230 -8720 1237.5 -8720 {}
L 2 1230 -8720 1245 -8720 {}
L 2 1260 -8720 1270 -8720 {}
L 2 1255 -8725 1260 -8720 {}
L 2 1255 -8715 1260 -8720 {}
L 2 1270 -8790 1270 -8780 {}
L 2 1270 -8790 1277.5 -8792.5 {}
L 2 1262.5 -8797.5 1277.5 -8792.5 {}
L 2 1262.5 -8797.5 1277.5 -8802.5 {}
L 2 1262.5 -8807.5 1277.5 -8802.5 {}
L 2 1262.5 -8807.5 1277.5 -8812.5 {}
L 2 1262.5 -8817.5 1277.5 -8812.5 {}
L 2 1262.5 -8817.5 1277.5 -8822.5 {}
L 2 1262.5 -8827.5 1277.5 -8822.5 {}
L 2 1262.5 -8827.5 1270 -8830 {}
L 2 1270 -8840 1270 -8830 {}
L 2 1272.5 -8832.5 1277.5 -8832.5 {}
L 2 1275 -8835 1275 -8830 {}
L 2 1360 -8715 1360 -8690 {}
L 2 1360 -8750 1360 -8725 {}
L 2 1350 -8725 1370 -8725 {}
L 2 1350 -8715 1370 -8715 {}
L 2 1362.5 -8742.5 1367.5 -8742.5 {}
L 2 1365 -8745 1365 -8740 {}
L 2 1270 -8780 1270 -8750 {}
L 2 1270 -8870 1270 -8840 {}
L 2 1360 -8690 1360 -8610 {}
L 2 1270 -8720 1270 -8610 {}
L 2 1270 -8610 1360 -8610 {}
L 2 2035 -8760 2035 -8700 {}
L 2 2035 -8750 2050 -8750 {}
L 2 2050 -8760 2050 -8750 {}
L 2 2035 -8710 2050 -8710 {}
L 2 2050 -8710 2050 -8700 {}
L 2 2025 -8745 2025 -8715 {}
L 2 2025 -8730 2025 -8725 {}
L 2 2010 -8730 2017.5 -8730 {}
L 2 2010 -8730 2025 -8730 {}
L 2 2040 -8730 2050 -8730 {}
L 2 2035 -8735 2040 -8730 {}
L 2 2035 -8725 2040 -8730 {}
L 2 2050 -8800 2050 -8790 {}
L 2 2050 -8800 2057.5 -8802.5 {}
L 2 2042.5 -8807.5 2057.5 -8802.5 {}
L 2 2042.5 -8807.5 2057.5 -8812.5 {}
L 2 2042.5 -8817.5 2057.5 -8812.5 {}
L 2 2042.5 -8817.5 2057.5 -8822.5 {}
L 2 2042.5 -8827.5 2057.5 -8822.5 {}
L 2 2042.5 -8827.5 2057.5 -8832.5 {}
L 2 2042.5 -8837.5 2057.5 -8832.5 {}
L 2 2042.5 -8837.5 2050 -8840 {}
L 2 2050 -8850 2050 -8840 {}
L 2 2052.5 -8842.5 2057.5 -8842.5 {}
L 2 2055 -8845 2055 -8840 {}
L 2 2140 -8725 2140 -8700 {}
L 2 2140 -8760 2140 -8735 {}
L 2 2130 -8735 2150 -8735 {}
L 2 2130 -8725 2150 -8725 {}
L 2 2142.5 -8752.5 2147.5 -8752.5 {}
L 2 2145 -8755 2145 -8750 {}
L 2 2050 -8790 2050 -8760 {}
L 2 2050 -8880 2050 -8850 {}
L 2 2140 -8700 2140 -8620 {}
L 2 2050 -8730 2050 -8620 {}
L 2 2050 -8620 2140 -8620 {}
L 2 725 -8750 725 -8690 {}
L 2 725 -8740 740 -8740 {}
L 2 740 -8750 740 -8740 {}
L 2 725 -8700 740 -8700 {}
L 2 740 -8700 740 -8690 {}
L 2 715 -8735 715 -8705 {}
L 2 715 -8720 715 -8715 {}
L 2 700 -8720 707.5 -8720 {}
L 2 700 -8720 715 -8720 {}
L 2 730 -8720 740 -8720 {}
L 2 725 -8725 730 -8720 {}
L 2 725 -8715 730 -8720 {}
L 2 740 -8790 740 -8780 {}
L 2 740 -8790 747.5 -8792.5 {}
L 2 732.5 -8797.5 747.5 -8792.5 {}
L 2 732.5 -8797.5 747.5 -8802.5 {}
L 2 732.5 -8807.5 747.5 -8802.5 {}
L 2 732.5 -8807.5 747.5 -8812.5 {}
L 2 732.5 -8817.5 747.5 -8812.5 {}
L 2 732.5 -8817.5 747.5 -8822.5 {}
L 2 732.5 -8827.5 747.5 -8822.5 {}
L 2 732.5 -8827.5 740 -8830 {}
L 2 740 -8840 740 -8830 {}
L 2 742.5 -8832.5 747.5 -8832.5 {}
L 2 745 -8835 745 -8830 {}
L 2 830 -8715 830 -8690 {}
L 2 830 -8750 830 -8725 {}
L 2 820 -8725 840 -8725 {}
L 2 820 -8715 840 -8715 {}
L 2 832.5 -8742.5 837.5 -8742.5 {}
L 2 835 -8745 835 -8740 {}
L 2 740 -8780 740 -8750 {}
L 2 740 -8870 740 -8840 {}
L 2 830 -8690 830 -8610 {}
L 2 740 -8720 740 -8610 {}
L 2 740 -8610 830 -8610 {}
L 2 1795 -10050 1795 -9990 {}
L 2 1795 -10040 1810 -10040 {}
L 2 1810 -10050 1810 -10040 {}
L 2 1795 -10000 1810 -10000 {}
L 2 1810 -10000 1810 -9990 {}
L 2 1785 -10035 1785 -10005 {}
L 2 1785 -10020 1785 -10015 {}
L 2 1770 -10020 1777.5 -10020 {}
L 2 1770 -10020 1785 -10020 {}
L 2 1800 -10020 1810 -10020 {}
L 2 1795 -10025 1800 -10020 {}
L 2 1795 -10015 1800 -10020 {}
L 2 1810 -10090 1810 -10080 {}
L 2 1810 -10090 1817.5 -10092.5 {}
L 2 1802.5 -10097.5 1817.5 -10092.5 {}
L 2 1802.5 -10097.5 1817.5 -10102.5 {}
L 2 1802.5 -10107.5 1817.5 -10102.5 {}
L 2 1802.5 -10107.5 1817.5 -10112.5 {}
L 2 1802.5 -10117.5 1817.5 -10112.5 {}
L 2 1802.5 -10117.5 1817.5 -10122.5 {}
L 2 1802.5 -10127.5 1817.5 -10122.5 {}
L 2 1802.5 -10127.5 1810 -10130 {}
L 2 1810 -10140 1810 -10130 {}
L 2 1812.5 -10132.5 1817.5 -10132.5 {}
L 2 1815 -10135 1815 -10130 {}
L 2 1900 -10015 1900 -9990 {}
L 2 1900 -10050 1900 -10025 {}
L 2 1890 -10025 1910 -10025 {}
L 2 1890 -10015 1910 -10015 {}
L 2 1902.5 -10042.5 1907.5 -10042.5 {}
L 2 1905 -10045 1905 -10040 {}
L 2 1810 -10080 1810 -10050 {}
L 2 1810 -10170 1810 -10140 {}
L 2 1900 -9990 1900 -9910 {}
L 2 1810 -10020 1810 -9910 {}
L 2 1810 -9910 1900 -9910 {}
L 2 670 -10050 670 -9990 {}
L 2 670 -10040 685 -10040 {}
L 2 685 -10050 685 -10040 {}
L 2 670 -10000 685 -10000 {}
L 2 685 -10000 685 -9990 {}
L 2 660 -10035 660 -10005 {}
L 2 660 -10020 660 -10015 {}
L 2 645 -10020 652.5 -10020 {}
L 2 645 -10020 660 -10020 {}
L 2 675 -10020 685 -10020 {}
L 2 670 -10025 675 -10020 {}
L 2 670 -10015 675 -10020 {}
L 2 685 -10090 685 -10080 {}
L 2 685 -10090 692.5 -10092.5 {}
L 2 677.5 -10097.5 692.5 -10092.5 {}
L 2 677.5 -10097.5 692.5 -10102.5 {}
L 2 677.5 -10107.5 692.5 -10102.5 {}
L 2 677.5 -10107.5 692.5 -10112.5 {}
L 2 677.5 -10117.5 692.5 -10112.5 {}
L 2 677.5 -10117.5 692.5 -10122.5 {}
L 2 677.5 -10127.5 692.5 -10122.5 {}
L 2 677.5 -10127.5 685 -10130 {}
L 2 685 -10140 685 -10130 {}
L 2 687.5 -10132.5 692.5 -10132.5 {}
L 2 690 -10135 690 -10130 {}
L 2 775 -10015 775 -9990 {}
L 2 775 -10050 775 -10025 {}
L 2 765 -10025 785 -10025 {}
L 2 765 -10015 785 -10015 {}
L 2 777.5 -10042.5 782.5 -10042.5 {}
L 2 780 -10045 780 -10040 {}
L 2 685 -10080 685 -10050 {}
L 2 685 -10170 685 -10140 {}
L 2 775 -9990 775 -9910 {}
L 2 685 -10020 685 -9910 {}
L 2 685 -9910 775 -9910 {}
L 2 1572.5 -9982.5 1577.5 -9982.5 {}
L 2 1575 -9985 1575 -9980 {}
L 2 1570 -9990 1570 -9930 {}
L 2 1570 -9930 1570 -9910 {}
L 2 1570 -10170 1570 -9990 {}
L 2 2255 -10050 2255 -9990 {}
L 2 2255 -10040 2270 -10040 {}
L 2 2270 -10050 2270 -10040 {}
L 2 2255 -10000 2270 -10000 {}
L 2 2270 -10000 2270 -9990 {}
L 2 2245 -10035 2245 -10005 {}
L 2 2245 -10020 2245 -10015 {}
L 2 2230 -10020 2237.5 -10020 {}
L 2 2230 -10020 2245 -10020 {}
L 2 2260 -10020 2270 -10020 {}
L 2 2255 -10025 2260 -10020 {}
L 2 2255 -10015 2260 -10020 {}
L 2 2270 -10090 2270 -10080 {}
L 2 2270 -10090 2277.5 -10092.5 {}
L 2 2262.5 -10097.5 2277.5 -10092.5 {}
L 2 2262.5 -10097.5 2277.5 -10102.5 {}
L 2 2262.5 -10107.5 2277.5 -10102.5 {}
L 2 2262.5 -10107.5 2277.5 -10112.5 {}
L 2 2262.5 -10117.5 2277.5 -10112.5 {}
L 2 2262.5 -10117.5 2277.5 -10122.5 {}
L 2 2262.5 -10127.5 2277.5 -10122.5 {}
L 2 2262.5 -10127.5 2270 -10130 {}
L 2 2270 -10140 2270 -10130 {}
L 2 2272.5 -10132.5 2277.5 -10132.5 {}
L 2 2275 -10135 2275 -10130 {}
L 2 2270 -10080 2270 -10050 {}
L 2 2270 -10170 2270 -10140 {}
L 2 2270 -10020 2270 -9910 {}
L 2 2270 -9910 2360 -9910 {}
L 2 2032.5 -9982.5 2037.5 -9982.5 {}
L 2 2035 -9985 2035 -9980 {}
L 2 2030 -9990 2030 -9930 {}
L 2 2030 -9930 2030 -9910 {}
L 2 2030 -10170 2030 -9990 {}
L 2 520 -8030 760 -8030 {}
L 2 1060 -8030 1300 -8030 {}
L 2 2190 -8030 2500 -8100 {}
L 2 1360 -3770 1360 -3760 {}
L 2 1360 -3770 1367.5 -3772.5 {}
L 2 1352.5 -3777.5 1367.5 -3772.5 {}
L 2 1352.5 -3777.5 1367.5 -3782.5 {}
L 2 1352.5 -3787.5 1367.5 -3782.5 {}
L 2 1352.5 -3787.5 1367.5 -3792.5 {}
L 2 1352.5 -3797.5 1367.5 -3792.5 {}
L 2 1352.5 -3797.5 1367.5 -3802.5 {}
L 2 1352.5 -3807.5 1367.5 -3802.5 {}
L 2 1352.5 -3807.5 1360 -3810 {}
L 2 1360 -3820 1360 -3810 {}
L 2 1362.5 -3812.5 1367.5 -3812.5 {}
L 2 1365 -3815 1365 -3810 {}
L 2 1900 -3800 1900 -3760 {}
L 2 1360 -3090 1360 -2990 {}
L 2 1250 -3090 1250 -2990 {}
L 2 1470 -3090 1470 -2990 {}
L 2 1900 -3090 1900 -2990 {}
L 2 1790 -3090 1790 -2990 {}
L 2 2010 -3090 2010 -2990 {}
L 2 2430 -3190 2430 -2990 {}
L 2 2320 -3190 2320 -2990 {}
L 2 2540 -3190 2540 -2990 {}
L 2 1360 -1160 1360 -1060 {}
L 2 1250 -1160 1250 -1060 {}
L 2 1470 -1160 1470 -1060 {}
L 2 1250 -1010 1250 -1000 {}
L 2 1250 -1010 1257.5 -1012.5 {}
L 2 1242.5 -1017.5 1257.5 -1012.5 {}
L 2 1242.5 -1017.5 1257.5 -1022.5 {}
L 2 1242.5 -1027.5 1257.5 -1022.5 {}
L 2 1242.5 -1027.5 1257.5 -1032.5 {}
L 2 1242.5 -1037.5 1257.5 -1032.5 {}
L 2 1242.5 -1037.5 1257.5 -1042.5 {}
L 2 1242.5 -1047.5 1257.5 -1042.5 {}
L 2 1242.5 -1047.5 1250 -1050 {}
L 2 1250 -1060 1250 -1050 {}
L 2 1252.5 -1052.5 1257.5 -1052.5 {}
L 2 1255 -1055 1255 -1050 {}
L 2 1360 -1010 1360 -1000 {}
L 2 1360 -1010 1367.5 -1012.5 {}
L 2 1352.5 -1017.5 1367.5 -1012.5 {}
L 2 1352.5 -1017.5 1367.5 -1022.5 {}
L 2 1352.5 -1027.5 1367.5 -1022.5 {}
L 2 1352.5 -1027.5 1367.5 -1032.5 {}
L 2 1352.5 -1037.5 1367.5 -1032.5 {}
L 2 1352.5 -1037.5 1367.5 -1042.5 {}
L 2 1352.5 -1047.5 1367.5 -1042.5 {}
L 2 1352.5 -1047.5 1360 -1050 {}
L 2 1360 -1060 1360 -1050 {}
L 2 1362.5 -1052.5 1367.5 -1052.5 {}
L 2 1365 -1055 1365 -1050 {}
L 2 1470 -1010 1470 -1000 {}
L 2 1470 -1010 1477.5 -1012.5 {}
L 2 1462.5 -1017.5 1477.5 -1012.5 {}
L 2 1462.5 -1017.5 1477.5 -1022.5 {}
L 2 1462.5 -1027.5 1477.5 -1022.5 {}
L 2 1462.5 -1027.5 1477.5 -1032.5 {}
L 2 1462.5 -1037.5 1477.5 -1032.5 {}
L 2 1462.5 -1037.5 1477.5 -1042.5 {}
L 2 1462.5 -1047.5 1477.5 -1042.5 {}
L 2 1462.5 -1047.5 1470 -1050 {}
L 2 1470 -1060 1470 -1050 {}
L 2 1472.5 -1052.5 1477.5 -1052.5 {}
L 2 1475 -1055 1475 -1050 {}
L 2 1360 -1000 1360 -970 {}
L 2 1250 -1000 1250 -970 {}
L 2 1470 -1000 1470 -970 {}
L 2 1900 -1160 1900 -1110 {}
L 2 1790 -1160 1790 -1110 {}
L 2 2010 -1160 2010 -1110 {}
L 2 1790 -1060 1790 -1050 {}
L 2 1790 -1060 1797.5 -1062.5 {}
L 2 1782.5 -1067.5 1797.5 -1062.5 {}
L 2 1782.5 -1067.5 1797.5 -1072.5 {}
L 2 1782.5 -1077.5 1797.5 -1072.5 {}
L 2 1782.5 -1077.5 1797.5 -1082.5 {}
L 2 1782.5 -1087.5 1797.5 -1082.5 {}
L 2 1782.5 -1087.5 1797.5 -1092.5 {}
L 2 1782.5 -1097.5 1797.5 -1092.5 {}
L 2 1782.5 -1097.5 1790 -1100 {}
L 2 1790 -1110 1790 -1100 {}
L 2 1792.5 -1102.5 1797.5 -1102.5 {}
L 2 1795 -1105 1795 -1100 {}
L 2 1900 -1060 1900 -1050 {}
L 2 1900 -1060 1907.5 -1062.5 {}
L 2 1892.5 -1067.5 1907.5 -1062.5 {}
L 2 1892.5 -1067.5 1907.5 -1072.5 {}
L 2 1892.5 -1077.5 1907.5 -1072.5 {}
L 2 1892.5 -1077.5 1907.5 -1082.5 {}
L 2 1892.5 -1087.5 1907.5 -1082.5 {}
L 2 1892.5 -1087.5 1907.5 -1092.5 {}
L 2 1892.5 -1097.5 1907.5 -1092.5 {}
L 2 1892.5 -1097.5 1900 -1100 {}
L 2 1900 -1110 1900 -1100 {}
L 2 1902.5 -1102.5 1907.5 -1102.5 {}
L 2 1905 -1105 1905 -1100 {}
L 2 2010 -1060 2010 -1050 {}
L 2 2010 -1060 2017.5 -1062.5 {}
L 2 2002.5 -1067.5 2017.5 -1062.5 {}
L 2 2002.5 -1067.5 2017.5 -1072.5 {}
L 2 2002.5 -1077.5 2017.5 -1072.5 {}
L 2 2002.5 -1077.5 2017.5 -1082.5 {}
L 2 2002.5 -1087.5 2017.5 -1082.5 {}
L 2 2002.5 -1087.5 2017.5 -1092.5 {}
L 2 2002.5 -1097.5 2017.5 -1092.5 {}
L 2 2002.5 -1097.5 2010 -1100 {}
L 2 2010 -1110 2010 -1100 {}
L 2 2012.5 -1102.5 2017.5 -1102.5 {}
L 2 2015 -1105 2015 -1100 {}
L 2 1900 -1050 1900 -970 {}
L 2 1790 -1050 1790 -970 {}
L 2 2010 -1050 2010 -970 {}
L 2 635 -2730 635 -2670 {}
L 2 635 -2720 650 -2720 {}
L 2 650 -2730 650 -2720 {}
L 2 635 -2680 650 -2680 {}
L 2 650 -2680 650 -2670 {}
L 2 625 -2715 625 -2685 {}
L 2 625 -2700 625 -2695 {}
L 2 610 -2700 617.5 -2700 {}
L 2 610 -2700 625 -2700 {}
L 2 640 -2700 650 -2700 {}
L 2 635 -2705 640 -2700 {}
L 2 635 -2695 640 -2700 {}
L 2 1215 -2730 1215 -2670 {}
L 2 1215 -2720 1230 -2720 {}
L 2 1230 -2730 1230 -2720 {}
L 2 1215 -2680 1230 -2680 {}
L 2 1230 -2680 1230 -2670 {}
L 2 1205 -2715 1205 -2685 {}
L 2 1205 -2700 1205 -2695 {}
L 2 1190 -2700 1197.5 -2700 {}
L 2 1190 -2700 1205 -2700 {}
L 2 1220 -2700 1230 -2700 {}
L 2 1215 -2705 1220 -2700 {}
L 2 1215 -2695 1220 -2700 {}
L 2 1255 -10050 1255 -9990 {}
L 2 1255 -10040 1270 -10040 {}
L 2 1270 -10050 1270 -10040 {}
L 2 1255 -10000 1270 -10000 {}
L 2 1270 -10000 1270 -9990 {}
L 2 1245 -10035 1245 -10005 {}
L 2 1245 -10020 1245 -10015 {}
L 2 1230 -10020 1237.5 -10020 {}
L 2 1230 -10020 1245 -10020 {}
L 2 1260 -10020 1270 -10020 {}
L 2 1255 -10025 1260 -10020 {}
L 2 1255 -10015 1260 -10020 {}
L 2 1270 -10090 1270 -10080 {}
L 2 1270 -10090 1277.5 -10092.5 {}
L 2 1262.5 -10097.5 1277.5 -10092.5 {}
L 2 1262.5 -10097.5 1277.5 -10102.5 {}
L 2 1262.5 -10107.5 1277.5 -10102.5 {}
L 2 1262.5 -10107.5 1277.5 -10112.5 {}
L 2 1262.5 -10117.5 1277.5 -10112.5 {}
L 2 1262.5 -10117.5 1277.5 -10122.5 {}
L 2 1262.5 -10127.5 1277.5 -10122.5 {}
L 2 1262.5 -10127.5 1270 -10130 {}
L 2 1270 -10140 1270 -10130 {}
L 2 1272.5 -10132.5 1277.5 -10132.5 {}
L 2 1275 -10135 1275 -10130 {}
L 2 1360 -10015 1360 -9990 {}
L 2 1360 -10050 1360 -10025 {}
L 2 1350 -10025 1370 -10025 {}
L 2 1350 -10015 1370 -10015 {}
L 2 1362.5 -10042.5 1367.5 -10042.5 {}
L 2 1365 -10045 1365 -10040 {}
L 2 1270 -10080 1270 -10050 {}
L 2 1270 -10170 1270 -10140 {}
L 2 1360 -9990 1360 -9910 {}
L 2 1270 -10020 1270 -9910 {}
L 2 1270 -9910 1360 -9910 {}
L 2 1360 -780 1360 -680 {}
L 2 1250 -780 1250 -680 {}
L 2 1470 -780 1470 -680 {}
L 2 1250 -630 1250 -620 {}
L 2 1250 -630 1257.5 -632.5 {}
L 2 1242.5 -637.5 1257.5 -632.5 {}
L 2 1242.5 -637.5 1257.5 -642.5 {}
L 2 1242.5 -647.5 1257.5 -642.5 {}
L 2 1242.5 -647.5 1257.5 -652.5 {}
L 2 1242.5 -657.5 1257.5 -652.5 {}
L 2 1242.5 -657.5 1257.5 -662.5 {}
L 2 1242.5 -667.5 1257.5 -662.5 {}
L 2 1242.5 -667.5 1250 -670 {}
L 2 1250 -680 1250 -670 {}
L 2 1252.5 -672.5 1257.5 -672.5 {}
L 2 1255 -675 1255 -670 {}
L 2 1360 -630 1360 -620 {}
L 2 1360 -630 1367.5 -632.5 {}
L 2 1352.5 -637.5 1367.5 -632.5 {}
L 2 1352.5 -637.5 1367.5 -642.5 {}
L 2 1352.5 -647.5 1367.5 -642.5 {}
L 2 1352.5 -647.5 1367.5 -652.5 {}
L 2 1352.5 -657.5 1367.5 -652.5 {}
L 2 1352.5 -657.5 1367.5 -662.5 {}
L 2 1352.5 -667.5 1367.5 -662.5 {}
L 2 1352.5 -667.5 1360 -670 {}
L 2 1360 -680 1360 -670 {}
L 2 1362.5 -672.5 1367.5 -672.5 {}
L 2 1365 -675 1365 -670 {}
L 2 1470 -630 1470 -620 {}
L 2 1470 -630 1477.5 -632.5 {}
L 2 1462.5 -637.5 1477.5 -632.5 {}
L 2 1462.5 -637.5 1477.5 -642.5 {}
L 2 1462.5 -647.5 1477.5 -642.5 {}
L 2 1462.5 -647.5 1477.5 -652.5 {}
L 2 1462.5 -657.5 1477.5 -652.5 {}
L 2 1462.5 -657.5 1477.5 -662.5 {}
L 2 1462.5 -667.5 1477.5 -662.5 {}
L 2 1462.5 -667.5 1470 -670 {}
L 2 1470 -680 1470 -670 {}
L 2 1472.5 -672.5 1477.5 -672.5 {}
L 2 1475 -675 1475 -670 {}
L 2 1900 -780 1900 -730 {}
L 2 1790 -780 1790 -730 {}
L 2 2010 -780 2010 -730 {}
L 2 1790 -680 1790 -670 {}
L 2 1790 -680 1797.5 -682.5 {}
L 2 1782.5 -687.5 1797.5 -682.5 {}
L 2 1782.5 -687.5 1797.5 -692.5 {}
L 2 1782.5 -697.5 1797.5 -692.5 {}
L 2 1782.5 -697.5 1797.5 -702.5 {}
L 2 1782.5 -707.5 1797.5 -702.5 {}
L 2 1782.5 -707.5 1797.5 -712.5 {}
L 2 1782.5 -717.5 1797.5 -712.5 {}
L 2 1782.5 -717.5 1790 -720 {}
L 2 1790 -730 1790 -720 {}
L 2 1792.5 -722.5 1797.5 -722.5 {}
L 2 1795 -725 1795 -720 {}
L 2 1900 -680 1900 -670 {}
L 2 1900 -680 1907.5 -682.5 {}
L 2 1892.5 -687.5 1907.5 -682.5 {}
L 2 1892.5 -687.5 1907.5 -692.5 {}
L 2 1892.5 -697.5 1907.5 -692.5 {}
L 2 1892.5 -697.5 1907.5 -702.5 {}
L 2 1892.5 -707.5 1907.5 -702.5 {}
L 2 1892.5 -707.5 1907.5 -712.5 {}
L 2 1892.5 -717.5 1907.5 -712.5 {}
L 2 1892.5 -717.5 1900 -720 {}
L 2 1900 -730 1900 -720 {}
L 2 1902.5 -722.5 1907.5 -722.5 {}
L 2 1905 -725 1905 -720 {}
L 2 2010 -680 2010 -670 {}
L 2 2010 -680 2017.5 -682.5 {}
L 2 2002.5 -687.5 2017.5 -682.5 {}
L 2 2002.5 -687.5 2017.5 -692.5 {}
L 2 2002.5 -697.5 2017.5 -692.5 {}
L 2 2002.5 -697.5 2017.5 -702.5 {}
L 2 2002.5 -707.5 2017.5 -702.5 {}
L 2 2002.5 -707.5 2017.5 -712.5 {}
L 2 2002.5 -717.5 2017.5 -712.5 {}
L 2 2002.5 -717.5 2010 -720 {}
L 2 2010 -730 2010 -720 {}
L 2 2012.5 -722.5 2017.5 -722.5 {}
L 2 2015 -725 2015 -720 {}
L 2 1900 -670 1900 -590 {}
L 2 1790 -670 1790 -590 {}
L 2 2010 -670 2010 -590 {}
L 2 600 -2450 720 -2450 {}
L 2 1220 -2360 1340 -2360 {}
L 2 740 -2230 740 -2110 {}
L 2 1280 -2200 1280 -2080 {}
L 2 2280 -2120 2410 -2120 {}
L 2 2360 -3610 2440 -3440 {}
L 2 1900 -3610 1900 -3440 {}
L 2 1760 -1400 1880 -1400 {}
L 2 680 -1450 680 -1440 {}
L 2 680 -1450 687.5 -1452.5 {}
L 2 672.5 -1457.5 687.5 -1452.5 {}
L 2 672.5 -1457.5 687.5 -1462.5 {}
L 2 672.5 -1467.5 687.5 -1462.5 {}
L 2 672.5 -1467.5 687.5 -1472.5 {}
L 2 672.5 -1477.5 687.5 -1472.5 {}
L 2 672.5 -1477.5 687.5 -1482.5 {}
L 2 672.5 -1487.5 687.5 -1482.5 {}
L 2 672.5 -1487.5 680 -1490 {}
L 2 680 -1500 680 -1490 {}
L 2 682.5 -1492.5 687.5 -1492.5 {}
L 2 685 -1495 685 -1490 {}
L 2 800 -1450 800 -1440 {}
L 2 800 -1450 807.5 -1452.5 {}
L 2 792.5 -1457.5 807.5 -1452.5 {}
L 2 792.5 -1457.5 807.5 -1462.5 {}
L 2 792.5 -1467.5 807.5 -1462.5 {}
L 2 792.5 -1467.5 807.5 -1472.5 {}
L 2 792.5 -1477.5 807.5 -1472.5 {}
L 2 792.5 -1477.5 807.5 -1482.5 {}
L 2 792.5 -1487.5 807.5 -1482.5 {}
L 2 792.5 -1487.5 800 -1490 {}
L 2 800 -1500 800 -1490 {}
L 2 802.5 -1492.5 807.5 -1492.5 {}
L 2 805 -1495 805 -1490 {}
L 2 1220 -1450 1220 -1440 {}
L 2 1220 -1450 1227.5 -1452.5 {}
L 2 1212.5 -1457.5 1227.5 -1452.5 {}
L 2 1212.5 -1457.5 1227.5 -1462.5 {}
L 2 1212.5 -1467.5 1227.5 -1462.5 {}
L 2 1212.5 -1467.5 1227.5 -1472.5 {}
L 2 1212.5 -1477.5 1227.5 -1472.5 {}
L 2 1212.5 -1477.5 1227.5 -1482.5 {}
L 2 1212.5 -1487.5 1227.5 -1482.5 {}
L 2 1212.5 -1487.5 1220 -1490 {}
L 2 1220 -1500 1220 -1490 {}
L 2 1222.5 -1492.5 1227.5 -1492.5 {}
L 2 1225 -1495 1225 -1490 {}
L 2 1340 -1450 1340 -1440 {}
L 2 1340 -1450 1347.5 -1452.5 {}
L 2 1332.5 -1457.5 1347.5 -1452.5 {}
L 2 1332.5 -1457.5 1347.5 -1462.5 {}
L 2 1332.5 -1467.5 1347.5 -1462.5 {}
L 2 1332.5 -1467.5 1347.5 -1472.5 {}
L 2 1332.5 -1477.5 1347.5 -1472.5 {}
L 2 1332.5 -1477.5 1347.5 -1482.5 {}
L 2 1332.5 -1487.5 1347.5 -1482.5 {}
L 2 1332.5 -1487.5 1340 -1490 {}
L 2 1340 -1500 1340 -1490 {}
L 2 1342.5 -1492.5 1347.5 -1492.5 {}
L 2 1345 -1495 1345 -1490 {}
L 2 1510 -185 1510 -160 {}
L 2 1510 -220 1510 -195 {}
L 2 1500 -195 1520 -195 {}
L 2 1500 -185 1520 -185 {}
L 2 1512.5 -212.5 1517.5 -212.5 {}
L 2 1515 -215 1515 -210 {}
L 2 1510 -160 1510 -80 {}
L 2 1180 -100 1180 -80 {}
L 2 1420 -190 1420 -80 {}
L 2 1420 -80 1510 -80 {}
L 2 1180 -80 1420 -80 {}
L 2 1420 -220 1560 -220 {}
L 2 740 -1800 740 -1680 {}
L 2 1200 -1850 1200 -1730 {}
L 2 2360 -1760 2610 -1760 {}
L 2 2430 -365 2430 -340 {}
L 2 2430 -400 2430 -375 {}
L 2 2420 -375 2440 -375 {}
L 2 2420 -365 2440 -365 {}
L 2 2432.5 -392.5 2437.5 -392.5 {}
L 2 2435 -395 2435 -390 {}
L 2 2430 -340 2430 -260 {}
L 2 2100 -280 2100 -260 {}
L 2 2340 -370 2340 -260 {}
L 2 2340 -260 2430 -260 {}
L 2 2100 -260 2340 -260 {}
L 2 2340 -400 2480 -400 {}
L 2 560 -7630 560 -7520 {}
L 2 1320 -7630 1380 -7630 {}
L 2 850 -4245 850 -4220 {}
L 2 850 -4280 850 -4255 {}
L 2 840 -4255 860 -4255 {}
L 2 840 -4245 860 -4245 {}
L 2 852.5 -4272.5 857.5 -4272.5 {}
L 2 855 -4275 855 -4270 {}
L 2 850 -4220 850 -4140 {}
L 2 1710 -4245 1710 -4220 {}
L 2 1710 -4280 1710 -4255 {}
L 2 1700 -4255 1720 -4255 {}
L 2 1700 -4245 1720 -4245 {}
L 2 1712.5 -4272.5 1717.5 -4272.5 {}
L 2 1715 -4275 1715 -4270 {}
L 2 1710 -4220 1710 -4140 {}
L 2 2470 -4245 2470 -4220 {}
L 2 2470 -4280 2470 -4255 {}
L 2 2460 -4255 2480 -4255 {}
L 2 2460 -4245 2480 -4245 {}
L 2 2472.5 -4272.5 2477.5 -4272.5 {}
L 2 2475 -4275 2475 -4270 {}
L 2 2470 -4220 2470 -4140 {}
L 2 805 -8440 885 -8440 {}
L 2 1330 -8330 1410 -8330 {}
L 2 1830 -8330 1910 -8330 {}
L 2 2260 -8330 2400 -8330 {}
L 2 1850 -7630 1910 -7630 {}
L 2 2150 -7460 2210 -7460 {}
L 2 515 -7270 515 -7210 {}
L 2 515 -7260 530 -7260 {}
L 2 530 -7270 530 -7260 {}
L 2 515 -7220 530 -7220 {}
L 2 530 -7220 530 -7210 {}
L 2 505 -7255 505 -7225 {}
L 2 505 -7240 505 -7235 {}
L 2 490 -7240 497.5 -7240 {}
L 2 490 -7240 505 -7240 {}
L 2 520 -7240 530 -7240 {}
L 2 515 -7245 520 -7240 {}
L 2 515 -7235 520 -7240 {}
L 2 455 -7240 460 -7240 {}
L 2 460 -7240 490 -7240 {}
L 2 530 -7240 530 -7130 {}
L 2 790 -7185 850 -7185 {}
L 2 840 -7185 840 -7170 {}
L 2 840 -7170 850 -7170 {}
L 2 800 -7185 800 -7170 {}
L 2 790 -7170 800 -7170 {}
L 2 805 -7195 835 -7195 {}
L 2 815 -7195 820 -7195 {}
L 2 820 -7210 820 -7202.5 {}
L 2 820 -7210 820 -7195 {}
L 2 820 -7180 820 -7170 {}
L 2 820 -7180 825 -7185 {}
L 2 815 -7185 820 -7180 {}
L 2 820 -7245 820 -7240 {}
L 2 820 -7240 820 -7210 {}
L 2 710 -7170 820 -7170 {}
L 2 1115 -7200 1115 -7140 {}
L 2 1100 -7150 1115 -7150 {}
L 2 1100 -7150 1100 -7140 {}
L 2 1100 -7190 1115 -7190 {}
L 2 1100 -7200 1100 -7190 {}
L 2 1125 -7185 1125 -7155 {}
L 2 1125 -7175 1125 -7170 {}
L 2 1132.5 -7170 1140 -7170 {}
L 2 1125 -7170 1140 -7170 {}
L 2 1100 -7170 1110 -7170 {}
L 2 1110 -7170 1115 -7165 {}
L 2 1110 -7170 1115 -7175 {}
L 2 1170 -7170 1175 -7170 {}
L 2 1140 -7170 1170 -7170 {}
L 2 1100 -7280 1100 -7170 {}
L 2 1380 -7235 1440 -7235 {}
L 2 1390 -7250 1390 -7235 {}
L 2 1380 -7250 1390 -7250 {}
L 2 1430 -7250 1430 -7235 {}
L 2 1430 -7250 1440 -7250 {}
L 2 1395 -7225 1425 -7225 {}
L 2 1410 -7225 1415 -7225 {}
L 2 1410 -7217.5 1410 -7210 {}
L 2 1410 -7225 1410 -7210 {}
L 2 1410 -7250 1410 -7240 {}
L 2 1405 -7235 1410 -7240 {}
L 2 1410 -7240 1415 -7235 {}
L 2 1410 -7180 1410 -7175 {}
L 2 1410 -7210 1410 -7180 {}
L 2 1410 -7250 1520 -7250 {}
L 2 1720 -7235 1780 -7235 {}
L 2 1770 -7250 1770 -7235 {}
L 2 1770 -7250 1780 -7250 {}
L 2 1730 -7250 1730 -7235 {}
L 2 1720 -7250 1730 -7250 {}
L 2 1735 -7225 1765 -7225 {}
L 2 1745 -7225 1750 -7225 {}
L 2 1750 -7217.5 1750 -7210 {}
L 2 1750 -7225 1750 -7210 {}
L 2 1750 -7250 1750 -7240 {}
L 2 1750 -7240 1755 -7235 {}
L 2 1745 -7235 1750 -7240 {}
L 2 1750 -7180 1750 -7175 {}
L 2 1750 -7210 1750 -7180 {}
L 2 1640 -7250 1750 -7250 {}
L 2 2050 -7195 2110 -7195 {}
L 2 2100 -7195 2100 -7180 {}
L 2 2100 -7180 2110 -7180 {}
L 2 2060 -7195 2060 -7180 {}
L 2 2050 -7180 2060 -7180 {}
L 2 2065 -7205 2095 -7205 {}
L 2 2075 -7205 2080 -7205 {}
L 2 2080 -7220 2080 -7212.5 {}
L 2 2080 -7220 2080 -7205 {}
L 2 2080 -7190 2080 -7180 {}
L 2 2080 -7190 2085 -7195 {}
L 2 2075 -7195 2080 -7190 {}
L 2 2080 -7255 2080 -7250 {}
L 2 2080 -7250 2080 -7220 {}
L 2 1970 -7180 2080 -7180 {}
L 2 530 -6890 770 -6890 {}
L 2 755 -6770 755 -6710 {}
L 2 755 -6760 770 -6760 {}
L 2 770 -6770 770 -6760 {}
L 2 755 -6720 770 -6720 {}
L 2 770 -6720 770 -6710 {}
L 2 745 -6755 745 -6725 {}
L 2 745 -6740 745 -6735 {}
L 2 730 -6740 737.5 -6740 {}
L 2 730 -6740 745 -6740 {}
L 2 760 -6740 770 -6740 {}
L 2 755 -6745 760 -6740 {}
L 2 755 -6735 760 -6740 {}
L 2 770 -6810 770 -6800 {}
L 2 770 -6810 777.5 -6812.5 {}
L 2 762.5 -6817.5 777.5 -6812.5 {}
L 2 762.5 -6817.5 777.5 -6822.5 {}
L 2 762.5 -6827.5 777.5 -6822.5 {}
L 2 762.5 -6827.5 777.5 -6832.5 {}
L 2 762.5 -6837.5 777.5 -6832.5 {}
L 2 762.5 -6837.5 777.5 -6842.5 {}
L 2 762.5 -6847.5 777.5 -6842.5 {}
L 2 762.5 -6847.5 770 -6850 {}
L 2 770 -6860 770 -6850 {}
L 2 772.5 -6852.5 777.5 -6852.5 {}
L 2 775 -6855 775 -6850 {}
L 2 860 -6735 860 -6710 {}
L 2 860 -6770 860 -6745 {}
L 2 850 -6745 870 -6745 {}
L 2 850 -6735 870 -6735 {}
L 2 862.5 -6762.5 867.5 -6762.5 {}
L 2 865 -6765 865 -6760 {}
L 2 532.5 -6702.5 537.5 -6702.5 {}
L 2 535 -6705 535 -6700 {}
L 2 530 -6710 530 -6650 {}
L 2 640 -6630 640 -6617.5 {}
L 2 635 -6617.5 645 -6617.5 {}
L 2 640 -6612.5 645 -6617.5 {}
L 2 635 -6617.5 640 -6612.5 {}
L 2 640 -6910 640 -6890 {}
L 2 630 -6910 650 -6910 {}
L 2 605 -6740 610 -6740 {}
L 2 610 -6740 730 -6740 {}
L 2 770 -6800 770 -6770 {}
L 2 770 -6890 770 -6860 {}
L 2 860 -6710 860 -6630 {}
L 2 530 -6650 530 -6630 {}
L 2 530 -6890 530 -6710 {}
L 2 770 -6740 770 -6630 {}
L 2 770 -6630 860 -6630 {}
L 2 530 -6630 770 -6630 {}
L 2 1005 -6890 1245 -6890 {}
L 2 1230 -6770 1230 -6710 {}
L 2 1230 -6760 1245 -6760 {}
L 2 1245 -6770 1245 -6760 {}
L 2 1230 -6720 1245 -6720 {}
L 2 1245 -6720 1245 -6710 {}
L 2 1220 -6755 1220 -6725 {}
L 2 1220 -6740 1220 -6735 {}
L 2 1205 -6740 1212.5 -6740 {}
L 2 1205 -6740 1220 -6740 {}
L 2 1235 -6740 1245 -6740 {}
L 2 1230 -6745 1235 -6740 {}
L 2 1230 -6735 1235 -6740 {}
L 2 1245 -6810 1245 -6800 {}
L 2 1245 -6810 1252.5 -6812.5 {}
L 2 1237.5 -6817.5 1252.5 -6812.5 {}
L 2 1237.5 -6817.5 1252.5 -6822.5 {}
L 2 1237.5 -6827.5 1252.5 -6822.5 {}
L 2 1237.5 -6827.5 1252.5 -6832.5 {}
L 2 1237.5 -6837.5 1252.5 -6832.5 {}
L 2 1237.5 -6837.5 1252.5 -6842.5 {}
L 2 1237.5 -6847.5 1252.5 -6842.5 {}
L 2 1237.5 -6847.5 1245 -6850 {}
L 2 1245 -6860 1245 -6850 {}
L 2 1247.5 -6852.5 1252.5 -6852.5 {}
L 2 1250 -6855 1250 -6850 {}
L 2 1335 -6735 1335 -6710 {}
L 2 1335 -6770 1335 -6745 {}
L 2 1325 -6745 1345 -6745 {}
L 2 1325 -6735 1345 -6735 {}
L 2 1337.5 -6762.5 1342.5 -6762.5 {}
L 2 1340 -6765 1340 -6760 {}
L 2 1007.5 -6702.5 1012.5 -6702.5 {}
L 2 1010 -6705 1010 -6700 {}
L 2 1005 -6710 1005 -6650 {}
L 2 1115 -6630 1115 -6617.5 {}
L 2 1110 -6617.5 1120 -6617.5 {}
L 2 1115 -6612.5 1120 -6617.5 {}
L 2 1110 -6617.5 1115 -6612.5 {}
L 2 1115 -6910 1115 -6890 {}
L 2 1105 -6910 1125 -6910 {}
L 2 1080 -6740 1085 -6740 {}
L 2 1085 -6740 1205 -6740 {}
L 2 1245 -6800 1245 -6770 {}
L 2 1245 -6890 1245 -6860 {}
L 2 1335 -6710 1335 -6630 {}
L 2 1005 -6650 1005 -6630 {}
L 2 1005 -6890 1005 -6710 {}
L 2 1245 -6740 1245 -6630 {}
L 2 1245 -6630 1335 -6630 {}
L 2 1005 -6630 1245 -6630 {}
L 2 1850 -6890 1850 -6650 {}
L 2 1670 -6665 1730 -6665 {}
L 2 1720 -6665 1720 -6650 {}
L 2 1720 -6650 1730 -6650 {}
L 2 1680 -6665 1680 -6650 {}
L 2 1670 -6650 1680 -6650 {}
L 2 1685 -6675 1715 -6675 {}
L 2 1695 -6675 1700 -6675 {}
L 2 1700 -6690 1700 -6682.5 {}
L 2 1700 -6690 1700 -6675 {}
L 2 1700 -6660 1700 -6650 {}
L 2 1700 -6660 1705 -6665 {}
L 2 1695 -6665 1700 -6660 {}
L 2 1760 -6650 1770 -6650 {}
L 2 1770 -6650 1772.5 -6642.5 {}
L 2 1772.5 -6642.5 1777.5 -6657.5 {}
L 2 1777.5 -6657.5 1782.5 -6642.5 {}
L 2 1782.5 -6642.5 1787.5 -6657.5 {}
L 2 1787.5 -6657.5 1792.5 -6642.5 {}
L 2 1792.5 -6642.5 1797.5 -6657.5 {}
L 2 1797.5 -6657.5 1802.5 -6642.5 {}
L 2 1802.5 -6642.5 1807.5 -6657.5 {}
L 2 1807.5 -6657.5 1810 -6650 {}
L 2 1810 -6650 1820 -6650 {}
L 2 1812.5 -6647.5 1812.5 -6642.5 {}
L 2 1810 -6645 1815 -6645 {}
L 2 1670 -6560 1695 -6560 {}
L 2 1705 -6560 1730 -6560 {}
L 2 1705 -6570 1705 -6550 {}
L 2 1695 -6570 1695 -6550 {}
L 2 1722.5 -6557.5 1722.5 -6552.5 {}
L 2 1720 -6555 1725 -6555 {}
L 2 1662.5 -6887.5 1662.5 -6882.5 {}
L 2 1660 -6885 1665 -6885 {}
L 2 1610 -6890 1670 -6890 {}
L 2 1577.5 -6780 1590 -6780 {}
L 2 1577.5 -6785 1577.5 -6775 {}
L 2 1572.5 -6780 1577.5 -6775 {}
L 2 1572.5 -6780 1577.5 -6785 {}
L 2 1850 -6780 1870 -6780 {}
L 2 1870 -6790 1870 -6770 {}
L 2 1700 -6815 1700 -6810 {}
L 2 1700 -6810 1700 -6690 {}
L 2 1730 -6650 1760 -6650 {}
L 2 1820 -6650 1850 -6650 {}
L 2 1590 -6560 1670 -6560 {}
L 2 1590 -6890 1610 -6890 {}
L 2 1670 -6890 1850 -6890 {}
L 2 1590 -6650 1700 -6650 {}
L 2 1590 -6650 1590 -6560 {}
L 2 1590 -6890 1590 -6650 {}
L 2 530 -6460 770 -6460 {}
L 2 755 -6340 755 -6280 {}
L 2 755 -6330 770 -6330 {}
L 2 770 -6340 770 -6330 {}
L 2 755 -6290 770 -6290 {}
L 2 770 -6290 770 -6280 {}
L 2 745 -6325 745 -6295 {}
L 2 745 -6310 745 -6305 {}
L 2 730 -6310 737.5 -6310 {}
L 2 730 -6310 745 -6310 {}
L 2 760 -6310 770 -6310 {}
L 2 755 -6315 760 -6310 {}
L 2 755 -6305 760 -6310 {}
L 2 770 -6380 770 -6370 {}
L 2 770 -6380 777.5 -6382.5 {}
L 2 762.5 -6387.5 777.5 -6382.5 {}
L 2 762.5 -6387.5 777.5 -6392.5 {}
L 2 762.5 -6397.5 777.5 -6392.5 {}
L 2 762.5 -6397.5 777.5 -6402.5 {}
L 2 762.5 -6407.5 777.5 -6402.5 {}
L 2 762.5 -6407.5 777.5 -6412.5 {}
L 2 762.5 -6417.5 777.5 -6412.5 {}
L 2 762.5 -6417.5 770 -6420 {}
L 2 770 -6430 770 -6420 {}
L 2 772.5 -6422.5 777.5 -6422.5 {}
L 2 775 -6425 775 -6420 {}
L 2 860 -6305 860 -6280 {}
L 2 860 -6340 860 -6315 {}
L 2 850 -6315 870 -6315 {}
L 2 850 -6305 870 -6305 {}
L 2 862.5 -6332.5 867.5 -6332.5 {}
L 2 865 -6335 865 -6330 {}
L 2 532.5 -6272.5 537.5 -6272.5 {}
L 2 535 -6275 535 -6270 {}
L 2 530 -6280 530 -6220 {}
L 2 640 -6200 640 -6187.5 {}
L 2 635 -6187.5 645 -6187.5 {}
L 2 640 -6182.5 645 -6187.5 {}
L 2 635 -6187.5 640 -6182.5 {}
L 2 640 -6480 640 -6460 {}
L 2 630 -6480 650 -6480 {}
L 2 605 -6310 610 -6310 {}
L 2 610 -6310 730 -6310 {}
L 2 770 -6370 770 -6340 {}
L 2 770 -6460 770 -6430 {}
L 2 860 -6280 860 -6200 {}
L 2 530 -6220 530 -6200 {}
L 2 530 -6460 530 -6280 {}
L 2 770 -6310 770 -6200 {}
L 2 770 -6200 860 -6200 {}
L 2 530 -6200 770 -6200 {}
L 2 980 -6460 1220 -6460 {}
L 2 1205 -6340 1205 -6280 {}
L 2 1205 -6330 1220 -6330 {}
L 2 1220 -6340 1220 -6330 {}
L 2 1205 -6290 1220 -6290 {}
L 2 1220 -6290 1220 -6280 {}
L 2 1195 -6325 1195 -6295 {}
L 2 1195 -6310 1195 -6305 {}
L 2 1180 -6310 1187.5 -6310 {}
L 2 1180 -6310 1195 -6310 {}
L 2 1210 -6310 1220 -6310 {}
L 2 1205 -6315 1210 -6310 {}
L 2 1205 -6305 1210 -6310 {}
L 2 1220 -6380 1220 -6370 {}
L 2 1220 -6380 1227.5 -6382.5 {}
L 2 1212.5 -6387.5 1227.5 -6382.5 {}
L 2 1212.5 -6387.5 1227.5 -6392.5 {}
L 2 1212.5 -6397.5 1227.5 -6392.5 {}
L 2 1212.5 -6397.5 1227.5 -6402.5 {}
L 2 1212.5 -6407.5 1227.5 -6402.5 {}
L 2 1212.5 -6407.5 1227.5 -6412.5 {}
L 2 1212.5 -6417.5 1227.5 -6412.5 {}
L 2 1212.5 -6417.5 1220 -6420 {}
L 2 1220 -6430 1220 -6420 {}
L 2 1222.5 -6422.5 1227.5 -6422.5 {}
L 2 1225 -6425 1225 -6420 {}
L 2 1310 -6305 1310 -6280 {}
L 2 1310 -6340 1310 -6315 {}
L 2 1300 -6315 1320 -6315 {}
L 2 1300 -6305 1320 -6305 {}
L 2 1312.5 -6332.5 1317.5 -6332.5 {}
L 2 1315 -6335 1315 -6330 {}
L 2 982.5 -6272.5 987.5 -6272.5 {}
L 2 985 -6275 985 -6270 {}
L 2 980 -6280 980 -6220 {}
L 2 1090 -6200 1090 -6187.5 {}
L 2 1085 -6187.5 1095 -6187.5 {}
L 2 1090 -6182.5 1095 -6187.5 {}
L 2 1085 -6187.5 1090 -6182.5 {}
L 2 1090 -6480 1090 -6460 {}
L 2 1080 -6480 1100 -6480 {}
L 2 1055 -6310 1060 -6310 {}
L 2 1060 -6310 1180 -6310 {}
L 2 1220 -6370 1220 -6340 {}
L 2 1220 -6460 1220 -6430 {}
L 2 1310 -6280 1310 -6200 {}
L 2 980 -6220 980 -6200 {}
L 2 980 -6460 980 -6280 {}
L 2 1220 -6310 1220 -6200 {}
L 2 1220 -6200 1310 -6200 {}
L 2 980 -6200 1220 -6200 {}
L 2 1600 -6460 1840 -6460 {}
L 2 1615 -6340 1615 -6280 {}
L 2 1600 -6330 1615 -6330 {}
L 2 1600 -6340 1600 -6330 {}
L 2 1600 -6290 1615 -6290 {}
L 2 1600 -6290 1600 -6280 {}
L 2 1625 -6325 1625 -6295 {}
L 2 1625 -6310 1625 -6305 {}
L 2 1632.5 -6310 1640 -6310 {}
L 2 1625 -6310 1640 -6310 {}
L 2 1600 -6310 1610 -6310 {}
L 2 1610 -6310 1615 -6315 {}
L 2 1610 -6310 1615 -6305 {}
L 2 1600 -6380 1600 -6370 {}
L 2 1592.5 -6382.5 1600 -6380 {}
L 2 1592.5 -6382.5 1607.5 -6387.5 {}
L 2 1592.5 -6392.5 1607.5 -6387.5 {}
L 2 1592.5 -6392.5 1607.5 -6397.5 {}
L 2 1592.5 -6402.5 1607.5 -6397.5 {}
L 2 1592.5 -6402.5 1607.5 -6407.5 {}
L 2 1592.5 -6412.5 1607.5 -6407.5 {}
L 2 1592.5 -6412.5 1607.5 -6417.5 {}
L 2 1600 -6420 1607.5 -6417.5 {}
L 2 1600 -6430 1600 -6420 {}
L 2 1592.5 -6422.5 1597.5 -6422.5 {}
L 2 1595 -6425 1595 -6420 {}
L 2 1510 -6305 1510 -6280 {}
L 2 1510 -6340 1510 -6315 {}
L 2 1500 -6315 1520 -6315 {}
L 2 1500 -6305 1520 -6305 {}
L 2 1502.5 -6332.5 1507.5 -6332.5 {}
L 2 1505 -6335 1505 -6330 {}
L 2 1832.5 -6272.5 1837.5 -6272.5 {}
L 2 1835 -6275 1835 -6270 {}
L 2 1840 -6280 1840 -6220 {}
L 2 1730 -6200 1730 -6187.5 {}
L 2 1725 -6187.5 1735 -6187.5 {}
L 2 1725 -6187.5 1730 -6182.5 {}
L 2 1730 -6182.5 1735 -6187.5 {}
L 2 1730 -6480 1730 -6460 {}
L 2 1720 -6480 1740 -6480 {}
L 2 1760 -6310 1765 -6310 {}
L 2 1640 -6310 1760 -6310 {}
L 2 1600 -6370 1600 -6340 {}
L 2 1600 -6460 1600 -6430 {}
L 2 1510 -6280 1510 -6200 {}
L 2 1840 -6220 1840 -6200 {}
L 2 1840 -6460 1840 -6280 {}
L 2 1600 -6310 1600 -6200 {}
L 2 1510 -6200 1600 -6200 {}
L 2 1600 -6200 1840 -6200 {}
L 2 610 -6030 610 -6020 {}
L 2 610 -6030 617.5 -6032.5 {}
L 2 602.5 -6037.5 617.5 -6032.5 {}
L 2 602.5 -6037.5 617.5 -6042.5 {}
L 2 602.5 -6047.5 617.5 -6042.5 {}
L 2 602.5 -6047.5 617.5 -6052.5 {}
L 2 602.5 -6057.5 617.5 -6052.5 {}
L 2 602.5 -6057.5 617.5 -6062.5 {}
L 2 602.5 -6067.5 617.5 -6062.5 {}
L 2 602.5 -6067.5 610 -6070 {}
L 2 610 -6080 610 -6070 {}
L 2 612.5 -6072.5 617.5 -6072.5 {}
L 2 615 -6075 615 -6070 {}
L 2 610 -5915 610 -5890 {}
L 2 610 -5950 610 -5925 {}
L 2 600 -5925 620 -5925 {}
L 2 600 -5915 620 -5915 {}
L 2 612.5 -5942.5 617.5 -5942.5 {}
L 2 615 -5945 615 -5940 {}
L 2 610 -5790 610 -5780 {}
L 2 610 -5790 617.5 -5792.5 {}
L 2 602.5 -5797.5 617.5 -5792.5 {}
L 2 602.5 -5797.5 617.5 -5802.5 {}
L 2 602.5 -5807.5 617.5 -5802.5 {}
L 2 602.5 -5807.5 617.5 -5812.5 {}
L 2 602.5 -5817.5 617.5 -5812.5 {}
L 2 602.5 -5817.5 617.5 -5822.5 {}
L 2 602.5 -5827.5 617.5 -5822.5 {}
L 2 602.5 -5827.5 610 -5830 {}
L 2 610 -5840 610 -5830 {}
L 2 612.5 -5832.5 617.5 -5832.5 {}
L 2 615 -5835 615 -5830 {}
L 2 900 -6050 910 -6050 {}
L 2 910 -6050 912.5 -6042.5 {}
L 2 912.5 -6042.5 917.5 -6057.5 {}
L 2 917.5 -6057.5 922.5 -6042.5 {}
L 2 922.5 -6042.5 927.5 -6057.5 {}
L 2 927.5 -6057.5 932.5 -6042.5 {}
L 2 932.5 -6042.5 937.5 -6057.5 {}
L 2 937.5 -6057.5 942.5 -6042.5 {}
L 2 942.5 -6042.5 947.5 -6057.5 {}
L 2 947.5 -6057.5 950 -6050 {}
L 2 950 -6050 960 -6050 {}
L 2 952.5 -6047.5 952.5 -6042.5 {}
L 2 950 -6045 955 -6045 {}
L 2 900 -5920 925 -5920 {}
L 2 935 -5920 960 -5920 {}
L 2 935 -5930 935 -5910 {}
L 2 925 -5930 925 -5910 {}
L 2 952.5 -5917.5 952.5 -5912.5 {}
L 2 950 -5915 955 -5915 {}
L 2 900 -5810 910 -5810 {}
L 2 910 -5810 912.5 -5802.5 {}
L 2 912.5 -5802.5 917.5 -5817.5 {}
L 2 917.5 -5817.5 922.5 -5802.5 {}
L 2 922.5 -5802.5 927.5 -5817.5 {}
L 2 927.5 -5817.5 932.5 -5802.5 {}
L 2 932.5 -5802.5 937.5 -5817.5 {}
L 2 937.5 -5817.5 942.5 -5802.5 {}
L 2 942.5 -5802.5 947.5 -5817.5 {}
L 2 947.5 -5817.5 950 -5810 {}
L 2 950 -5810 960 -5810 {}
L 2 952.5 -5807.5 952.5 -5802.5 {}
L 2 950 -5805 955 -5805 {}
L 2 2360 -7460 2420 -7460 {}
L 2 2420 -7630 2420 -7520 {}
L 4 1032.5 -9512.5 1037.5 -9512.5 {}
L 4 1035 -9515 1035 -9510 {}
L 4 1030 -9520 1030 -9460 {}
L 4 1140 -9440 1140 -9427.5 {}
L 4 1135 -9427.5 1145 -9427.5 {}
L 4 1140 -9422.5 1145 -9427.5 {}
L 4 1135 -9427.5 1140 -9422.5 {}
L 4 1140 -9720 1140 -9700 {}
L 4 1130 -9720 1150 -9720 {}
L 4 1572.5 -9512.5 1577.5 -9512.5 {}
L 4 1575 -9515 1575 -9510 {}
L 4 1570 -9520 1570 -9460 {}
L 4 1680 -9440 1680 -9427.5 {}
L 4 1675 -9427.5 1685 -9427.5 {}
L 4 1680 -9422.5 1685 -9427.5 {}
L 4 1675 -9427.5 1680 -9422.5 {}
L 4 1680 -9720 1680 -9700 {}
L 4 1670 -9720 1690 -9720 {}
L 4 502.5 -9512.5 507.5 -9512.5 {}
L 4 505 -9515 505 -9510 {}
L 4 500 -9520 500 -9460 {}
L 4 610 -9440 610 -9427.5 {}
L 4 605 -9427.5 615 -9427.5 {}
L 4 610 -9422.5 615 -9427.5 {}
L 4 605 -9427.5 610 -9422.5 {}
L 4 610 -9720 610 -9700 {}
L 4 600 -9720 620 -9720 {}
L 4 725 -9120 725 -9060 {}
L 4 725 -9110 740 -9110 {}
L 4 740 -9120 740 -9110 {}
L 4 725 -9070 740 -9070 {}
L 4 740 -9070 740 -9060 {}
L 4 715 -9105 715 -9075 {}
L 4 715 -9090 715 -9085 {}
L 4 700 -9090 707.5 -9090 {}
L 4 700 -9090 715 -9090 {}
L 4 730 -9090 740 -9090 {}
L 4 725 -9095 730 -9090 {}
L 4 725 -9085 730 -9090 {}
L 4 740 -9160 740 -9150 {}
L 4 740 -9160 747.5 -9162.5 {}
L 4 732.5 -9167.5 747.5 -9162.5 {}
L 4 732.5 -9167.5 747.5 -9172.5 {}
L 4 732.5 -9177.5 747.5 -9172.5 {}
L 4 732.5 -9177.5 747.5 -9182.5 {}
L 4 732.5 -9187.5 747.5 -9182.5 {}
L 4 732.5 -9187.5 747.5 -9192.5 {}
L 4 732.5 -9197.5 747.5 -9192.5 {}
L 4 732.5 -9197.5 740 -9200 {}
L 4 740 -9210 740 -9200 {}
L 4 742.5 -9202.5 747.5 -9202.5 {}
L 4 745 -9205 745 -9200 {}
L 4 830 -9085 830 -9060 {}
L 4 830 -9120 830 -9095 {}
L 4 820 -9095 840 -9095 {}
L 4 820 -9085 840 -9085 {}
L 4 832.5 -9112.5 837.5 -9112.5 {}
L 4 835 -9115 835 -9110 {}
L 4 502.5 -9052.5 507.5 -9052.5 {}
L 4 505 -9055 505 -9050 {}
L 4 500 -9060 500 -9000 {}
L 4 610 -8980 610 -8967.5 {}
L 4 605 -8967.5 615 -8967.5 {}
L 4 610 -8962.5 615 -8967.5 {}
L 4 605 -8967.5 610 -8962.5 {}
L 4 610 -9260 610 -9240 {}
L 4 600 -9260 620 -9260 {}
L 4 1265 -9120 1265 -9060 {}
L 4 1265 -9110 1280 -9110 {}
L 4 1280 -9120 1280 -9110 {}
L 4 1265 -9070 1280 -9070 {}
L 4 1280 -9070 1280 -9060 {}
L 4 1255 -9105 1255 -9075 {}
L 4 1255 -9090 1255 -9085 {}
L 4 1240 -9090 1247.5 -9090 {}
L 4 1240 -9090 1255 -9090 {}
L 4 1270 -9090 1280 -9090 {}
L 4 1265 -9095 1270 -9090 {}
L 4 1265 -9085 1270 -9090 {}
L 4 1370 -9085 1370 -9060 {}
L 4 1370 -9120 1370 -9095 {}
L 4 1360 -9095 1380 -9095 {}
L 4 1360 -9085 1380 -9085 {}
L 4 1372.5 -9112.5 1377.5 -9112.5 {}
L 4 1375 -9115 1375 -9110 {}
L 4 1042.5 -9052.5 1047.5 -9052.5 {}
L 4 1045 -9055 1045 -9050 {}
L 4 1040 -9060 1040 -9000 {}
L 4 1150 -8980 1150 -8967.5 {}
L 4 1145 -8967.5 1155 -8967.5 {}
L 4 1150 -8962.5 1155 -8967.5 {}
L 4 1145 -8967.5 1150 -8962.5 {}
L 4 1150 -9260 1150 -9240 {}
L 4 1140 -9260 1160 -9260 {}
L 4 725 -5530 725 -5470 {}
L 4 725 -5520 740 -5520 {}
L 4 740 -5530 740 -5520 {}
L 4 725 -5480 740 -5480 {}
L 4 740 -5480 740 -5470 {}
L 4 715 -5515 715 -5485 {}
L 4 715 -5500 715 -5495 {}
L 4 700 -5500 707.5 -5500 {}
L 4 700 -5500 715 -5500 {}
L 4 730 -5500 740 -5500 {}
L 4 725 -5505 730 -5500 {}
L 4 725 -5495 730 -5500 {}
L 4 740 -5570 740 -5560 {}
L 4 740 -5570 747.5 -5572.5 {}
L 4 732.5 -5577.5 747.5 -5572.5 {}
L 4 732.5 -5577.5 747.5 -5582.5 {}
L 4 732.5 -5587.5 747.5 -5582.5 {}
L 4 732.5 -5587.5 747.5 -5592.5 {}
L 4 732.5 -5597.5 747.5 -5592.5 {}
L 4 732.5 -5597.5 747.5 -5602.5 {}
L 4 732.5 -5607.5 747.5 -5602.5 {}
L 4 732.5 -5607.5 740 -5610 {}
L 4 740 -5620 740 -5610 {}
L 4 742.5 -5612.5 747.5 -5612.5 {}
L 4 745 -5615 745 -5610 {}
L 4 830 -5495 830 -5470 {}
L 4 830 -5530 830 -5505 {}
L 4 820 -5505 840 -5505 {}
L 4 820 -5495 840 -5495 {}
L 4 832.5 -5522.5 837.5 -5522.5 {}
L 4 835 -5525 835 -5520 {}
L 4 502.5 -5462.5 507.5 -5462.5 {}
L 4 505 -5465 505 -5460 {}
L 4 500 -5470 500 -5410 {}
L 4 610 -5390 610 -5377.5 {}
L 4 605 -5377.5 615 -5377.5 {}
L 4 610 -5372.5 615 -5377.5 {}
L 4 605 -5377.5 610 -5372.5 {}
L 4 610 -5670 610 -5650 {}
L 4 600 -5670 620 -5670 {}
L 4 1265 -5530 1265 -5470 {}
L 4 1265 -5520 1280 -5520 {}
L 4 1280 -5530 1280 -5520 {}
L 4 1265 -5480 1280 -5480 {}
L 4 1280 -5480 1280 -5470 {}
L 4 1255 -5515 1255 -5485 {}
L 4 1255 -5500 1255 -5495 {}
L 4 1240 -5500 1247.5 -5500 {}
L 4 1240 -5500 1255 -5500 {}
L 4 1270 -5500 1280 -5500 {}
L 4 1265 -5505 1270 -5500 {}
L 4 1265 -5495 1270 -5500 {}
L 4 1370 -5495 1370 -5470 {}
L 4 1370 -5530 1370 -5505 {}
L 4 1360 -5505 1380 -5505 {}
L 4 1360 -5495 1380 -5495 {}
L 4 1372.5 -5522.5 1377.5 -5522.5 {}
L 4 1375 -5525 1375 -5520 {}
L 4 1042.5 -5462.5 1047.5 -5462.5 {}
L 4 1045 -5465 1045 -5460 {}
L 4 1040 -5470 1040 -5410 {}
L 4 1150 -5390 1150 -5377.5 {}
L 4 1145 -5377.5 1155 -5377.5 {}
L 4 1150 -5372.5 1155 -5377.5 {}
L 4 1145 -5377.5 1150 -5372.5 {}
L 4 1150 -5670 1150 -5650 {}
L 4 1140 -5670 1160 -5670 {}
L 4 725 -5130 725 -5070 {}
L 4 725 -5120 740 -5120 {}
L 4 740 -5130 740 -5120 {}
L 4 725 -5080 740 -5080 {}
L 4 740 -5080 740 -5070 {}
L 4 715 -5115 715 -5085 {}
L 4 715 -5100 715 -5095 {}
L 4 700 -5100 707.5 -5100 {}
L 4 700 -5100 715 -5100 {}
L 4 730 -5100 740 -5100 {}
L 4 725 -5105 730 -5100 {}
L 4 725 -5095 730 -5100 {}
L 4 740 -5170 740 -5160 {}
L 4 740 -5170 747.5 -5172.5 {}
L 4 732.5 -5177.5 747.5 -5172.5 {}
L 4 732.5 -5177.5 747.5 -5182.5 {}
L 4 732.5 -5187.5 747.5 -5182.5 {}
L 4 732.5 -5187.5 747.5 -5192.5 {}
L 4 732.5 -5197.5 747.5 -5192.5 {}
L 4 732.5 -5197.5 747.5 -5202.5 {}
L 4 732.5 -5207.5 747.5 -5202.5 {}
L 4 732.5 -5207.5 740 -5210 {}
L 4 740 -5220 740 -5210 {}
L 4 742.5 -5212.5 747.5 -5212.5 {}
L 4 745 -5215 745 -5210 {}
L 4 830 -5095 830 -5070 {}
L 4 830 -5130 830 -5105 {}
L 4 820 -5105 840 -5105 {}
L 4 820 -5095 840 -5095 {}
L 4 832.5 -5122.5 837.5 -5122.5 {}
L 4 835 -5125 835 -5120 {}
L 4 502.5 -5062.5 507.5 -5062.5 {}
L 4 505 -5065 505 -5060 {}
L 4 500 -5070 500 -5010 {}
L 4 610 -4990 610 -4977.5 {}
L 4 605 -4977.5 615 -4977.5 {}
L 4 610 -4972.5 615 -4977.5 {}
L 4 605 -4977.5 610 -4972.5 {}
L 4 610 -5270 610 -5250 {}
L 4 600 -5270 620 -5270 {}
L 4 1265 -5130 1265 -5070 {}
L 4 1265 -5120 1280 -5120 {}
L 4 1280 -5130 1280 -5120 {}
L 4 1265 -5080 1280 -5080 {}
L 4 1280 -5080 1280 -5070 {}
L 4 1255 -5115 1255 -5085 {}
L 4 1255 -5100 1255 -5095 {}
L 4 1240 -5100 1247.5 -5100 {}
L 4 1240 -5100 1255 -5100 {}
L 4 1270 -5100 1280 -5100 {}
L 4 1265 -5105 1270 -5100 {}
L 4 1265 -5095 1270 -5100 {}
L 4 1370 -5095 1370 -5070 {}
L 4 1370 -5130 1370 -5105 {}
L 4 1360 -5105 1380 -5105 {}
L 4 1360 -5095 1380 -5095 {}
L 4 1372.5 -5122.5 1377.5 -5122.5 {}
L 4 1375 -5125 1375 -5120 {}
L 4 1042.5 -5062.5 1047.5 -5062.5 {}
L 4 1045 -5065 1045 -5060 {}
L 4 1040 -5070 1040 -5010 {}
L 4 1150 -4990 1150 -4977.5 {}
L 4 1145 -4977.5 1155 -4977.5 {}
L 4 1150 -4972.5 1155 -4977.5 {}
L 4 1145 -4977.5 1150 -4972.5 {}
L 4 1150 -5270 1150 -5250 {}
L 4 1140 -5270 1160 -5270 {}
L 4 502.5 -4622.5 507.5 -4622.5 {}
L 4 505 -4625 505 -4620 {}
L 4 500 -4630 500 -4570 {}
L 4 610 -4550 610 -4537.5 {}
L 4 605 -4537.5 615 -4537.5 {}
L 4 610 -4532.5 615 -4537.5 {}
L 4 605 -4537.5 610 -4532.5 {}
L 4 610 -4830 610 -4810 {}
L 4 600 -4830 620 -4830 {}
L 4 1692.5 -4622.5 1697.5 -4622.5 {}
L 4 1695 -4625 1695 -4620 {}
L 4 1690 -4630 1690 -4570 {}
L 4 1800 -4550 1800 -4537.5 {}
L 4 1795 -4537.5 1805 -4537.5 {}
L 4 1800 -4532.5 1805 -4537.5 {}
L 4 1795 -4537.5 1800 -4532.5 {}
L 4 1800 -4830 1800 -4810 {}
L 4 1790 -4830 1810 -4830 {}
L 4 1062.5 -4622.5 1067.5 -4622.5 {}
L 4 1065 -4625 1065 -4620 {}
L 4 1060 -4630 1060 -4570 {}
L 4 1170 -4550 1170 -4537.5 {}
L 4 1165 -4537.5 1175 -4537.5 {}
L 4 1170 -4532.5 1175 -4537.5 {}
L 4 1165 -4537.5 1170 -4532.5 {}
L 4 1170 -4830 1170 -4810 {}
L 4 1160 -4830 1180 -4830 {}
L 4 1032.5 -8682.5 1037.5 -8682.5 {}
L 4 1035 -8685 1035 -8680 {}
L 4 1030 -8690 1030 -8630 {}
L 4 1140 -8610 1140 -8597.5 {}
L 4 1135 -8597.5 1145 -8597.5 {}
L 4 1140 -8592.5 1145 -8597.5 {}
L 4 1135 -8597.5 1140 -8592.5 {}
L 4 1140 -8890 1140 -8870 {}
L 4 1130 -8890 1150 -8890 {}
L 4 502.5 -8682.5 507.5 -8682.5 {}
L 4 505 -8685 505 -8680 {}
L 4 500 -8690 500 -8630 {}
L 4 610 -8610 610 -8597.5 {}
L 4 605 -8597.5 615 -8597.5 {}
L 4 610 -8592.5 615 -8597.5 {}
L 4 605 -8597.5 610 -8592.5 {}
L 4 610 -8890 610 -8870 {}
L 4 600 -8890 620 -8890 {}
L 4 1755 -8750 1755 -8690 {}
L 4 1755 -8740 1770 -8740 {}
L 4 1770 -8750 1770 -8740 {}
L 4 1755 -8700 1770 -8700 {}
L 4 1770 -8700 1770 -8690 {}
L 4 1745 -8735 1745 -8705 {}
L 4 1745 -8720 1745 -8715 {}
L 4 1730 -8720 1737.5 -8720 {}
L 4 1730 -8720 1745 -8720 {}
L 4 1760 -8720 1770 -8720 {}
L 4 1755 -8725 1760 -8720 {}
L 4 1755 -8715 1760 -8720 {}
L 4 1770 -8790 1770 -8780 {}
L 4 1770 -8790 1777.5 -8792.5 {}
L 4 1762.5 -8797.5 1777.5 -8792.5 {}
L 4 1762.5 -8797.5 1777.5 -8802.5 {}
L 4 1762.5 -8807.5 1777.5 -8802.5 {}
L 4 1762.5 -8807.5 1777.5 -8812.5 {}
L 4 1762.5 -8817.5 1777.5 -8812.5 {}
L 4 1762.5 -8817.5 1777.5 -8822.5 {}
L 4 1762.5 -8827.5 1777.5 -8822.5 {}
L 4 1762.5 -8827.5 1770 -8830 {}
L 4 1770 -8840 1770 -8830 {}
L 4 1772.5 -8832.5 1777.5 -8832.5 {}
L 4 1775 -8835 1775 -8830 {}
L 4 1860 -8715 1860 -8690 {}
L 4 1860 -8750 1860 -8725 {}
L 4 1850 -8725 1870 -8725 {}
L 4 1850 -8715 1870 -8715 {}
L 4 1862.5 -8742.5 1867.5 -8742.5 {}
L 4 1865 -8745 1865 -8740 {}
L 4 1532.5 -8682.5 1537.5 -8682.5 {}
L 4 1535 -8685 1535 -8680 {}
L 4 1530 -8690 1530 -8630 {}
L 4 1640 -8610 1640 -8597.5 {}
L 4 1635 -8597.5 1645 -8597.5 {}
L 4 1640 -8592.5 1645 -8597.5 {}
L 4 1635 -8597.5 1640 -8592.5 {}
L 4 1640 -8890 1640 -8870 {}
L 4 1630 -8890 1650 -8890 {}
L 4 1680 -9910 1680 -9897.5 {}
L 4 1675 -9897.5 1685 -9897.5 {}
L 4 1680 -9892.5 1685 -9897.5 {}
L 4 1675 -9897.5 1680 -9892.5 {}
L 4 1680 -10190 1680 -10170 {}
L 4 1670 -10190 1690 -10190 {}
L 4 447.5 -9982.5 452.5 -9982.5 {}
L 4 450 -9985 450 -9980 {}
L 4 445 -9990 445 -9930 {}
L 4 555 -9910 555 -9897.5 {}
L 4 550 -9897.5 560 -9897.5 {}
L 4 555 -9892.5 560 -9897.5 {}
L 4 550 -9897.5 555 -9892.5 {}
L 4 555 -10190 555 -10170 {}
L 4 545 -10190 565 -10190 {}
L 4 2140 -9910 2140 -9897.5 {}
L 4 2135 -9897.5 2145 -9897.5 {}
L 4 2140 -9892.5 2145 -9897.5 {}
L 4 2135 -9897.5 2140 -9892.5 {}
L 4 2140 -10190 2140 -10170 {}
L 4 2130 -10190 2150 -10190 {}
L 4 2360 -10015 2360 -9990 {}
L 4 2360 -10050 2360 -10025 {}
L 4 2350 -10025 2370 -10025 {}
L 4 2350 -10015 2370 -10015 {}
L 4 2362.5 -10042.5 2367.5 -10042.5 {}
L 4 2365 -10045 2365 -10040 {}
L 4 745 -7910 745 -7850 {}
L 4 745 -7900 760 -7900 {}
L 4 760 -7910 760 -7900 {}
L 4 745 -7860 760 -7860 {}
L 4 760 -7860 760 -7850 {}
L 4 735 -7895 735 -7865 {}
L 4 735 -7880 735 -7875 {}
L 4 720 -7880 727.5 -7880 {}
L 4 720 -7880 735 -7880 {}
L 4 750 -7880 760 -7880 {}
L 4 745 -7885 750 -7880 {}
L 4 745 -7875 750 -7880 {}
L 4 760 -7950 760 -7940 {}
L 4 760 -7950 767.5 -7952.5 {}
L 4 752.5 -7957.5 767.5 -7952.5 {}
L 4 752.5 -7957.5 767.5 -7962.5 {}
L 4 752.5 -7967.5 767.5 -7962.5 {}
L 4 752.5 -7967.5 767.5 -7972.5 {}
L 4 752.5 -7977.5 767.5 -7972.5 {}
L 4 752.5 -7977.5 767.5 -7982.5 {}
L 4 752.5 -7987.5 767.5 -7982.5 {}
L 4 752.5 -7987.5 760 -7990 {}
L 4 760 -8000 760 -7990 {}
L 4 762.5 -7992.5 767.5 -7992.5 {}
L 4 765 -7995 765 -7990 {}
L 4 850 -7875 850 -7850 {}
L 4 850 -7910 850 -7885 {}
L 4 840 -7885 860 -7885 {}
L 4 840 -7875 860 -7875 {}
L 4 852.5 -7902.5 857.5 -7902.5 {}
L 4 855 -7905 855 -7900 {}
L 4 522.5 -7842.5 527.5 -7842.5 {}
L 4 525 -7845 525 -7840 {}
L 4 520 -7850 520 -7790 {}
L 4 630 -7770 630 -7757.5 {}
L 4 625 -7757.5 635 -7757.5 {}
L 4 630 -7752.5 635 -7757.5 {}
L 4 625 -7757.5 630 -7752.5 {}
L 4 630 -8050 630 -8030 {}
L 4 620 -8050 640 -8050 {}
L 4 1285 -7910 1285 -7850 {}
L 4 1285 -7900 1300 -7900 {}
L 4 1300 -7910 1300 -7900 {}
L 4 1285 -7860 1300 -7860 {}
L 4 1300 -7860 1300 -7850 {}
L 4 1275 -7895 1275 -7865 {}
L 4 1275 -7880 1275 -7875 {}
L 4 1260 -7880 1267.5 -7880 {}
L 4 1260 -7880 1275 -7880 {}
L 4 1290 -7880 1300 -7880 {}
L 4 1285 -7885 1290 -7880 {}
L 4 1285 -7875 1290 -7880 {}
L 4 1300 -7950 1300 -7940 {}
L 4 1300 -7950 1307.5 -7952.5 {}
L 4 1292.5 -7957.5 1307.5 -7952.5 {}
L 4 1292.5 -7957.5 1307.5 -7962.5 {}
L 4 1292.5 -7967.5 1307.5 -7962.5 {}
L 4 1292.5 -7967.5 1307.5 -7972.5 {}
L 4 1292.5 -7977.5 1307.5 -7972.5 {}
L 4 1292.5 -7977.5 1307.5 -7982.5 {}
L 4 1292.5 -7987.5 1307.5 -7982.5 {}
L 4 1292.5 -7987.5 1300 -7990 {}
L 4 1300 -8000 1300 -7990 {}
L 4 1302.5 -7992.5 1307.5 -7992.5 {}
L 4 1305 -7995 1305 -7990 {}
L 4 1390 -7875 1390 -7850 {}
L 4 1390 -7910 1390 -7885 {}
L 4 1380 -7885 1400 -7885 {}
L 4 1380 -7875 1400 -7875 {}
L 4 1392.5 -7902.5 1397.5 -7902.5 {}
L 4 1395 -7905 1395 -7900 {}
L 4 1062.5 -7842.5 1067.5 -7842.5 {}
L 4 1065 -7845 1065 -7840 {}
L 4 1060 -7850 1060 -7790 {}
L 4 1170 -7770 1170 -7757.5 {}
L 4 1165 -7757.5 1175 -7757.5 {}
L 4 1170 -7752.5 1175 -7757.5 {}
L 4 1165 -7757.5 1170 -7752.5 {}
L 4 1170 -8050 1170 -8030 {}
L 4 1160 -8050 1180 -8050 {}
L 4 2415 -7910 2415 -7850 {}
L 4 2415 -7900 2430 -7900 {}
L 4 2430 -7910 2430 -7900 {}
L 4 2415 -7860 2430 -7860 {}
L 4 2430 -7860 2430 -7850 {}
L 4 2405 -7895 2405 -7865 {}
L 4 2405 -7880 2405 -7875 {}
L 4 2390 -7880 2397.5 -7880 {}
L 4 2390 -7880 2405 -7880 {}
L 4 2420 -7880 2430 -7880 {}
L 4 2415 -7885 2420 -7880 {}
L 4 2415 -7875 2420 -7880 {}
L 4 2430 -7950 2430 -7940 {}
L 4 2430 -7950 2437.5 -7952.5 {}
L 4 2422.5 -7957.5 2437.5 -7952.5 {}
L 4 2422.5 -7957.5 2437.5 -7962.5 {}
L 4 2422.5 -7967.5 2437.5 -7962.5 {}
L 4 2422.5 -7967.5 2437.5 -7972.5 {}
L 4 2422.5 -7977.5 2437.5 -7972.5 {}
L 4 2422.5 -7977.5 2437.5 -7982.5 {}
L 4 2422.5 -7987.5 2437.5 -7982.5 {}
L 4 2422.5 -7987.5 2430 -7990 {}
L 4 2430 -8000 2430 -7990 {}
L 4 2432.5 -7992.5 2437.5 -7992.5 {}
L 4 2435 -7995 2435 -7990 {}
L 4 2520 -7875 2520 -7850 {}
L 4 2520 -7910 2520 -7885 {}
L 4 2510 -7885 2530 -7885 {}
L 4 2510 -7875 2530 -7875 {}
L 4 2522.5 -7902.5 2527.5 -7902.5 {}
L 4 2525 -7905 2525 -7900 {}
L 4 2192.5 -7842.5 2197.5 -7842.5 {}
L 4 2195 -7845 2195 -7840 {}
L 4 2190 -7850 2190 -7790 {}
L 4 2300 -7770 2300 -7757.5 {}
L 4 2295 -7757.5 2305 -7757.5 {}
L 4 2300 -7752.5 2305 -7757.5 {}
L 4 2295 -7757.5 2300 -7752.5 {}
L 4 2300 -8050 2300 -8030 {}
L 4 2290 -8050 2310 -8050 {}
L 4 820 -3770 820 -3760 {}
L 4 820 -3770 827.5 -3772.5 {}
L 4 812.5 -3777.5 827.5 -3772.5 {}
L 4 812.5 -3777.5 827.5 -3782.5 {}
L 4 812.5 -3787.5 827.5 -3782.5 {}
L 4 812.5 -3787.5 827.5 -3792.5 {}
L 4 812.5 -3797.5 827.5 -3792.5 {}
L 4 812.5 -3797.5 827.5 -3802.5 {}
L 4 812.5 -3807.5 827.5 -3802.5 {}
L 4 812.5 -3807.5 820 -3810 {}
L 4 820 -3820 820 -3810 {}
L 4 822.5 -3812.5 827.5 -3812.5 {}
L 4 825 -3815 825 -3810 {}
L 4 820 -3710 820 -3700 {}
L 4 820 -3710 827.5 -3712.5 {}
L 4 812.5 -3717.5 827.5 -3712.5 {}
L 4 812.5 -3717.5 827.5 -3722.5 {}
L 4 812.5 -3727.5 827.5 -3722.5 {}
L 4 812.5 -3727.5 827.5 -3732.5 {}
L 4 812.5 -3737.5 827.5 -3732.5 {}
L 4 812.5 -3737.5 827.5 -3742.5 {}
L 4 812.5 -3747.5 827.5 -3742.5 {}
L 4 812.5 -3747.5 820 -3750 {}
L 4 820 -3760 820 -3750 {}
L 4 822.5 -3752.5 827.5 -3752.5 {}
L 4 825 -3755 825 -3750 {}
L 4 1360 -3710 1360 -3700 {}
L 4 1360 -3710 1367.5 -3712.5 {}
L 4 1352.5 -3717.5 1367.5 -3712.5 {}
L 4 1352.5 -3717.5 1367.5 -3722.5 {}
L 4 1352.5 -3727.5 1367.5 -3722.5 {}
L 4 1352.5 -3727.5 1367.5 -3732.5 {}
L 4 1352.5 -3737.5 1367.5 -3732.5 {}
L 4 1352.5 -3737.5 1367.5 -3742.5 {}
L 4 1352.5 -3747.5 1367.5 -3742.5 {}
L 4 1352.5 -3747.5 1360 -3750 {}
L 4 1360 -3760 1360 -3750 {}
L 4 1362.5 -3752.5 1367.5 -3752.5 {}
L 4 1365 -3755 1365 -3750 {}
L 4 1900 -3810 1900 -3800 {}
L 4 1900 -3810 1907.5 -3812.5 {}
L 4 1892.5 -3817.5 1907.5 -3812.5 {}
L 4 1892.5 -3817.5 1907.5 -3822.5 {}
L 4 1892.5 -3827.5 1907.5 -3822.5 {}
L 4 1892.5 -3827.5 1907.5 -3832.5 {}
L 4 1892.5 -3837.5 1907.5 -3832.5 {}
L 4 1892.5 -3837.5 1907.5 -3842.5 {}
L 4 1892.5 -3847.5 1907.5 -3842.5 {}
L 4 1892.5 -3847.5 1900 -3850 {}
L 4 1900 -3860 1900 -3850 {}
L 4 1902.5 -3852.5 1907.5 -3852.5 {}
L 4 1905 -3855 1905 -3850 {}
L 4 1900 -3710 1900 -3700 {}
L 4 1900 -3710 1907.5 -3712.5 {}
L 4 1892.5 -3717.5 1907.5 -3712.5 {}
L 4 1892.5 -3717.5 1907.5 -3722.5 {}
L 4 1892.5 -3727.5 1907.5 -3722.5 {}
L 4 1892.5 -3727.5 1907.5 -3732.5 {}
L 4 1892.5 -3737.5 1907.5 -3732.5 {}
L 4 1892.5 -3737.5 1907.5 -3742.5 {}
L 4 1892.5 -3747.5 1907.5 -3742.5 {}
L 4 1892.5 -3747.5 1900 -3750 {}
L 4 1900 -3760 1900 -3750 {}
L 4 1902.5 -3752.5 1907.5 -3752.5 {}
L 4 1905 -3755 1905 -3750 {}
L 4 710 -2940 710 -2930 {}
L 4 710 -2940 717.5 -2942.5 {}
L 4 702.5 -2947.5 717.5 -2942.5 {}
L 4 702.5 -2947.5 717.5 -2952.5 {}
L 4 702.5 -2957.5 717.5 -2952.5 {}
L 4 702.5 -2957.5 717.5 -2962.5 {}
L 4 702.5 -2967.5 717.5 -2962.5 {}
L 4 702.5 -2967.5 717.5 -2972.5 {}
L 4 702.5 -2977.5 717.5 -2972.5 {}
L 4 702.5 -2977.5 710 -2980 {}
L 4 710 -2990 710 -2980 {}
L 4 712.5 -2982.5 717.5 -2982.5 {}
L 4 715 -2985 715 -2980 {}
L 4 820 -2940 820 -2930 {}
L 4 820 -2940 827.5 -2942.5 {}
L 4 812.5 -2947.5 827.5 -2942.5 {}
L 4 812.5 -2947.5 827.5 -2952.5 {}
L 4 812.5 -2957.5 827.5 -2952.5 {}
L 4 812.5 -2957.5 827.5 -2962.5 {}
L 4 812.5 -2967.5 827.5 -2962.5 {}
L 4 812.5 -2967.5 827.5 -2972.5 {}
L 4 812.5 -2977.5 827.5 -2972.5 {}
L 4 812.5 -2977.5 820 -2980 {}
L 4 820 -2990 820 -2980 {}
L 4 822.5 -2982.5 827.5 -2982.5 {}
L 4 825 -2985 825 -2980 {}
L 4 930 -2940 930 -2930 {}
L 4 930 -2940 937.5 -2942.5 {}
L 4 922.5 -2947.5 937.5 -2942.5 {}
L 4 922.5 -2947.5 937.5 -2952.5 {}
L 4 922.5 -2957.5 937.5 -2952.5 {}
L 4 922.5 -2957.5 937.5 -2962.5 {}
L 4 922.5 -2967.5 937.5 -2962.5 {}
L 4 922.5 -2967.5 937.5 -2972.5 {}
L 4 922.5 -2977.5 937.5 -2972.5 {}
L 4 922.5 -2977.5 930 -2980 {}
L 4 930 -2990 930 -2980 {}
L 4 932.5 -2982.5 937.5 -2982.5 {}
L 4 935 -2985 935 -2980 {}
L 4 1250 -2940 1250 -2930 {}
L 4 1250 -2940 1257.5 -2942.5 {}
L 4 1242.5 -2947.5 1257.5 -2942.5 {}
L 4 1242.5 -2947.5 1257.5 -2952.5 {}
L 4 1242.5 -2957.5 1257.5 -2952.5 {}
L 4 1242.5 -2957.5 1257.5 -2962.5 {}
L 4 1242.5 -2967.5 1257.5 -2962.5 {}
L 4 1242.5 -2967.5 1257.5 -2972.5 {}
L 4 1242.5 -2977.5 1257.5 -2972.5 {}
L 4 1242.5 -2977.5 1250 -2980 {}
L 4 1250 -2990 1250 -2980 {}
L 4 1252.5 -2982.5 1257.5 -2982.5 {}
L 4 1255 -2985 1255 -2980 {}
L 4 1360 -2940 1360 -2930 {}
L 4 1360 -2940 1367.5 -2942.5 {}
L 4 1352.5 -2947.5 1367.5 -2942.5 {}
L 4 1352.5 -2947.5 1367.5 -2952.5 {}
L 4 1352.5 -2957.5 1367.5 -2952.5 {}
L 4 1352.5 -2957.5 1367.5 -2962.5 {}
L 4 1352.5 -2967.5 1367.5 -2962.5 {}
L 4 1352.5 -2967.5 1367.5 -2972.5 {}
L 4 1352.5 -2977.5 1367.5 -2972.5 {}
L 4 1352.5 -2977.5 1360 -2980 {}
L 4 1360 -2990 1360 -2980 {}
L 4 1362.5 -2982.5 1367.5 -2982.5 {}
L 4 1365 -2985 1365 -2980 {}
L 4 1470 -2940 1470 -2930 {}
L 4 1470 -2940 1477.5 -2942.5 {}
L 4 1462.5 -2947.5 1477.5 -2942.5 {}
L 4 1462.5 -2947.5 1477.5 -2952.5 {}
L 4 1462.5 -2957.5 1477.5 -2952.5 {}
L 4 1462.5 -2957.5 1477.5 -2962.5 {}
L 4 1462.5 -2967.5 1477.5 -2962.5 {}
L 4 1462.5 -2967.5 1477.5 -2972.5 {}
L 4 1462.5 -2977.5 1477.5 -2972.5 {}
L 4 1462.5 -2977.5 1470 -2980 {}
L 4 1470 -2990 1470 -2980 {}
L 4 1472.5 -2982.5 1477.5 -2982.5 {}
L 4 1475 -2985 1475 -2980 {}
L 4 1790 -2940 1790 -2930 {}
L 4 1790 -2940 1797.5 -2942.5 {}
L 4 1782.5 -2947.5 1797.5 -2942.5 {}
L 4 1782.5 -2947.5 1797.5 -2952.5 {}
L 4 1782.5 -2957.5 1797.5 -2952.5 {}
L 4 1782.5 -2957.5 1797.5 -2962.5 {}
L 4 1782.5 -2967.5 1797.5 -2962.5 {}
L 4 1782.5 -2967.5 1797.5 -2972.5 {}
L 4 1782.5 -2977.5 1797.5 -2972.5 {}
L 4 1782.5 -2977.5 1790 -2980 {}
L 4 1790 -2990 1790 -2980 {}
L 4 1792.5 -2982.5 1797.5 -2982.5 {}
L 4 1795 -2985 1795 -2980 {}
L 4 1900 -2940 1900 -2930 {}
L 4 1900 -2940 1907.5 -2942.5 {}
L 4 1892.5 -2947.5 1907.5 -2942.5 {}
L 4 1892.5 -2947.5 1907.5 -2952.5 {}
L 4 1892.5 -2957.5 1907.5 -2952.5 {}
L 4 1892.5 -2957.5 1907.5 -2962.5 {}
L 4 1892.5 -2967.5 1907.5 -2962.5 {}
L 4 1892.5 -2967.5 1907.5 -2972.5 {}
L 4 1892.5 -2977.5 1907.5 -2972.5 {}
L 4 1892.5 -2977.5 1900 -2980 {}
L 4 1900 -2990 1900 -2980 {}
L 4 1902.5 -2982.5 1907.5 -2982.5 {}
L 4 1905 -2985 1905 -2980 {}
L 4 2010 -2940 2010 -2930 {}
L 4 2010 -2940 2017.5 -2942.5 {}
L 4 2002.5 -2947.5 2017.5 -2942.5 {}
L 4 2002.5 -2947.5 2017.5 -2952.5 {}
L 4 2002.5 -2957.5 2017.5 -2952.5 {}
L 4 2002.5 -2957.5 2017.5 -2962.5 {}
L 4 2002.5 -2967.5 2017.5 -2962.5 {}
L 4 2002.5 -2967.5 2017.5 -2972.5 {}
L 4 2002.5 -2977.5 2017.5 -2972.5 {}
L 4 2002.5 -2977.5 2010 -2980 {}
L 4 2010 -2990 2010 -2980 {}
L 4 2012.5 -2982.5 2017.5 -2982.5 {}
L 4 2015 -2985 2015 -2980 {}
L 4 2320 -2940 2320 -2930 {}
L 4 2320 -2940 2327.5 -2942.5 {}
L 4 2312.5 -2947.5 2327.5 -2942.5 {}
L 4 2312.5 -2947.5 2327.5 -2952.5 {}
L 4 2312.5 -2957.5 2327.5 -2952.5 {}
L 4 2312.5 -2957.5 2327.5 -2962.5 {}
L 4 2312.5 -2967.5 2327.5 -2962.5 {}
L 4 2312.5 -2967.5 2327.5 -2972.5 {}
L 4 2312.5 -2977.5 2327.5 -2972.5 {}
L 4 2312.5 -2977.5 2320 -2980 {}
L 4 2320 -2990 2320 -2980 {}
L 4 2322.5 -2982.5 2327.5 -2982.5 {}
L 4 2325 -2985 2325 -2980 {}
L 4 2430 -2940 2430 -2930 {}
L 4 2430 -2940 2437.5 -2942.5 {}
L 4 2422.5 -2947.5 2437.5 -2942.5 {}
L 4 2422.5 -2947.5 2437.5 -2952.5 {}
L 4 2422.5 -2957.5 2437.5 -2952.5 {}
L 4 2422.5 -2957.5 2437.5 -2962.5 {}
L 4 2422.5 -2967.5 2437.5 -2962.5 {}
L 4 2422.5 -2967.5 2437.5 -2972.5 {}
L 4 2422.5 -2977.5 2437.5 -2972.5 {}
L 4 2422.5 -2977.5 2430 -2980 {}
L 4 2430 -2990 2430 -2980 {}
L 4 2432.5 -2982.5 2437.5 -2982.5 {}
L 4 2435 -2985 2435 -2980 {}
L 4 2540 -2940 2540 -2930 {}
L 4 2540 -2940 2547.5 -2942.5 {}
L 4 2532.5 -2947.5 2547.5 -2942.5 {}
L 4 2532.5 -2947.5 2547.5 -2952.5 {}
L 4 2532.5 -2957.5 2547.5 -2952.5 {}
L 4 2532.5 -2957.5 2547.5 -2962.5 {}
L 4 2532.5 -2967.5 2547.5 -2962.5 {}
L 4 2532.5 -2967.5 2547.5 -2972.5 {}
L 4 2532.5 -2977.5 2547.5 -2972.5 {}
L 4 2532.5 -2977.5 2540 -2980 {}
L 4 2540 -2990 2540 -2980 {}
L 4 2542.5 -2982.5 2547.5 -2982.5 {}
L 4 2545 -2985 2545 -2980 {}
L 4 710 -1010 710 -1000 {}
L 4 710 -1010 717.5 -1012.5 {}
L 4 702.5 -1017.5 717.5 -1012.5 {}
L 4 702.5 -1017.5 717.5 -1022.5 {}
L 4 702.5 -1027.5 717.5 -1022.5 {}
L 4 702.5 -1027.5 717.5 -1032.5 {}
L 4 702.5 -1037.5 717.5 -1032.5 {}
L 4 702.5 -1037.5 717.5 -1042.5 {}
L 4 702.5 -1047.5 717.5 -1042.5 {}
L 4 702.5 -1047.5 710 -1050 {}
L 4 710 -1060 710 -1050 {}
L 4 712.5 -1052.5 717.5 -1052.5 {}
L 4 715 -1055 715 -1050 {}
L 4 820 -1010 820 -1000 {}
L 4 820 -1010 827.5 -1012.5 {}
L 4 812.5 -1017.5 827.5 -1012.5 {}
L 4 812.5 -1017.5 827.5 -1022.5 {}
L 4 812.5 -1027.5 827.5 -1022.5 {}
L 4 812.5 -1027.5 827.5 -1032.5 {}
L 4 812.5 -1037.5 827.5 -1032.5 {}
L 4 812.5 -1037.5 827.5 -1042.5 {}
L 4 812.5 -1047.5 827.5 -1042.5 {}
L 4 812.5 -1047.5 820 -1050 {}
L 4 820 -1060 820 -1050 {}
L 4 822.5 -1052.5 827.5 -1052.5 {}
L 4 825 -1055 825 -1050 {}
L 4 930 -1010 930 -1000 {}
L 4 930 -1010 937.5 -1012.5 {}
L 4 922.5 -1017.5 937.5 -1012.5 {}
L 4 922.5 -1017.5 937.5 -1022.5 {}
L 4 922.5 -1027.5 937.5 -1022.5 {}
L 4 922.5 -1027.5 937.5 -1032.5 {}
L 4 922.5 -1037.5 937.5 -1032.5 {}
L 4 922.5 -1037.5 937.5 -1042.5 {}
L 4 922.5 -1047.5 937.5 -1042.5 {}
L 4 922.5 -1047.5 930 -1050 {}
L 4 930 -1060 930 -1050 {}
L 4 932.5 -1052.5 937.5 -1052.5 {}
L 4 935 -1055 935 -1050 {}
L 4 710 -920 710 -910 {}
L 4 710 -920 717.5 -922.5 {}
L 4 702.5 -927.5 717.5 -922.5 {}
L 4 702.5 -927.5 717.5 -932.5 {}
L 4 702.5 -937.5 717.5 -932.5 {}
L 4 702.5 -937.5 717.5 -942.5 {}
L 4 702.5 -947.5 717.5 -942.5 {}
L 4 702.5 -947.5 717.5 -952.5 {}
L 4 702.5 -957.5 717.5 -952.5 {}
L 4 702.5 -957.5 710 -960 {}
L 4 710 -970 710 -960 {}
L 4 712.5 -962.5 717.5 -962.5 {}
L 4 715 -965 715 -960 {}
L 4 820 -920 820 -910 {}
L 4 820 -920 827.5 -922.5 {}
L 4 812.5 -927.5 827.5 -922.5 {}
L 4 812.5 -927.5 827.5 -932.5 {}
L 4 812.5 -937.5 827.5 -932.5 {}
L 4 812.5 -937.5 827.5 -942.5 {}
L 4 812.5 -947.5 827.5 -942.5 {}
L 4 812.5 -947.5 827.5 -952.5 {}
L 4 812.5 -957.5 827.5 -952.5 {}
L 4 812.5 -957.5 820 -960 {}
L 4 820 -970 820 -960 {}
L 4 822.5 -962.5 827.5 -962.5 {}
L 4 825 -965 825 -960 {}
L 4 930 -920 930 -910 {}
L 4 930 -920 937.5 -922.5 {}
L 4 922.5 -927.5 937.5 -922.5 {}
L 4 922.5 -927.5 937.5 -932.5 {}
L 4 922.5 -937.5 937.5 -932.5 {}
L 4 922.5 -937.5 937.5 -942.5 {}
L 4 922.5 -947.5 937.5 -942.5 {}
L 4 922.5 -947.5 937.5 -952.5 {}
L 4 922.5 -957.5 937.5 -952.5 {}
L 4 922.5 -957.5 930 -960 {}
L 4 930 -970 930 -960 {}
L 4 932.5 -962.5 937.5 -962.5 {}
L 4 935 -965 935 -960 {}
L 4 1250 -920 1250 -910 {}
L 4 1250 -920 1257.5 -922.5 {}
L 4 1242.5 -927.5 1257.5 -922.5 {}
L 4 1242.5 -927.5 1257.5 -932.5 {}
L 4 1242.5 -937.5 1257.5 -932.5 {}
L 4 1242.5 -937.5 1257.5 -942.5 {}
L 4 1242.5 -947.5 1257.5 -942.5 {}
L 4 1242.5 -947.5 1257.5 -952.5 {}
L 4 1242.5 -957.5 1257.5 -952.5 {}
L 4 1242.5 -957.5 1250 -960 {}
L 4 1250 -970 1250 -960 {}
L 4 1252.5 -962.5 1257.5 -962.5 {}
L 4 1255 -965 1255 -960 {}
L 4 1360 -920 1360 -910 {}
L 4 1360 -920 1367.5 -922.5 {}
L 4 1352.5 -927.5 1367.5 -922.5 {}
L 4 1352.5 -927.5 1367.5 -932.5 {}
L 4 1352.5 -937.5 1367.5 -932.5 {}
L 4 1352.5 -937.5 1367.5 -942.5 {}
L 4 1352.5 -947.5 1367.5 -942.5 {}
L 4 1352.5 -947.5 1367.5 -952.5 {}
L 4 1352.5 -957.5 1367.5 -952.5 {}
L 4 1352.5 -957.5 1360 -960 {}
L 4 1360 -970 1360 -960 {}
L 4 1362.5 -962.5 1367.5 -962.5 {}
L 4 1365 -965 1365 -960 {}
L 4 1470 -920 1470 -910 {}
L 4 1470 -920 1477.5 -922.5 {}
L 4 1462.5 -927.5 1477.5 -922.5 {}
L 4 1462.5 -927.5 1477.5 -932.5 {}
L 4 1462.5 -937.5 1477.5 -932.5 {}
L 4 1462.5 -937.5 1477.5 -942.5 {}
L 4 1462.5 -947.5 1477.5 -942.5 {}
L 4 1462.5 -947.5 1477.5 -952.5 {}
L 4 1462.5 -957.5 1477.5 -952.5 {}
L 4 1462.5 -957.5 1470 -960 {}
L 4 1470 -970 1470 -960 {}
L 4 1472.5 -962.5 1477.5 -962.5 {}
L 4 1475 -965 1475 -960 {}
L 4 1790 -920 1790 -910 {}
L 4 1790 -920 1797.5 -922.5 {}
L 4 1782.5 -927.5 1797.5 -922.5 {}
L 4 1782.5 -927.5 1797.5 -932.5 {}
L 4 1782.5 -937.5 1797.5 -932.5 {}
L 4 1782.5 -937.5 1797.5 -942.5 {}
L 4 1782.5 -947.5 1797.5 -942.5 {}
L 4 1782.5 -947.5 1797.5 -952.5 {}
L 4 1782.5 -957.5 1797.5 -952.5 {}
L 4 1782.5 -957.5 1790 -960 {}
L 4 1790 -970 1790 -960 {}
L 4 1792.5 -962.5 1797.5 -962.5 {}
L 4 1795 -965 1795 -960 {}
L 4 1900 -920 1900 -910 {}
L 4 1900 -920 1907.5 -922.5 {}
L 4 1892.5 -927.5 1907.5 -922.5 {}
L 4 1892.5 -927.5 1907.5 -932.5 {}
L 4 1892.5 -937.5 1907.5 -932.5 {}
L 4 1892.5 -937.5 1907.5 -942.5 {}
L 4 1892.5 -947.5 1907.5 -942.5 {}
L 4 1892.5 -947.5 1907.5 -952.5 {}
L 4 1892.5 -957.5 1907.5 -952.5 {}
L 4 1892.5 -957.5 1900 -960 {}
L 4 1900 -970 1900 -960 {}
L 4 1902.5 -962.5 1907.5 -962.5 {}
L 4 1905 -965 1905 -960 {}
L 4 2010 -920 2010 -910 {}
L 4 2010 -920 2017.5 -922.5 {}
L 4 2002.5 -927.5 2017.5 -922.5 {}
L 4 2002.5 -927.5 2017.5 -932.5 {}
L 4 2002.5 -937.5 2017.5 -932.5 {}
L 4 2002.5 -937.5 2017.5 -942.5 {}
L 4 2002.5 -947.5 2017.5 -942.5 {}
L 4 2002.5 -947.5 2017.5 -952.5 {}
L 4 2002.5 -957.5 2017.5 -952.5 {}
L 4 2002.5 -957.5 2010 -960 {}
L 4 2010 -970 2010 -960 {}
L 4 2012.5 -962.5 2017.5 -962.5 {}
L 4 2015 -965 2015 -960 {}
L 4 1865 -2730 1865 -2670 {}
L 4 1865 -2720 1880 -2720 {}
L 4 1880 -2730 1880 -2720 {}
L 4 1865 -2680 1880 -2680 {}
L 4 1880 -2680 1880 -2670 {}
L 4 1855 -2715 1855 -2685 {}
L 4 1855 -2700 1855 -2695 {}
L 4 1840 -2700 1847.5 -2700 {}
L 4 1840 -2700 1855 -2700 {}
L 4 1870 -2700 1880 -2700 {}
L 4 1865 -2705 1870 -2700 {}
L 4 1865 -2695 1870 -2700 {}
L 4 1140 -9910 1140 -9897.5 {}
L 4 1135 -9897.5 1145 -9897.5 {}
L 4 1140 -9892.5 1145 -9897.5 {}
L 4 1135 -9897.5 1140 -9892.5 {}
L 4 1140 -10190 1140 -10170 {}
L 4 1130 -10190 1150 -10190 {}
L 4 1032.5 -9982.5 1037.5 -9982.5 {}
L 4 1035 -9985 1035 -9980 {}
L 4 1030 -9990 1030 -9930 {}
L 4 710 -630 710 -620 {}
L 4 710 -630 717.5 -632.5 {}
L 4 702.5 -637.5 717.5 -632.5 {}
L 4 702.5 -637.5 717.5 -642.5 {}
L 4 702.5 -647.5 717.5 -642.5 {}
L 4 702.5 -647.5 717.5 -652.5 {}
L 4 702.5 -657.5 717.5 -652.5 {}
L 4 702.5 -657.5 717.5 -662.5 {}
L 4 702.5 -667.5 717.5 -662.5 {}
L 4 702.5 -667.5 710 -670 {}
L 4 710 -680 710 -670 {}
L 4 712.5 -672.5 717.5 -672.5 {}
L 4 715 -675 715 -670 {}
L 4 820 -630 820 -620 {}
L 4 820 -630 827.5 -632.5 {}
L 4 812.5 -637.5 827.5 -632.5 {}
L 4 812.5 -637.5 827.5 -642.5 {}
L 4 812.5 -647.5 827.5 -642.5 {}
L 4 812.5 -647.5 827.5 -652.5 {}
L 4 812.5 -657.5 827.5 -652.5 {}
L 4 812.5 -657.5 827.5 -662.5 {}
L 4 812.5 -667.5 827.5 -662.5 {}
L 4 812.5 -667.5 820 -670 {}
L 4 820 -680 820 -670 {}
L 4 822.5 -672.5 827.5 -672.5 {}
L 4 825 -675 825 -670 {}
L 4 930 -630 930 -620 {}
L 4 930 -630 937.5 -632.5 {}
L 4 922.5 -637.5 937.5 -632.5 {}
L 4 922.5 -637.5 937.5 -642.5 {}
L 4 922.5 -647.5 937.5 -642.5 {}
L 4 922.5 -647.5 937.5 -652.5 {}
L 4 922.5 -657.5 937.5 -652.5 {}
L 4 922.5 -657.5 937.5 -662.5 {}
L 4 922.5 -667.5 937.5 -662.5 {}
L 4 922.5 -667.5 930 -670 {}
L 4 930 -680 930 -670 {}
L 4 932.5 -672.5 937.5 -672.5 {}
L 4 935 -675 935 -670 {}
L 4 710 -570 710 -560 {}
L 4 710 -570 717.5 -572.5 {}
L 4 702.5 -577.5 717.5 -572.5 {}
L 4 702.5 -577.5 717.5 -582.5 {}
L 4 702.5 -587.5 717.5 -582.5 {}
L 4 702.5 -587.5 717.5 -592.5 {}
L 4 702.5 -597.5 717.5 -592.5 {}
L 4 702.5 -597.5 717.5 -602.5 {}
L 4 702.5 -607.5 717.5 -602.5 {}
L 4 702.5 -607.5 710 -610 {}
L 4 710 -620 710 -610 {}
L 4 712.5 -612.5 717.5 -612.5 {}
L 4 715 -615 715 -610 {}
L 4 820 -570 820 -560 {}
L 4 820 -570 827.5 -572.5 {}
L 4 812.5 -577.5 827.5 -572.5 {}
L 4 812.5 -577.5 827.5 -582.5 {}
L 4 812.5 -587.5 827.5 -582.5 {}
L 4 812.5 -587.5 827.5 -592.5 {}
L 4 812.5 -597.5 827.5 -592.5 {}
L 4 812.5 -597.5 827.5 -602.5 {}
L 4 812.5 -607.5 827.5 -602.5 {}
L 4 812.5 -607.5 820 -610 {}
L 4 820 -620 820 -610 {}
L 4 822.5 -612.5 827.5 -612.5 {}
L 4 825 -615 825 -610 {}
L 4 930 -570 930 -560 {}
L 4 930 -570 937.5 -572.5 {}
L 4 922.5 -577.5 937.5 -572.5 {}
L 4 922.5 -577.5 937.5 -582.5 {}
L 4 922.5 -587.5 937.5 -582.5 {}
L 4 922.5 -587.5 937.5 -592.5 {}
L 4 922.5 -597.5 937.5 -592.5 {}
L 4 922.5 -597.5 937.5 -602.5 {}
L 4 922.5 -607.5 937.5 -602.5 {}
L 4 922.5 -607.5 930 -610 {}
L 4 930 -620 930 -610 {}
L 4 932.5 -612.5 937.5 -612.5 {}
L 4 935 -615 935 -610 {}
L 4 1250 -570 1250 -560 {}
L 4 1250 -570 1257.5 -572.5 {}
L 4 1242.5 -577.5 1257.5 -572.5 {}
L 4 1242.5 -577.5 1257.5 -582.5 {}
L 4 1242.5 -587.5 1257.5 -582.5 {}
L 4 1242.5 -587.5 1257.5 -592.5 {}
L 4 1242.5 -597.5 1257.5 -592.5 {}
L 4 1242.5 -597.5 1257.5 -602.5 {}
L 4 1242.5 -607.5 1257.5 -602.5 {}
L 4 1242.5 -607.5 1250 -610 {}
L 4 1250 -620 1250 -610 {}
L 4 1252.5 -612.5 1257.5 -612.5 {}
L 4 1255 -615 1255 -610 {}
L 4 1360 -570 1360 -560 {}
L 4 1360 -570 1367.5 -572.5 {}
L 4 1352.5 -577.5 1367.5 -572.5 {}
L 4 1352.5 -577.5 1367.5 -582.5 {}
L 4 1352.5 -587.5 1367.5 -582.5 {}
L 4 1352.5 -587.5 1367.5 -592.5 {}
L 4 1352.5 -597.5 1367.5 -592.5 {}
L 4 1352.5 -597.5 1367.5 -602.5 {}
L 4 1352.5 -607.5 1367.5 -602.5 {}
L 4 1352.5 -607.5 1360 -610 {}
L 4 1360 -620 1360 -610 {}
L 4 1362.5 -612.5 1367.5 -612.5 {}
L 4 1365 -615 1365 -610 {}
L 4 1470 -570 1470 -560 {}
L 4 1470 -570 1477.5 -572.5 {}
L 4 1462.5 -577.5 1477.5 -572.5 {}
L 4 1462.5 -577.5 1477.5 -582.5 {}
L 4 1462.5 -587.5 1477.5 -582.5 {}
L 4 1462.5 -587.5 1477.5 -592.5 {}
L 4 1462.5 -597.5 1477.5 -592.5 {}
L 4 1462.5 -597.5 1477.5 -602.5 {}
L 4 1462.5 -607.5 1477.5 -602.5 {}
L 4 1462.5 -607.5 1470 -610 {}
L 4 1470 -620 1470 -610 {}
L 4 1472.5 -612.5 1477.5 -612.5 {}
L 4 1475 -615 1475 -610 {}
L 4 1790 -540 1790 -530 {}
L 4 1790 -540 1797.5 -542.5 {}
L 4 1782.5 -547.5 1797.5 -542.5 {}
L 4 1782.5 -547.5 1797.5 -552.5 {}
L 4 1782.5 -557.5 1797.5 -552.5 {}
L 4 1782.5 -557.5 1797.5 -562.5 {}
L 4 1782.5 -567.5 1797.5 -562.5 {}
L 4 1782.5 -567.5 1797.5 -572.5 {}
L 4 1782.5 -577.5 1797.5 -572.5 {}
L 4 1782.5 -577.5 1790 -580 {}
L 4 1790 -590 1790 -580 {}
L 4 1792.5 -582.5 1797.5 -582.5 {}
L 4 1795 -585 1795 -580 {}
L 4 1900 -540 1900 -530 {}
L 4 1900 -540 1907.5 -542.5 {}
L 4 1892.5 -547.5 1907.5 -542.5 {}
L 4 1892.5 -547.5 1907.5 -552.5 {}
L 4 1892.5 -557.5 1907.5 -552.5 {}
L 4 1892.5 -557.5 1907.5 -562.5 {}
L 4 1892.5 -567.5 1907.5 -562.5 {}
L 4 1892.5 -567.5 1907.5 -572.5 {}
L 4 1892.5 -577.5 1907.5 -572.5 {}
L 4 1892.5 -577.5 1900 -580 {}
L 4 1900 -590 1900 -580 {}
L 4 1902.5 -582.5 1907.5 -582.5 {}
L 4 1905 -585 1905 -580 {}
L 4 2010 -540 2010 -530 {}
L 4 2010 -540 2017.5 -542.5 {}
L 4 2002.5 -547.5 2017.5 -542.5 {}
L 4 2002.5 -547.5 2017.5 -552.5 {}
L 4 2002.5 -557.5 2017.5 -552.5 {}
L 4 2002.5 -557.5 2017.5 -562.5 {}
L 4 2002.5 -567.5 2017.5 -562.5 {}
L 4 2002.5 -567.5 2017.5 -572.5 {}
L 4 2002.5 -577.5 2017.5 -572.5 {}
L 4 2002.5 -577.5 2010 -580 {}
L 4 2010 -590 2010 -580 {}
L 4 2012.5 -582.5 2017.5 -582.5 {}
L 4 2015 -585 2015 -580 {}
L 4 1760 -1320 1760 -1310 {}
L 4 1760 -1320 1767.5 -1322.5 {}
L 4 1752.5 -1327.5 1767.5 -1322.5 {}
L 4 1752.5 -1327.5 1767.5 -1332.5 {}
L 4 1752.5 -1337.5 1767.5 -1332.5 {}
L 4 1752.5 -1337.5 1767.5 -1342.5 {}
L 4 1752.5 -1347.5 1767.5 -1342.5 {}
L 4 1752.5 -1347.5 1767.5 -1352.5 {}
L 4 1752.5 -1357.5 1767.5 -1352.5 {}
L 4 1752.5 -1357.5 1760 -1360 {}
L 4 1760 -1370 1760 -1360 {}
L 4 1762.5 -1362.5 1767.5 -1362.5 {}
L 4 1765 -1365 1765 -1360 {}
L 4 1880 -1320 1880 -1310 {}
L 4 1880 -1320 1887.5 -1322.5 {}
L 4 1872.5 -1327.5 1887.5 -1322.5 {}
L 4 1872.5 -1327.5 1887.5 -1332.5 {}
L 4 1872.5 -1337.5 1887.5 -1332.5 {}
L 4 1872.5 -1337.5 1887.5 -1342.5 {}
L 4 1872.5 -1347.5 1887.5 -1342.5 {}
L 4 1872.5 -1347.5 1887.5 -1352.5 {}
L 4 1872.5 -1357.5 1887.5 -1352.5 {}
L 4 1872.5 -1357.5 1880 -1360 {}
L 4 1880 -1370 1880 -1360 {}
L 4 1882.5 -1362.5 1887.5 -1362.5 {}
L 4 1885 -1365 1885 -1360 {}
L 4 805 -220 805 -160 {}
L 4 805 -210 820 -210 {}
L 4 820 -220 820 -210 {}
L 4 805 -170 820 -170 {}
L 4 820 -170 820 -160 {}
L 4 795 -205 795 -175 {}
L 4 795 -190 795 -185 {}
L 4 780 -190 787.5 -190 {}
L 4 780 -190 795 -190 {}
L 4 810 -190 820 -190 {}
L 4 805 -195 810 -190 {}
L 4 805 -185 810 -190 {}
L 4 820 -260 820 -250 {}
L 4 820 -260 827.5 -262.5 {}
L 4 812.5 -267.5 827.5 -262.5 {}
L 4 812.5 -267.5 827.5 -272.5 {}
L 4 812.5 -277.5 827.5 -272.5 {}
L 4 812.5 -277.5 827.5 -282.5 {}
L 4 812.5 -287.5 827.5 -282.5 {}
L 4 812.5 -287.5 827.5 -292.5 {}
L 4 812.5 -297.5 827.5 -292.5 {}
L 4 812.5 -297.5 820 -300 {}
L 4 820 -310 820 -300 {}
L 4 822.5 -302.5 827.5 -302.5 {}
L 4 825 -305 825 -300 {}
L 4 910 -185 910 -160 {}
L 4 910 -220 910 -195 {}
L 4 900 -195 920 -195 {}
L 4 900 -185 920 -185 {}
L 4 912.5 -212.5 917.5 -212.5 {}
L 4 915 -215 915 -210 {}
L 4 582.5 -152.5 587.5 -152.5 {}
L 4 585 -155 585 -150 {}
L 4 580 -160 580 -100 {}
L 4 690 -80 690 -67.5 {}
L 4 685 -67.5 695 -67.5 {}
L 4 690 -62.5 695 -67.5 {}
L 4 685 -67.5 690 -62.5 {}
L 4 690 -360 690 -340 {}
L 4 680 -360 700 -360 {}
L 4 1405 -220 1405 -160 {}
L 4 1405 -210 1420 -210 {}
L 4 1420 -220 1420 -210 {}
L 4 1405 -170 1420 -170 {}
L 4 1420 -170 1420 -160 {}
L 4 1395 -205 1395 -175 {}
L 4 1395 -190 1395 -185 {}
L 4 1380 -190 1387.5 -190 {}
L 4 1380 -190 1395 -190 {}
L 4 1410 -190 1420 -190 {}
L 4 1405 -195 1410 -190 {}
L 4 1405 -185 1410 -190 {}
L 4 1420 -260 1420 -250 {}
L 4 1420 -260 1427.5 -262.5 {}
L 4 1412.5 -267.5 1427.5 -262.5 {}
L 4 1412.5 -267.5 1427.5 -272.5 {}
L 4 1412.5 -277.5 1427.5 -272.5 {}
L 4 1412.5 -277.5 1427.5 -282.5 {}
L 4 1412.5 -287.5 1427.5 -282.5 {}
L 4 1412.5 -287.5 1427.5 -292.5 {}
L 4 1412.5 -297.5 1427.5 -292.5 {}
L 4 1412.5 -297.5 1420 -300 {}
L 4 1420 -310 1420 -300 {}
L 4 1422.5 -302.5 1427.5 -302.5 {}
L 4 1425 -305 1425 -300 {}
L 4 1182.5 -152.5 1187.5 -152.5 {}
L 4 1185 -155 1185 -150 {}
L 4 1180 -160 1180 -100 {}
L 4 1290 -80 1290 -67.5 {}
L 4 1285 -67.5 1295 -67.5 {}
L 4 1290 -62.5 1295 -67.5 {}
L 4 1285 -67.5 1290 -62.5 {}
L 4 1290 -360 1290 -340 {}
L 4 1280 -360 1300 -360 {}
L 4 2015 -220 2015 -160 {}
L 4 2015 -210 2030 -210 {}
L 4 2030 -220 2030 -210 {}
L 4 2015 -170 2030 -170 {}
L 4 2030 -170 2030 -160 {}
L 4 2005 -205 2005 -175 {}
L 4 2005 -190 2005 -185 {}
L 4 1990 -190 1997.5 -190 {}
L 4 1990 -190 2005 -190 {}
L 4 2020 -190 2030 -190 {}
L 4 2015 -195 2020 -190 {}
L 4 2015 -185 2020 -190 {}
L 4 2030 -260 2030 -250 {}
L 4 2030 -260 2037.5 -262.5 {}
L 4 2022.5 -267.5 2037.5 -262.5 {}
L 4 2022.5 -267.5 2037.5 -272.5 {}
L 4 2022.5 -277.5 2037.5 -272.5 {}
L 4 2022.5 -277.5 2037.5 -282.5 {}
L 4 2022.5 -287.5 2037.5 -282.5 {}
L 4 2022.5 -287.5 2037.5 -292.5 {}
L 4 2022.5 -297.5 2037.5 -292.5 {}
L 4 2022.5 -297.5 2030 -300 {}
L 4 2030 -310 2030 -300 {}
L 4 2032.5 -302.5 2037.5 -302.5 {}
L 4 2035 -305 2035 -300 {}
L 4 1792.5 -152.5 1797.5 -152.5 {}
L 4 1795 -155 1795 -150 {}
L 4 1790 -160 1790 -100 {}
L 4 1900 -80 1900 -67.5 {}
L 4 1895 -67.5 1905 -67.5 {}
L 4 1900 -62.5 1905 -67.5 {}
L 4 1895 -67.5 1900 -62.5 {}
L 4 1900 -360 1900 -340 {}
L 4 1890 -360 1910 -360 {}
L 4 360 -7470 360 -7460 {}
L 4 360 -7470 367.5 -7472.5 {}
L 4 352.5 -7477.5 367.5 -7472.5 {}
L 4 352.5 -7477.5 367.5 -7482.5 {}
L 4 352.5 -7487.5 367.5 -7482.5 {}
L 4 352.5 -7487.5 367.5 -7492.5 {}
L 4 352.5 -7497.5 367.5 -7492.5 {}
L 4 352.5 -7497.5 367.5 -7502.5 {}
L 4 352.5 -7507.5 367.5 -7502.5 {}
L 4 352.5 -7507.5 360 -7510 {}
L 4 360 -7520 360 -7510 {}
L 4 362.5 -7512.5 367.5 -7512.5 {}
L 4 365 -7515 365 -7510 {}
L 4 560 -7470 560 -7460 {}
L 4 560 -7470 567.5 -7472.5 {}
L 4 552.5 -7477.5 567.5 -7472.5 {}
L 4 552.5 -7477.5 567.5 -7482.5 {}
L 4 552.5 -7487.5 567.5 -7482.5 {}
L 4 552.5 -7487.5 567.5 -7492.5 {}
L 4 552.5 -7497.5 567.5 -7492.5 {}
L 4 552.5 -7497.5 567.5 -7502.5 {}
L 4 552.5 -7507.5 567.5 -7502.5 {}
L 4 552.5 -7507.5 560 -7510 {}
L 4 560 -7520 560 -7510 {}
L 4 562.5 -7512.5 567.5 -7512.5 {}
L 4 565 -7515 565 -7510 {}
L 4 800 -7470 800 -7460 {}
L 4 800 -7470 807.5 -7472.5 {}
L 4 792.5 -7477.5 807.5 -7472.5 {}
L 4 792.5 -7477.5 807.5 -7482.5 {}
L 4 792.5 -7487.5 807.5 -7482.5 {}
L 4 792.5 -7487.5 807.5 -7492.5 {}
L 4 792.5 -7497.5 807.5 -7492.5 {}
L 4 792.5 -7497.5 807.5 -7502.5 {}
L 4 792.5 -7507.5 807.5 -7502.5 {}
L 4 792.5 -7507.5 800 -7510 {}
L 4 800 -7520 800 -7510 {}
L 4 802.5 -7512.5 807.5 -7512.5 {}
L 4 805 -7515 805 -7510 {}
L 4 1090 -7470 1090 -7460 {}
L 4 1090 -7470 1097.5 -7472.5 {}
L 4 1082.5 -7477.5 1097.5 -7472.5 {}
L 4 1082.5 -7477.5 1097.5 -7482.5 {}
L 4 1082.5 -7487.5 1097.5 -7482.5 {}
L 4 1082.5 -7487.5 1097.5 -7492.5 {}
L 4 1082.5 -7497.5 1097.5 -7492.5 {}
L 4 1082.5 -7497.5 1097.5 -7502.5 {}
L 4 1082.5 -7507.5 1097.5 -7502.5 {}
L 4 1082.5 -7507.5 1090 -7510 {}
L 4 1090 -7520 1090 -7510 {}
L 4 1092.5 -7512.5 1097.5 -7512.5 {}
L 4 1095 -7515 1095 -7510 {}
L 4 1320 -7470 1320 -7460 {}
L 4 1320 -7470 1327.5 -7472.5 {}
L 4 1312.5 -7477.5 1327.5 -7472.5 {}
L 4 1312.5 -7477.5 1327.5 -7482.5 {}
L 4 1312.5 -7487.5 1327.5 -7482.5 {}
L 4 1312.5 -7487.5 1327.5 -7492.5 {}
L 4 1312.5 -7497.5 1327.5 -7492.5 {}
L 4 1312.5 -7497.5 1327.5 -7502.5 {}
L 4 1312.5 -7507.5 1327.5 -7502.5 {}
L 4 1312.5 -7507.5 1320 -7510 {}
L 4 1320 -7520 1320 -7510 {}
L 4 1322.5 -7512.5 1327.5 -7512.5 {}
L 4 1325 -7515 1325 -7510 {}
L 4 1610 -7470 1610 -7460 {}
L 4 1610 -7470 1617.5 -7472.5 {}
L 4 1602.5 -7477.5 1617.5 -7472.5 {}
L 4 1602.5 -7477.5 1617.5 -7482.5 {}
L 4 1602.5 -7487.5 1617.5 -7482.5 {}
L 4 1602.5 -7487.5 1617.5 -7492.5 {}
L 4 1602.5 -7497.5 1617.5 -7492.5 {}
L 4 1602.5 -7497.5 1617.5 -7502.5 {}
L 4 1602.5 -7507.5 1617.5 -7502.5 {}
L 4 1602.5 -7507.5 1610 -7510 {}
L 4 1610 -7520 1610 -7510 {}
L 4 1612.5 -7512.5 1617.5 -7512.5 {}
L 4 1615 -7515 1615 -7510 {}
L 4 1850 -7470 1850 -7460 {}
L 4 1850 -7470 1857.5 -7472.5 {}
L 4 1842.5 -7477.5 1857.5 -7472.5 {}
L 4 1842.5 -7477.5 1857.5 -7482.5 {}
L 4 1842.5 -7487.5 1857.5 -7482.5 {}
L 4 1842.5 -7487.5 1857.5 -7492.5 {}
L 4 1842.5 -7497.5 1857.5 -7492.5 {}
L 4 1842.5 -7497.5 1857.5 -7502.5 {}
L 4 1842.5 -7507.5 1857.5 -7502.5 {}
L 4 1842.5 -7507.5 1850 -7510 {}
L 4 1850 -7520 1850 -7510 {}
L 4 1852.5 -7512.5 1857.5 -7512.5 {}
L 4 1855 -7515 1855 -7510 {}
L 4 2150 -7470 2150 -7460 {}
L 4 2150 -7470 2157.5 -7472.5 {}
L 4 2142.5 -7477.5 2157.5 -7472.5 {}
L 4 2142.5 -7477.5 2157.5 -7482.5 {}
L 4 2142.5 -7487.5 2157.5 -7482.5 {}
L 4 2142.5 -7487.5 2157.5 -7492.5 {}
L 4 2142.5 -7497.5 2157.5 -7492.5 {}
L 4 2142.5 -7497.5 2157.5 -7502.5 {}
L 4 2142.5 -7507.5 2157.5 -7502.5 {}
L 4 2142.5 -7507.5 2150 -7510 {}
L 4 2150 -7520 2150 -7510 {}
L 4 2152.5 -7512.5 2157.5 -7512.5 {}
L 4 2155 -7515 2155 -7510 {}
L 4 745 -4280 745 -4220 {}
L 4 745 -4270 760 -4270 {}
L 4 760 -4280 760 -4270 {}
L 4 745 -4230 760 -4230 {}
L 4 760 -4230 760 -4220 {}
L 4 735 -4265 735 -4235 {}
L 4 735 -4250 735 -4245 {}
L 4 720 -4250 727.5 -4250 {}
L 4 720 -4250 735 -4250 {}
L 4 750 -4250 760 -4250 {}
L 4 745 -4255 750 -4250 {}
L 4 745 -4245 750 -4250 {}
L 4 760 -4320 760 -4310 {}
L 4 760 -4320 767.5 -4322.5 {}
L 4 752.5 -4327.5 767.5 -4322.5 {}
L 4 752.5 -4327.5 767.5 -4332.5 {}
L 4 752.5 -4337.5 767.5 -4332.5 {}
L 4 752.5 -4337.5 767.5 -4342.5 {}
L 4 752.5 -4347.5 767.5 -4342.5 {}
L 4 752.5 -4347.5 767.5 -4352.5 {}
L 4 752.5 -4357.5 767.5 -4352.5 {}
L 4 752.5 -4357.5 760 -4360 {}
L 4 760 -4370 760 -4360 {}
L 4 762.5 -4362.5 767.5 -4362.5 {}
L 4 765 -4365 765 -4360 {}
L 4 522.5 -4212.5 527.5 -4212.5 {}
L 4 525 -4215 525 -4210 {}
L 4 520 -4220 520 -4160 {}
L 4 630 -4140 630 -4127.5 {}
L 4 625 -4127.5 635 -4127.5 {}
L 4 630 -4122.5 635 -4127.5 {}
L 4 625 -4127.5 630 -4122.5 {}
L 4 630 -4420 630 -4400 {}
L 4 620 -4420 640 -4420 {}
L 4 1305 -4280 1305 -4220 {}
L 4 1305 -4270 1320 -4270 {}
L 4 1320 -4280 1320 -4270 {}
L 4 1305 -4230 1320 -4230 {}
L 4 1320 -4230 1320 -4220 {}
L 4 1295 -4265 1295 -4235 {}
L 4 1295 -4250 1295 -4245 {}
L 4 1280 -4250 1287.5 -4250 {}
L 4 1280 -4250 1295 -4250 {}
L 4 1310 -4250 1320 -4250 {}
L 4 1305 -4255 1310 -4250 {}
L 4 1305 -4245 1310 -4250 {}
L 4 1320 -4320 1320 -4310 {}
L 4 1320 -4320 1327.5 -4322.5 {}
L 4 1312.5 -4327.5 1327.5 -4322.5 {}
L 4 1312.5 -4327.5 1327.5 -4332.5 {}
L 4 1312.5 -4337.5 1327.5 -4332.5 {}
L 4 1312.5 -4337.5 1327.5 -4342.5 {}
L 4 1312.5 -4347.5 1327.5 -4342.5 {}
L 4 1312.5 -4347.5 1327.5 -4352.5 {}
L 4 1312.5 -4357.5 1327.5 -4352.5 {}
L 4 1312.5 -4357.5 1320 -4360 {}
L 4 1320 -4370 1320 -4360 {}
L 4 1322.5 -4362.5 1327.5 -4362.5 {}
L 4 1325 -4365 1325 -4360 {}
L 4 1082.5 -4212.5 1087.5 -4212.5 {}
L 4 1085 -4215 1085 -4210 {}
L 4 1080 -4220 1080 -4160 {}
L 4 1190 -4140 1190 -4127.5 {}
L 4 1185 -4127.5 1195 -4127.5 {}
L 4 1190 -4122.5 1195 -4127.5 {}
L 4 1185 -4127.5 1190 -4122.5 {}
L 4 1190 -4420 1190 -4400 {}
L 4 1180 -4420 1200 -4420 {}
L 4 690 -8330 690 -8270 {}
L 4 690 -8320 705 -8320 {}
L 4 705 -8330 705 -8320 {}
L 4 690 -8280 705 -8280 {}
L 4 705 -8280 705 -8270 {}
L 4 680 -8315 680 -8285 {}
L 4 680 -8300 680 -8295 {}
L 4 665 -8300 672.5 -8300 {}
L 4 665 -8300 680 -8300 {}
L 4 695 -8300 705 -8300 {}
L 4 690 -8305 695 -8300 {}
L 4 690 -8295 695 -8300 {}
L 4 705 -8370 705 -8360 {}
L 4 705 -8370 712.5 -8372.5 {}
L 4 697.5 -8377.5 712.5 -8372.5 {}
L 4 697.5 -8377.5 712.5 -8382.5 {}
L 4 697.5 -8387.5 712.5 -8382.5 {}
L 4 697.5 -8387.5 712.5 -8392.5 {}
L 4 697.5 -8397.5 712.5 -8392.5 {}
L 4 697.5 -8397.5 712.5 -8402.5 {}
L 4 697.5 -8407.5 712.5 -8402.5 {}
L 4 697.5 -8407.5 705 -8410 {}
L 4 705 -8420 705 -8410 {}
L 4 707.5 -8412.5 712.5 -8412.5 {}
L 4 710 -8415 710 -8410 {}
L 4 795 -8295 795 -8270 {}
L 4 795 -8330 795 -8305 {}
L 4 785 -8305 805 -8305 {}
L 4 785 -8295 805 -8295 {}
L 4 797.5 -8322.5 802.5 -8322.5 {}
L 4 800 -8325 800 -8320 {}
L 4 467.5 -8262.5 472.5 -8262.5 {}
L 4 470 -8265 470 -8260 {}
L 4 465 -8270 465 -8210 {}
L 4 575 -8190 575 -8177.5 {}
L 4 570 -8177.5 580 -8177.5 {}
L 4 575 -8172.5 580 -8177.5 {}
L 4 570 -8177.5 575 -8172.5 {}
L 4 575 -8470 575 -8450 {}
L 4 565 -8470 585 -8470 {}
L 4 1255 -8330 1255 -8270 {}
L 4 1255 -8320 1270 -8320 {}
L 4 1270 -8330 1270 -8320 {}
L 4 1255 -8280 1270 -8280 {}
L 4 1270 -8280 1270 -8270 {}
L 4 1245 -8315 1245 -8285 {}
L 4 1245 -8300 1245 -8295 {}
L 4 1230 -8300 1237.5 -8300 {}
L 4 1230 -8300 1245 -8300 {}
L 4 1260 -8300 1270 -8300 {}
L 4 1255 -8305 1260 -8300 {}
L 4 1255 -8295 1260 -8300 {}
L 4 1270 -8370 1270 -8360 {}
L 4 1270 -8370 1277.5 -8372.5 {}
L 4 1262.5 -8377.5 1277.5 -8372.5 {}
L 4 1262.5 -8377.5 1277.5 -8382.5 {}
L 4 1262.5 -8387.5 1277.5 -8382.5 {}
L 4 1262.5 -8387.5 1277.5 -8392.5 {}
L 4 1262.5 -8397.5 1277.5 -8392.5 {}
L 4 1262.5 -8397.5 1277.5 -8402.5 {}
L 4 1262.5 -8407.5 1277.5 -8402.5 {}
L 4 1262.5 -8407.5 1270 -8410 {}
L 4 1270 -8420 1270 -8410 {}
L 4 1272.5 -8412.5 1277.5 -8412.5 {}
L 4 1275 -8415 1275 -8410 {}
L 4 1360 -8295 1360 -8270 {}
L 4 1360 -8330 1360 -8305 {}
L 4 1350 -8305 1370 -8305 {}
L 4 1350 -8295 1370 -8295 {}
L 4 1362.5 -8322.5 1367.5 -8322.5 {}
L 4 1365 -8325 1365 -8320 {}
L 4 1032.5 -8262.5 1037.5 -8262.5 {}
L 4 1035 -8265 1035 -8260 {}
L 4 1030 -8270 1030 -8210 {}
L 4 1140 -8190 1140 -8177.5 {}
L 4 1135 -8177.5 1145 -8177.5 {}
L 4 1140 -8172.5 1145 -8177.5 {}
L 4 1135 -8177.5 1140 -8172.5 {}
L 4 1140 -8470 1140 -8450 {}
L 4 1130 -8470 1150 -8470 {}
L 4 1755 -8330 1755 -8270 {}
L 4 1755 -8320 1770 -8320 {}
L 4 1770 -8330 1770 -8320 {}
L 4 1755 -8280 1770 -8280 {}
L 4 1770 -8280 1770 -8270 {}
L 4 1745 -8315 1745 -8285 {}
L 4 1745 -8300 1745 -8295 {}
L 4 1730 -8300 1737.5 -8300 {}
L 4 1730 -8300 1745 -8300 {}
L 4 1760 -8300 1770 -8300 {}
L 4 1755 -8305 1760 -8300 {}
L 4 1755 -8295 1760 -8300 {}
L 4 1770 -8370 1770 -8360 {}
L 4 1770 -8370 1777.5 -8372.5 {}
L 4 1762.5 -8377.5 1777.5 -8372.5 {}
L 4 1762.5 -8377.5 1777.5 -8382.5 {}
L 4 1762.5 -8387.5 1777.5 -8382.5 {}
L 4 1762.5 -8387.5 1777.5 -8392.5 {}
L 4 1762.5 -8397.5 1777.5 -8392.5 {}
L 4 1762.5 -8397.5 1777.5 -8402.5 {}
L 4 1762.5 -8407.5 1777.5 -8402.5 {}
L 4 1762.5 -8407.5 1770 -8410 {}
L 4 1770 -8420 1770 -8410 {}
L 4 1772.5 -8412.5 1777.5 -8412.5 {}
L 4 1775 -8415 1775 -8410 {}
L 4 1860 -8295 1860 -8270 {}
L 4 1860 -8330 1860 -8305 {}
L 4 1850 -8305 1870 -8305 {}
L 4 1850 -8295 1870 -8295 {}
L 4 1862.5 -8322.5 1867.5 -8322.5 {}
L 4 1865 -8325 1865 -8320 {}
L 4 1532.5 -8262.5 1537.5 -8262.5 {}
L 4 1535 -8265 1535 -8260 {}
L 4 1530 -8270 1530 -8210 {}
L 4 1640 -8190 1640 -8177.5 {}
L 4 1635 -8177.5 1645 -8177.5 {}
L 4 1640 -8172.5 1645 -8177.5 {}
L 4 1635 -8177.5 1640 -8172.5 {}
L 4 1640 -8470 1640 -8450 {}
L 4 1630 -8470 1650 -8470 {}
L 4 2245 -8330 2245 -8270 {}
L 4 2245 -8320 2260 -8320 {}
L 4 2260 -8330 2260 -8320 {}
L 4 2245 -8280 2260 -8280 {}
L 4 2260 -8280 2260 -8270 {}
L 4 2235 -8315 2235 -8285 {}
L 4 2235 -8300 2235 -8295 {}
L 4 2220 -8300 2227.5 -8300 {}
L 4 2220 -8300 2235 -8300 {}
L 4 2250 -8300 2260 -8300 {}
L 4 2245 -8305 2250 -8300 {}
L 4 2245 -8295 2250 -8300 {}
L 4 2260 -8370 2260 -8360 {}
L 4 2260 -8370 2267.5 -8372.5 {}
L 4 2252.5 -8377.5 2267.5 -8372.5 {}
L 4 2252.5 -8377.5 2267.5 -8382.5 {}
L 4 2252.5 -8387.5 2267.5 -8382.5 {}
L 4 2252.5 -8387.5 2267.5 -8392.5 {}
L 4 2252.5 -8397.5 2267.5 -8392.5 {}
L 4 2252.5 -8397.5 2267.5 -8402.5 {}
L 4 2252.5 -8407.5 2267.5 -8402.5 {}
L 4 2252.5 -8407.5 2260 -8410 {}
L 4 2260 -8420 2260 -8410 {}
L 4 2262.5 -8412.5 2267.5 -8412.5 {}
L 4 2265 -8415 2265 -8410 {}
L 4 2350 -8295 2350 -8270 {}
L 4 2350 -8330 2350 -8305 {}
L 4 2340 -8305 2360 -8305 {}
L 4 2340 -8295 2360 -8295 {}
L 4 2352.5 -8322.5 2357.5 -8322.5 {}
L 4 2355 -8325 2355 -8320 {}
L 4 2022.5 -8262.5 2027.5 -8262.5 {}
L 4 2025 -8265 2025 -8260 {}
L 4 2020 -8270 2020 -8210 {}
L 4 2130 -8190 2130 -8177.5 {}
L 4 2125 -8177.5 2135 -8177.5 {}
L 4 2130 -8172.5 2135 -8177.5 {}
L 4 2125 -8177.5 2130 -8172.5 {}
L 4 2130 -8470 2130 -8450 {}
L 4 2120 -8470 2140 -8470 {}
L 4 420 -7485 420 -7460 {}
L 4 420 -7520 420 -7495 {}
L 4 410 -7495 430 -7495 {}
L 4 410 -7485 430 -7485 {}
L 4 422.5 -7512.5 427.5 -7512.5 {}
L 4 425 -7515 425 -7510 {}
L 4 620 -7485 620 -7460 {}
L 4 620 -7520 620 -7495 {}
L 4 610 -7495 630 -7495 {}
L 4 610 -7485 630 -7485 {}
L 4 622.5 -7512.5 627.5 -7512.5 {}
L 4 625 -7515 625 -7510 {}
L 4 860 -7485 860 -7460 {}
L 4 860 -7520 860 -7495 {}
L 4 850 -7495 870 -7495 {}
L 4 850 -7485 870 -7485 {}
L 4 862.5 -7512.5 867.5 -7512.5 {}
L 4 865 -7515 865 -7510 {}
L 4 1150 -7485 1150 -7460 {}
L 4 1150 -7520 1150 -7495 {}
L 4 1140 -7495 1160 -7495 {}
L 4 1140 -7485 1160 -7485 {}
L 4 1152.5 -7512.5 1157.5 -7512.5 {}
L 4 1155 -7515 1155 -7510 {}
L 4 1380 -7485 1380 -7460 {}
L 4 1380 -7520 1380 -7495 {}
L 4 1370 -7495 1390 -7495 {}
L 4 1370 -7485 1390 -7485 {}
L 4 1382.5 -7512.5 1387.5 -7512.5 {}
L 4 1385 -7515 1385 -7510 {}
L 4 1670 -7485 1670 -7460 {}
L 4 1670 -7520 1670 -7495 {}
L 4 1660 -7495 1680 -7495 {}
L 4 1660 -7485 1680 -7485 {}
L 4 1672.5 -7512.5 1677.5 -7512.5 {}
L 4 1675 -7515 1675 -7510 {}
L 4 1910 -7485 1910 -7460 {}
L 4 1910 -7520 1910 -7495 {}
L 4 1900 -7495 1920 -7495 {}
L 4 1900 -7485 1920 -7485 {}
L 4 1912.5 -7512.5 1917.5 -7512.5 {}
L 4 1915 -7515 1915 -7510 {}
L 4 2210 -7485 2210 -7460 {}
L 4 2210 -7520 2210 -7495 {}
L 4 2200 -7495 2220 -7495 {}
L 4 2200 -7485 2220 -7485 {}
L 4 2212.5 -7512.5 2217.5 -7512.5 {}
L 4 2215 -7515 2215 -7510 {}
L 4 2360 -7470 2360 -7460 {}
L 4 2360 -7470 2367.5 -7472.5 {}
L 4 2352.5 -7477.5 2367.5 -7472.5 {}
L 4 2352.5 -7477.5 2367.5 -7482.5 {}
L 4 2352.5 -7487.5 2367.5 -7482.5 {}
L 4 2352.5 -7487.5 2367.5 -7492.5 {}
L 4 2352.5 -7497.5 2367.5 -7492.5 {}
L 4 2352.5 -7497.5 2367.5 -7502.5 {}
L 4 2352.5 -7507.5 2367.5 -7502.5 {}
L 4 2352.5 -7507.5 2360 -7510 {}
L 4 2360 -7520 2360 -7510 {}
L 4 2362.5 -7512.5 2367.5 -7512.5 {}
L 4 2365 -7515 2365 -7510 {}
L 4 2420 -7485 2420 -7460 {}
L 4 2420 -7520 2420 -7495 {}
L 4 2410 -7495 2430 -7495 {}
L 4 2410 -7485 2430 -7485 {}
L 4 2422.5 -7512.5 2427.5 -7512.5 {}
L 4 2425 -7515 2425 -7510 {}
L 4 1120 -6410 1120 -6350 {}
L 5 1105 -9550 1110 -9550 {}
L 5 1410 -9580 1418.75 -9580 {}
L 5 1645 -9550 1650 -9550 {}
L 5 1950 -9580 1958.75 -9580 {}
L 5 575 -9550 580 -9550 {}
L 5 880 -9580 888.75 -9580 {}
L 5 575 -9090 580 -9090 {}
L 5 880 -9120 888.75 -9120 {}
L 5 1115 -9090 1120 -9090 {}
L 5 1420 -9120 1428.75 -9120 {}
L 5 575 -5500 580 -5500 {}
L 5 880 -5530 888.75 -5530 {}
L 5 1115 -5500 1120 -5500 {}
L 5 1420 -5530 1428.75 -5530 {}
L 5 575 -5100 580 -5100 {}
L 5 880 -5130 888.75 -5130 {}
L 5 1115 -5100 1120 -5100 {}
L 5 1420 -5130 1428.75 -5130 {}
L 5 575 -4660 580 -4660 {}
L 5 1765 -4660 1770 -4660 {}
L 5 1135 -4660 1140 -4660 {}
L 5 1105 -8720 1110 -8720 {}
L 5 1410 -8750 1418.75 -8750 {}
L 5 575 -8720 580 -8720 {}
L 5 880 -8750 888.75 -8750 {}
L 5 1605 -8720 1610 -8720 {}
L 5 1910 -8750 1918.75 -8750 {}
L 5 1645 -10020 1650 -10020 {}
L 5 1950 -10050 1958.75 -10050 {}
L 5 520 -10020 525 -10020 {}
L 5 825 -10050 833.75 -10050 {}
L 5 2105 -10020 2110 -10020 {}
L 5 2410 -10050 2418.75 -10050 {}
L 5 595 -7880 600 -7880 {}
L 5 900 -7910 908.75 -7910 {}
L 5 1135 -7880 1140 -7880 {}
L 5 1440 -7910 1448.75 -7910 {}
L 5 2265 -7880 2270 -7880 {}
L 5 2570 -7910 2578.75 -7910 {}
L 5 1105 -10020 1110 -10020 {}
L 5 1410 -10050 1418.75 -10050 {}
L 5 655 -190 660 -190 {}
L 5 960 -220 968.75 -220 {}
L 5 1255 -190 1260 -190 {}
L 5 1560 -220 1568.75 -220 {}
L 5 1865 -190 1870 -190 {}
L 5 2170 -220 2178.75 -220 {}
L 5 595 -4250 600 -4250 {}
L 5 900 -4280 908.75 -4280 {}
L 5 1155 -4250 1160 -4250 {}
L 5 1460 -4280 1468.75 -4280 {}
L 5 540 -8300 545 -8300 {}
L 5 845 -8330 853.75 -8330 {}
L 5 1105 -8300 1110 -8300 {}
L 5 1410 -8330 1418.75 -8330 {}
L 5 1605 -8300 1610 -8300 {}
L 5 1910 -8330 1918.75 -8330 {}
L 5 2095 -8300 2100 -8300 {}
L 5 2400 -8330 2408.75 -8330 {}
L 6 1110 -9550 1230 -9550 {}
L 6 1030 -9700 1270 -9700 {}
L 6 1270 -9580 1410 -9580 {}
L 6 1030 -9460 1030 -9440 {}
L 6 1030 -9700 1030 -9520 {}
L 6 1030 -9440 1270 -9440 {}
L 6 1650 -9550 1770 -9550 {}
L 6 1570 -9700 1810 -9700 {}
L 6 1810 -9580 1950 -9580 {}
L 6 1570 -9460 1570 -9440 {}
L 6 1570 -9700 1570 -9520 {}
L 6 1570 -9440 1810 -9440 {}
L 6 580 -9550 700 -9550 {}
L 6 500 -9700 740 -9700 {}
L 6 740 -9580 880 -9580 {}
L 6 500 -9460 500 -9440 {}
L 6 500 -9700 500 -9520 {}
L 6 500 -9440 740 -9440 {}
L 6 580 -9090 700 -9090 {}
L 6 740 -9150 740 -9120 {}
L 6 740 -9240 740 -9210 {}
L 6 500 -9240 740 -9240 {}
L 6 740 -9120 880 -9120 {}
L 6 830 -9060 830 -8980 {}
L 6 500 -9000 500 -8980 {}
L 6 500 -9240 500 -9060 {}
L 6 740 -9090 740 -8980 {}
L 6 740 -8980 830 -8980 {}
L 6 500 -8980 740 -8980 {}
L 6 1120 -9090 1240 -9090 {}
L 6 1280 -9150 1280 -9120 {}
L 6 1280 -9240 1280 -9210 {}
L 6 1040 -9240 1280 -9240 {}
L 6 1280 -9120 1420 -9120 {}
L 6 1370 -9060 1370 -8980 {}
L 6 1040 -9000 1040 -8980 {}
L 6 1040 -9240 1040 -9060 {}
L 6 1280 -9090 1280 -8980 {}
L 6 1280 -8980 1370 -8980 {}
L 6 1040 -8980 1280 -8980 {}
L 6 580 -5500 700 -5500 {}
L 6 740 -5560 740 -5530 {}
L 6 740 -5650 740 -5620 {}
L 6 500 -5650 740 -5650 {}
L 6 740 -5530 880 -5530 {}
L 6 830 -5470 830 -5390 {}
L 6 500 -5410 500 -5390 {}
L 6 500 -5650 500 -5470 {}
L 6 740 -5500 740 -5390 {}
L 6 740 -5390 830 -5390 {}
L 6 500 -5390 740 -5390 {}
L 6 1120 -5500 1240 -5500 {}
L 6 1280 -5560 1280 -5530 {}
L 6 1280 -5650 1280 -5620 {}
L 6 1040 -5650 1280 -5650 {}
L 6 1280 -5530 1420 -5530 {}
L 6 1370 -5470 1370 -5390 {}
L 6 1040 -5410 1040 -5390 {}
L 6 1040 -5650 1040 -5470 {}
L 6 1280 -5500 1280 -5390 {}
L 6 1280 -5390 1370 -5390 {}
L 6 1040 -5390 1280 -5390 {}
L 6 580 -5100 700 -5100 {}
L 6 740 -5160 740 -5130 {}
L 6 740 -5250 740 -5220 {}
L 6 500 -5250 740 -5250 {}
L 6 740 -5130 880 -5130 {}
L 6 830 -5070 830 -4990 {}
L 6 500 -5010 500 -4990 {}
L 6 500 -5250 500 -5070 {}
L 6 740 -5100 740 -4990 {}
L 6 740 -4990 830 -4990 {}
L 6 500 -4990 740 -4990 {}
L 6 1120 -5100 1240 -5100 {}
L 6 1040 -5250 1280 -5250 {}
L 6 1280 -5130 1420 -5130 {}
L 6 1370 -5070 1370 -4990 {}
L 6 1040 -5010 1040 -4990 {}
L 6 1040 -5250 1040 -5070 {}
L 6 1280 -5100 1280 -4990 {}
L 6 1280 -4990 1370 -4990 {}
L 6 1040 -4990 1280 -4990 {}
L 6 580 -4660 700 -4660 {}
L 6 500 -4810 740 -4810 {}
L 6 500 -4570 500 -4550 {}
L 6 500 -4810 500 -4630 {}
L 6 500 -4550 740 -4550 {}
L 6 1690 -4570 1690 -4550 {}
L 6 1690 -4810 1690 -4630 {}
L 6 1140 -4660 1260 -4660 {}
L 6 1060 -4570 1060 -4550 {}
L 6 1060 -4810 1060 -4630 {}
L 6 1110 -8720 1230 -8720 {}
L 6 1030 -8870 1270 -8870 {}
L 6 1270 -8750 1410 -8750 {}
L 6 1030 -8630 1030 -8610 {}
L 6 1030 -8870 1030 -8690 {}
L 6 1030 -8610 1270 -8610 {}
L 6 580 -8720 700 -8720 {}
L 6 500 -8870 740 -8870 {}
L 6 740 -8750 880 -8750 {}
L 6 500 -8630 500 -8610 {}
L 6 500 -8870 500 -8690 {}
L 6 500 -8610 740 -8610 {}
L 6 1610 -8720 1730 -8720 {}
L 6 1770 -8780 1770 -8750 {}
L 6 1770 -8870 1770 -8840 {}
L 6 1530 -8870 1770 -8870 {}
L 6 1770 -8750 1910 -8750 {}
L 6 1860 -8690 1860 -8610 {}
L 6 1530 -8630 1530 -8610 {}
L 6 1530 -8870 1530 -8690 {}
L 6 1770 -8720 1770 -8610 {}
L 6 1770 -8610 1860 -8610 {}
L 6 1530 -8610 1770 -8610 {}
L 6 1650 -10020 1770 -10020 {}
L 6 1570 -10170 1810 -10170 {}
L 6 1810 -10050 1950 -10050 {}
L 6 1570 -9910 1810 -9910 {}
L 6 525 -10020 645 -10020 {}
L 6 445 -10170 685 -10170 {}
L 6 685 -10050 825 -10050 {}
L 6 445 -9930 445 -9910 {}
L 6 445 -10170 445 -9990 {}
L 6 445 -9910 685 -9910 {}
L 6 2110 -10020 2230 -10020 {}
L 6 2030 -10170 2270 -10170 {}
L 6 2270 -10050 2410 -10050 {}
L 6 2030 -9910 2270 -9910 {}
L 6 2360 -9990 2360 -9910 {}
L 6 600 -7880 720 -7880 {}
L 6 760 -7940 760 -7910 {}
L 6 760 -8030 760 -8000 {}
L 6 760 -7910 900 -7910 {}
L 6 850 -7850 850 -7770 {}
L 6 520 -7790 520 -7770 {}
L 6 520 -8030 520 -7850 {}
L 6 760 -7880 760 -7770 {}
L 6 760 -7770 850 -7770 {}
L 6 520 -7770 760 -7770 {}
L 6 1140 -7880 1260 -7880 {}
L 6 1300 -7940 1300 -7910 {}
L 6 1300 -8030 1300 -8000 {}
L 6 1300 -7910 1440 -7910 {}
L 6 1390 -7850 1390 -7770 {}
L 6 1060 -7790 1060 -7770 {}
L 6 1060 -8030 1060 -7850 {}
L 6 1300 -7880 1300 -7770 {}
L 6 1300 -7770 1390 -7770 {}
L 6 1060 -7770 1300 -7770 {}
L 6 2270 -7880 2390 -7880 {}
L 6 2430 -7940 2430 -7910 {}
L 6 2430 -8030 2430 -8000 {}
L 6 2430 -7910 2570 -7910 {}
L 6 2520 -7850 2520 -7770 {}
L 6 2190 -7790 2190 -7770 {}
L 6 2190 -8030 2190 -7850 {}
L 6 2430 -7880 2430 -7770 {}
L 6 2430 -7770 2520 -7770 {}
L 6 2190 -7770 2430 -7770 {}
L 6 690 -2790 690 -2610 {}
L 6 1230 -2790 1230 -2610 {}
L 6 1880 -2790 1880 -2730 {}
L 6 1880 -2670 1880 -2610 {}
L 6 1110 -10020 1230 -10020 {}
L 6 1030 -10170 1270 -10170 {}
L 6 1270 -10050 1410 -10050 {}
L 6 1030 -9910 1270 -9910 {}
L 6 1030 -9930 1030 -9910 {}
L 6 1030 -10170 1030 -9990 {}
L 6 660 -190 780 -190 {}
L 6 820 -250 820 -220 {}
L 6 820 -340 820 -310 {}
L 6 580 -340 820 -340 {}
L 6 820 -220 960 -220 {}
L 6 910 -160 910 -80 {}
L 6 580 -100 580 -80 {}
L 6 580 -340 580 -160 {}
L 6 820 -190 820 -80 {}
L 6 820 -80 910 -80 {}
L 6 580 -80 820 -80 {}
L 6 1260 -190 1380 -190 {}
L 6 1420 -250 1420 -220 {}
L 6 1420 -340 1420 -310 {}
L 6 1180 -340 1420 -340 {}
L 6 1180 -340 1180 -160 {}
L 6 1870 -190 1990 -190 {}
L 6 2030 -250 2030 -220 {}
L 6 2030 -340 2030 -310 {}
L 6 1790 -340 2030 -340 {}
L 6 1790 -340 1790 -160 {}
L 6 600 -4250 720 -4250 {}
L 6 760 -4310 760 -4280 {}
L 6 760 -4400 760 -4370 {}
L 6 520 -4400 760 -4400 {}
L 6 760 -4280 900 -4280 {}
L 6 520 -4160 520 -4140 {}
L 6 520 -4400 520 -4220 {}
L 6 760 -4250 760 -4140 {}
L 6 760 -4140 850 -4140 {}
L 6 520 -4140 760 -4140 {}
L 6 1160 -4250 1280 -4250 {}
L 6 1320 -4310 1320 -4280 {}
L 6 1320 -4400 1320 -4370 {}
L 6 1080 -4400 1320 -4400 {}
L 6 1320 -4280 1460 -4280 {}
L 6 1080 -4160 1080 -4140 {}
L 6 1080 -4400 1080 -4220 {}
L 6 1320 -4250 1320 -4140 {}
L 6 1320 -4140 1410 -4140 {}
L 6 1080 -4140 1320 -4140 {}
L 6 545 -8300 665 -8300 {}
L 6 705 -8360 705 -8330 {}
L 6 705 -8450 705 -8420 {}
L 6 795 -8270 795 -8190 {}
L 6 465 -8210 465 -8190 {}
L 6 465 -8450 465 -8270 {}
L 6 705 -8300 705 -8190 {}
L 6 705 -8190 795 -8190 {}
L 6 465 -8190 705 -8190 {}
L 6 1110 -8300 1230 -8300 {}
L 6 1270 -8360 1270 -8330 {}
L 6 1270 -8450 1270 -8420 {}
L 6 1360 -8270 1360 -8190 {}
L 6 1030 -8210 1030 -8190 {}
L 6 1030 -8450 1030 -8270 {}
L 6 1270 -8300 1270 -8190 {}
L 6 1270 -8190 1360 -8190 {}
L 6 1030 -8190 1270 -8190 {}
L 6 1610 -8300 1730 -8300 {}
L 6 1770 -8360 1770 -8330 {}
L 6 1770 -8450 1770 -8420 {}
L 6 1860 -8270 1860 -8190 {}
L 6 1530 -8210 1530 -8190 {}
L 6 1530 -8450 1530 -8270 {}
L 6 1770 -8300 1770 -8190 {}
L 6 1770 -8190 1860 -8190 {}
L 6 1530 -8190 1770 -8190 {}
L 6 2100 -8300 2220 -8300 {}
L 6 2260 -8360 2260 -8330 {}
L 6 2260 -8450 2260 -8420 {}
L 6 2350 -8270 2350 -8190 {}
L 6 2020 -8210 2020 -8190 {}
L 6 2020 -8450 2020 -8270 {}
L 6 2260 -8300 2260 -8190 {}
L 6 2260 -8190 2350 -8190 {}
L 6 2020 -8190 2260 -8190 {}
L 7 600 -6050 620 -6050 {dash=3}
L 7 610 -6060 610 -6040 {dash=3}
L 7 600 -5920 620 -5920 {dash=3}
L 7 610 -5930 610 -5910 {dash=3}
L 7 600 -5810 620 -5810 {dash=3}
L 7 610 -5820 610 -5800 {dash=3}
L 7 920 -6050 940 -6050 {dash=3}
L 7 930 -6060 930 -6040 {dash=3}
L 7 920 -5920 940 -5920 {dash=3}
L 7 930 -5930 930 -5910 {dash=3}
L 7 920 -5810 940 -5810 {dash=3}
L 7 930 -5820 930 -5800 {dash=3}
L 9 0 -4950 2670 -4950 {dash=4}
L 9 0 -5340 2670 -5340 {dash=4}
L 9 0 -8500 2670 -8500 {dash=4}
L 9 0 -9330 2670 -9330 {dash=4}
L 9 0 -8940 2670 -8940 {dash=4}
L 9 0 -9780 2670 -9780 {dash=4}
L 9 0 -3660 2670 -3660 {dash=4}
L 9 0 -4040 2670 -4040 {dash=4}
L 9 0 -4470 2670 -4470 {dash=4}
L 9 0 -3240 2670 -3240 {dash=4}
L 9 0 -2860 2670 -2860 {dash=4}
L 9 0 -830 2670 -830 {dash=4}
L 9 0 -2540 2670 -2540 {dash=4}
L 9 0 -1600 2670 -1600 {dash=4}
L 9 0 -1230 2670 -1230 {dash=4}
L 9 0 -430 2670 -430 {dash=4}
L 9 0 0 2670 0 {dash=4}
L 9 0 -2310 2670 -2310 {dash=4}
L 9 0 -1940 2670 -1940 {dash=4}
L 9 0 -7720 2670 -7720 {dash=4}
L 9 0 -8150 2670 -8150 {dash=4}
L 9 0 -7330 2670 -7330 {dash=4}
L 9 0 -6940 2670 -6940 {dash=4}
L 9 0 -6520 2670 -6520 {dash=4}
L 9 0 -6130 2670 -6130 {dash=4}
L 9 0 -5730 2670 -5730 {dash=4}
L 9 490 -7650 490 -7400 {dash=4}
L 9 710 -7650 710 -7400 {dash=4}
L 9 1000 -7650 1000 -7400 {dash=4}
L 9 1240 -7650 1240 -7400 {dash=4}
L 9 1520 -7650 1520 -7400 {dash=4}
L 9 1760 -7650 1760 -7400 {dash=4}
L 9 2070 -7650 2070 -7400 {dash=4}
L 9 2310 -7650 2310 -7400 {dash=4}
L 9 980 -8445 980 -8195 {dash=4}
L 9 1490 -8445 1490 -8195 {dash=4}
L 9 1965 -8445 1965 -8195 {dash=4}
L 9 975 -8855 975 -8605 {dash=4}
L 9 1460 -8855 1460 -8605 {dash=4}
L 9 930 -10145 930 -9895 {dash=4}
L 9 1475 -10145 1475 -9895 {dash=4}
L 9 1990 -10145 1990 -9895 {dash=4}
L 9 975 -9695 975 -9445 {dash=4}
L 9 1480 -9695 1480 -9445 {dash=4}
L 9 960 -9255 960 -9005 {dash=4}
L 9 970 -8035 970 -7785 {dash=4}
L 9 1545 -8035 1545 -7785 {dash=4}
L 9 2070 -8035 2070 -7785 {dash=4}
L 9 920 -6870 920 -6620 {dash=4}
L 9 1435 -6870 1435 -6620 {dash=4}
L 9 920 -6455 920 -6205 {dash=4}
L 9 1435 -6455 1435 -6205 {dash=4}
L 9 765 -6060 765 -5810 {dash=4}
L 9 960 -5660 960 -5410 {dash=4}
L 9 955 -5280 955 -5030 {dash=4}
L 9 1000 -4840 1000 -4590 {dash=4}
L 9 1610 -4840 1610 -4590 {dash=4}
L 9 990 -4400 990 -4150 {dash=4}
L 9 1080 -3950 1080 -3700 {dash=4}
L 9 1650 -3950 1650 -3700 {dash=4}
L 9 1080 -3560 1080 -3310 {dash=4}
L 9 1650 -3560 1650 -3310 {dash=4}
L 9 2230 -3560 2230 -3310 {dash=4}
L 9 1080 -3180 1080 -2930 {dash=4}
L 9 1680 -3180 1680 -2930 {dash=4}
L 9 2230 -3180 2230 -2930 {dash=4}
L 9 960 -2830 960 -2580 {dash=4}
L 9 1480 -2820 1480 -2570 {dash=4}
L 9 970 -2470 970 -2360 {dash=4}
L 9 1610 -2470 1610 -2360 {dash=4}
L 9 2130 -2470 2130 -2360 {dash=4}
L 9 1000 -2230 1000 -1980 {dash=4}
L 9 1620 -2230 1620 -1980 {dash=4}
L 9 2160 -2230 2160 -1980 {dash=4}
L 9 990 -1870 990 -1620 {dash=4}
L 9 1580 -1870 1580 -1620 {dash=4}
L 9 2210 -1870 2210 -1620 {dash=4}
L 9 1000 -1550 1000 -1300 {dash=4}
L 9 1570 -1550 1570 -1300 {dash=4}
L 9 1070 -1140 1070 -890 {dash=4}
L 9 1680 -1140 1680 -890 {dash=4}
L 9 1060 -750 1060 -500 {dash=4}
L 9 1660 -750 1660 -500 {dash=4}
L 9 1060 -360 1060 -110 {dash=4}
L 9 1720 -360 1720 -110 {dash=4}
B 1 1790 -7940 1820 -7790 {}
B 2 660 -9720 860 -9400 {}
B 2 1267.5 -9582.5 1272.5 -9577.5 {name=d dir=inout}
B 2 1227.5 -9552.5 1232.5 -9547.5 {name=g dir=in}
B 2 1267.5 -9522.5 1272.5 -9517.5 {name=s dir=inout}
B 2 1267.5 -9552.5 1272.5 -9547.5 {name=b dir=in}
B 2 1267.5 -9672.5 1272.5 -9667.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -9612.5 1272.5 -9607.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -9582.5 1362.5 -9577.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -9522.5 1362.5 -9517.5 {name=m dir=inout pinnumber=2}
B 2 2047.5 -9592.5 2052.5 -9587.5 {name=d dir=inout}
B 2 2007.5 -9562.5 2012.5 -9557.5 {name=g dir=in}
B 2 2047.5 -9532.5 2052.5 -9527.5 {name=s dir=inout}
B 2 2047.5 -9562.5 2052.5 -9557.5 {name=b dir=in}
B 2 2047.5 -9682.5 2052.5 -9677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2047.5 -9622.5 2052.5 -9617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2137.5 -9592.5 2142.5 -9587.5 {name=p dir=inout pinnumber=1}
B 2 2137.5 -9532.5 2142.5 -9527.5 {name=m dir=inout pinnumber=2}
B 2 1357.5 -9212.5 1362.5 -9207.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -9152.5 1362.5 -9147.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -5622.5 1362.5 -5617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -5562.5 1362.5 -5557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -5222.5 1362.5 -5217.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -5162.5 1362.5 -5157.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 660 -4840 900 -4520 {}
B 2 737.5 -9582.5 742.5 -9577.5 {name=d dir=inout}
B 2 737.5 -9522.5 742.5 -9517.5 {name=s dir=inout}
B 2 737.5 -9552.5 742.5 -9547.5 {name=b dir=in}
B 2 737.5 -9672.5 742.5 -9667.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -9612.5 742.5 -9607.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -9582.5 832.5 -9577.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -9522.5 832.5 -9517.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -4692.5 742.5 -4687.5 {name=d dir=inout}
B 2 737.5 -4632.5 742.5 -4627.5 {name=s dir=inout}
B 2 737.5 -4662.5 742.5 -4657.5 {name=b dir=in}
B 2 737.5 -4782.5 742.5 -4777.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -4722.5 742.5 -4717.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -4692.5 832.5 -4687.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -4632.5 832.5 -4627.5 {name=m dir=inout pinnumber=2}
B 2 878.75 -4691.25 881.25 -4688.75 {name=p dir=in}
B 2 1297.5 -4692.5 1302.5 -4687.5 {name=d dir=inout}
B 2 1257.5 -4662.5 1262.5 -4657.5 {name=g dir=in}
B 2 1297.5 -4632.5 1302.5 -4627.5 {name=s dir=inout}
B 2 1297.5 -4662.5 1302.5 -4657.5 {name=b dir=in}
B 2 1297.5 -4782.5 1302.5 -4777.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1297.5 -4722.5 1302.5 -4717.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1387.5 -4692.5 1392.5 -4687.5 {name=p dir=inout pinnumber=1}
B 2 1387.5 -4632.5 1392.5 -4627.5 {name=m dir=inout pinnumber=2}
B 2 1438.75 -4691.25 1441.25 -4688.75 {name=p dir=in}
B 2 2117.5 -4692.5 2122.5 -4687.5 {name=d dir=inout}
B 2 2077.5 -4662.5 2082.5 -4657.5 {name=g dir=in}
B 2 2117.5 -4632.5 2122.5 -4627.5 {name=s dir=inout}
B 2 2117.5 -4662.5 2122.5 -4657.5 {name=b dir=in}
B 2 2117.5 -4782.5 2122.5 -4777.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2117.5 -4722.5 2122.5 -4717.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2207.5 -4692.5 2212.5 -4687.5 {name=p dir=inout pinnumber=1}
B 2 2207.5 -4632.5 2212.5 -4627.5 {name=m dir=inout pinnumber=2}
B 2 2258.75 -4691.25 2261.25 -4688.75 {name=p dir=in}
B 2 660 -8890 860 -8570 {}
B 2 1267.5 -8752.5 1272.5 -8747.5 {name=d dir=inout}
B 2 1227.5 -8722.5 1232.5 -8717.5 {name=g dir=in}
B 2 1267.5 -8692.5 1272.5 -8687.5 {name=s dir=inout}
B 2 1267.5 -8722.5 1272.5 -8717.5 {name=b dir=in}
B 2 1267.5 -8842.5 1272.5 -8837.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -8782.5 1272.5 -8777.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -8752.5 1362.5 -8747.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -8692.5 1362.5 -8687.5 {name=m dir=inout pinnumber=2}
B 2 2047.5 -8762.5 2052.5 -8757.5 {name=d dir=inout}
B 2 2007.5 -8732.5 2012.5 -8727.5 {name=g dir=in}
B 2 2047.5 -8702.5 2052.5 -8697.5 {name=s dir=inout}
B 2 2047.5 -8732.5 2052.5 -8727.5 {name=b dir=in}
B 2 2047.5 -8852.5 2052.5 -8847.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2047.5 -8792.5 2052.5 -8787.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2137.5 -8762.5 2142.5 -8757.5 {name=p dir=inout pinnumber=1}
B 2 2137.5 -8702.5 2142.5 -8697.5 {name=m dir=inout pinnumber=2}
B 2 737.5 -8752.5 742.5 -8747.5 {name=d dir=inout}
B 2 737.5 -8692.5 742.5 -8687.5 {name=s dir=inout}
B 2 737.5 -8722.5 742.5 -8717.5 {name=b dir=in}
B 2 737.5 -8842.5 742.5 -8837.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 737.5 -8782.5 742.5 -8777.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 827.5 -8752.5 832.5 -8747.5 {name=p dir=inout pinnumber=1}
B 2 827.5 -8692.5 832.5 -8687.5 {name=m dir=inout pinnumber=2}
B 2 605 -10190 805 -9870 {}
B 2 1807.5 -10052.5 1812.5 -10047.5 {name=d dir=inout}
B 2 1767.5 -10022.5 1772.5 -10017.5 {name=g dir=in}
B 2 1807.5 -9992.5 1812.5 -9987.5 {name=s dir=inout}
B 2 1807.5 -10022.5 1812.5 -10017.5 {name=b dir=in}
B 2 1807.5 -10142.5 1812.5 -10137.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1807.5 -10082.5 1812.5 -10077.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -10052.5 1902.5 -10047.5 {name=p dir=inout pinnumber=1}
B 2 1897.5 -9992.5 1902.5 -9987.5 {name=m dir=inout pinnumber=2}
B 2 682.5 -10052.5 687.5 -10047.5 {name=d dir=inout}
B 2 682.5 -9992.5 687.5 -9987.5 {name=s dir=inout}
B 2 682.5 -10022.5 687.5 -10017.5 {name=b dir=in}
B 2 682.5 -10142.5 687.5 -10137.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 682.5 -10082.5 687.5 -10077.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 772.5 -10052.5 777.5 -10047.5 {name=p dir=inout pinnumber=1}
B 2 772.5 -9992.5 777.5 -9987.5 {name=m dir=inout pinnumber=2}
B 2 1530 -10180 1610 -9900 {}
B 2 1567.5 -9992.5 1572.5 -9987.5 {name=p dir=inout}
B 2 1567.5 -9932.5 1572.5 -9927.5 {name=m dir=inout}
B 2 2267.5 -10052.5 2272.5 -10047.5 {name=d dir=inout}
B 2 2227.5 -10022.5 2232.5 -10017.5 {name=g dir=in}
B 2 2267.5 -9992.5 2272.5 -9987.5 {name=s dir=inout}
B 2 2267.5 -10022.5 2272.5 -10017.5 {name=b dir=in}
B 2 2267.5 -10142.5 2272.5 -10137.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2267.5 -10082.5 2272.5 -10077.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2027.5 -9992.5 2032.5 -9987.5 {name=p dir=inout}
B 2 2027.5 -9932.5 2032.5 -9927.5 {name=m dir=inout}
B 2 2320 -10070 2390 -9890 {}
B 2 1670 -7970 1820 -7940 {}
B 2 1357.5 -3822.5 1362.5 -3817.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -3762.5 1362.5 -3757.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1210 -3150 1500 -3080 {}
B 2 1210 -1070 1500 -990 {}
B 2 1247.5 -1062.5 1252.5 -1057.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1247.5 -1002.5 1252.5 -997.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -1062.5 1362.5 -1057.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -1002.5 1362.5 -997.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1467.5 -1062.5 1472.5 -1057.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1467.5 -1002.5 1472.5 -997.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1787.5 -1112.5 1792.5 -1107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1787.5 -1052.5 1792.5 -1047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -1112.5 1902.5 -1107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1897.5 -1052.5 1902.5 -1047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2007.5 -1112.5 2012.5 -1107.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2007.5 -1052.5 2012.5 -1047.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 647.5 -2732.5 652.5 -2727.5 {name=d dir=inout}
B 2 607.5 -2702.5 612.5 -2697.5 {name=g dir=in}
B 2 647.5 -2672.5 652.5 -2667.5 {name=s dir=inout}
B 2 647.5 -2702.5 652.5 -2697.5 {name=b dir=in}
B 2 1227.5 -2732.5 1232.5 -2727.5 {name=d dir=inout}
B 2 1187.5 -2702.5 1192.5 -2697.5 {name=g dir=in}
B 2 1227.5 -2672.5 1232.5 -2667.5 {name=s dir=inout}
B 2 1227.5 -2702.5 1232.5 -2697.5 {name=b dir=in}
B 2 1267.5 -10052.5 1272.5 -10047.5 {name=d dir=inout}
B 2 1227.5 -10022.5 1232.5 -10017.5 {name=g dir=in}
B 2 1267.5 -9992.5 1272.5 -9987.5 {name=s dir=inout}
B 2 1267.5 -10022.5 1272.5 -10017.5 {name=b dir=in}
B 2 1267.5 -10142.5 1272.5 -10137.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1267.5 -10082.5 1272.5 -10077.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -10052.5 1362.5 -10047.5 {name=p dir=inout pinnumber=1}
B 2 1357.5 -9992.5 1362.5 -9987.5 {name=m dir=inout pinnumber=2}
B 2 1210 -690 1500 -610 {}
B 2 1247.5 -682.5 1252.5 -677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1247.5 -622.5 1252.5 -617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1357.5 -682.5 1362.5 -677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1357.5 -622.5 1362.5 -617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1467.5 -682.5 1472.5 -677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1467.5 -622.5 1472.5 -617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1787.5 -732.5 1792.5 -727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1787.5 -672.5 1792.5 -667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1897.5 -732.5 1902.5 -727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1897.5 -672.5 1902.5 -667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 2007.5 -732.5 2012.5 -727.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 2007.5 -672.5 2012.5 -667.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 677.5 -1502.5 682.5 -1497.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 677.5 -1442.5 682.5 -1437.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 797.5 -1502.5 802.5 -1497.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1217.5 -1502.5 1222.5 -1497.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1217.5 -1442.5 1222.5 -1437.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1337.5 -1502.5 1342.5 -1497.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1337.5 -1442.5 1342.5 -1437.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1507.5 -222.5 1512.5 -217.5 {name=p dir=inout pinnumber=1}
B 2 1507.5 -162.5 1512.5 -157.5 {name=m dir=inout pinnumber=2}
B 2 2427.5 -402.5 2432.5 -397.5 {name=p dir=inout pinnumber=1}
B 2 2427.5 -342.5 2432.5 -337.5 {name=m dir=inout pinnumber=2}
B 2 820 -4300 870 -4120 {}
B 2 847.5 -4282.5 852.5 -4277.5 {name=p dir=inout pinnumber=1}
B 2 847.5 -4222.5 852.5 -4217.5 {name=m dir=inout pinnumber=2}
B 2 1707.5 -4282.5 1712.5 -4277.5 {name=p dir=inout pinnumber=1}
B 2 1707.5 -4222.5 1712.5 -4217.5 {name=m dir=inout pinnumber=2}
B 2 2467.5 -4282.5 2472.5 -4277.5 {name=p dir=inout pinnumber=1}
B 2 2467.5 -4222.5 2472.5 -4217.5 {name=m dir=inout pinnumber=2}
B 2 527.5 -7272.5 532.5 -7267.5 {name=d dir=inout}
B 2 487.5 -7242.5 492.5 -7237.5 {name=g dir=in}
B 2 527.5 -7212.5 532.5 -7207.5 {name=s dir=inout}
B 2 527.5 -7242.5 532.5 -7237.5 {name=b dir=in}
B 2 458.75 -7241.25 461.25 -7238.75 {name=p dir=out}
B 2 847.5 -7172.5 852.5 -7167.5 {name=d dir=inout}
B 2 817.5 -7212.5 822.5 -7207.5 {name=g dir=in}
B 2 787.5 -7172.5 792.5 -7167.5 {name=s dir=inout}
B 2 817.5 -7172.5 822.5 -7167.5 {name=b dir=in}
B 2 818.75 -7241.25 821.25 -7238.75 {name=p dir=out}
B 2 1097.5 -7142.5 1102.5 -7137.5 {name=d dir=inout}
B 2 1137.5 -7172.5 1142.5 -7167.5 {name=g dir=in}
B 2 1097.5 -7202.5 1102.5 -7197.5 {name=s dir=inout}
B 2 1097.5 -7172.5 1102.5 -7167.5 {name=b dir=in}
B 2 1168.75 -7171.25 1171.25 -7168.75 {name=p dir=out}
B 2 1377.5 -7252.5 1382.5 -7247.5 {name=d dir=inout}
B 2 1407.5 -7212.5 1412.5 -7207.5 {name=g dir=in}
B 2 1437.5 -7252.5 1442.5 -7247.5 {name=s dir=inout}
B 2 1407.5 -7252.5 1412.5 -7247.5 {name=b dir=in}
B 2 1408.75 -7181.25 1411.25 -7178.75 {name=p dir=out}
B 2 1777.5 -7252.5 1782.5 -7247.5 {name=d dir=inout}
B 2 1747.5 -7212.5 1752.5 -7207.5 {name=g dir=in}
B 2 1717.5 -7252.5 1722.5 -7247.5 {name=s dir=inout}
B 2 1747.5 -7252.5 1752.5 -7247.5 {name=b dir=in}
B 2 1748.75 -7181.25 1751.25 -7178.75 {name=p dir=out}
B 2 2107.5 -7182.5 2112.5 -7177.5 {name=d dir=inout}
B 2 2077.5 -7222.5 2082.5 -7217.5 {name=g dir=in}
B 2 2047.5 -7182.5 2052.5 -7177.5 {name=s dir=inout}
B 2 2077.5 -7182.5 2082.5 -7177.5 {name=b dir=in}
B 2 2078.75 -7251.25 2081.25 -7248.75 {name=p dir=out}
B 2 767.5 -6772.5 772.5 -6767.5 {name=d dir=inout}
B 2 727.5 -6742.5 732.5 -6737.5 {name=g dir=in}
B 2 767.5 -6712.5 772.5 -6707.5 {name=s dir=inout}
B 2 767.5 -6742.5 772.5 -6737.5 {name=b dir=in}
B 2 767.5 -6862.5 772.5 -6857.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 767.5 -6802.5 772.5 -6797.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 857.5 -6772.5 862.5 -6767.5 {name=p dir=inout pinnumber=1}
B 2 857.5 -6712.5 862.5 -6707.5 {name=m dir=inout pinnumber=2}
B 2 527.5 -6712.5 532.5 -6707.5 {name=p dir=inout}
B 2 527.5 -6652.5 532.5 -6647.5 {name=m dir=inout}
B 2 608.75 -6741.25 611.25 -6738.75 {name=p dir=out}
B 2 637.5 -6632.5 642.5 -6627.5 {name=p dir=inout goto=0}
B 2 637.5 -6892.5 642.5 -6887.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1242.5 -6772.5 1247.5 -6767.5 {name=d dir=inout}
B 2 1202.5 -6742.5 1207.5 -6737.5 {name=g dir=in}
B 2 1242.5 -6712.5 1247.5 -6707.5 {name=s dir=inout}
B 2 1242.5 -6742.5 1247.5 -6737.5 {name=b dir=in}
B 2 1242.5 -6862.5 1247.5 -6857.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1242.5 -6802.5 1247.5 -6797.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1332.5 -6772.5 1337.5 -6767.5 {name=p dir=inout pinnumber=1}
B 2 1332.5 -6712.5 1337.5 -6707.5 {name=m dir=inout pinnumber=2}
B 2 1002.5 -6712.5 1007.5 -6707.5 {name=p dir=inout}
B 2 1002.5 -6652.5 1007.5 -6647.5 {name=m dir=inout}
B 2 1083.75 -6741.25 1086.25 -6738.75 {name=p dir=out}
B 2 1112.5 -6632.5 1117.5 -6627.5 {name=p dir=inout goto=0}
B 2 1112.5 -6892.5 1117.5 -6887.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1727.5 -6652.5 1732.5 -6647.5 {name=d dir=inout}
B 2 1697.5 -6692.5 1702.5 -6687.5 {name=g dir=in}
B 2 1667.5 -6652.5 1672.5 -6647.5 {name=s dir=inout}
B 2 1697.5 -6652.5 1702.5 -6647.5 {name=b dir=in}
B 2 1817.5 -6652.5 1822.5 -6647.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1757.5 -6652.5 1762.5 -6647.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1727.5 -6562.5 1732.5 -6557.5 {name=p dir=inout pinnumber=1}
B 2 1667.5 -6562.5 1672.5 -6557.5 {name=m dir=inout pinnumber=2}
B 2 1667.5 -6892.5 1672.5 -6887.5 {name=p dir=inout}
B 2 1607.5 -6892.5 1612.5 -6887.5 {name=m dir=inout}
B 2 1698.75 -6811.25 1701.25 -6808.75 {name=p dir=out}
B 2 1587.5 -6782.5 1592.5 -6777.5 {name=p dir=inout goto=0}
B 2 1847.5 -6782.5 1852.5 -6777.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 767.5 -6342.5 772.5 -6337.5 {name=d dir=inout}
B 2 727.5 -6312.5 732.5 -6307.5 {name=g dir=in}
B 2 767.5 -6282.5 772.5 -6277.5 {name=s dir=inout}
B 2 767.5 -6312.5 772.5 -6307.5 {name=b dir=in}
B 2 767.5 -6432.5 772.5 -6427.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 767.5 -6372.5 772.5 -6367.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 857.5 -6342.5 862.5 -6337.5 {name=p dir=inout pinnumber=1}
B 2 857.5 -6282.5 862.5 -6277.5 {name=m dir=inout pinnumber=2}
B 2 527.5 -6282.5 532.5 -6277.5 {name=p dir=inout}
B 2 527.5 -6222.5 532.5 -6217.5 {name=m dir=inout}
B 2 608.75 -6311.25 611.25 -6308.75 {name=p dir=out}
B 2 637.5 -6202.5 642.5 -6197.5 {name=p dir=inout goto=0}
B 2 637.5 -6462.5 642.5 -6457.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1217.5 -6342.5 1222.5 -6337.5 {name=d dir=inout}
B 2 1177.5 -6312.5 1182.5 -6307.5 {name=g dir=in}
B 2 1217.5 -6282.5 1222.5 -6277.5 {name=s dir=inout}
B 2 1217.5 -6312.5 1222.5 -6307.5 {name=b dir=in}
B 2 1217.5 -6432.5 1222.5 -6427.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1217.5 -6372.5 1222.5 -6367.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1307.5 -6342.5 1312.5 -6337.5 {name=p dir=inout pinnumber=1}
B 2 1307.5 -6282.5 1312.5 -6277.5 {name=m dir=inout pinnumber=2}
B 2 977.5 -6282.5 982.5 -6277.5 {name=p dir=inout}
B 2 977.5 -6222.5 982.5 -6217.5 {name=m dir=inout}
B 2 1058.75 -6311.25 1061.25 -6308.75 {name=p dir=out}
B 2 1087.5 -6202.5 1092.5 -6197.5 {name=p dir=inout goto=0}
B 2 1087.5 -6462.5 1092.5 -6457.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 1597.5 -6342.5 1602.5 -6337.5 {name=d dir=inout}
B 2 1637.5 -6312.5 1642.5 -6307.5 {name=g dir=in}
B 2 1597.5 -6282.5 1602.5 -6277.5 {name=s dir=inout}
B 2 1597.5 -6312.5 1602.5 -6307.5 {name=b dir=in}
B 2 1597.5 -6432.5 1602.5 -6427.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 1597.5 -6372.5 1602.5 -6367.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 2 1507.5 -6342.5 1512.5 -6337.5 {name=p dir=inout pinnumber=1}
B 2 1507.5 -6282.5 1512.5 -6277.5 {name=m dir=inout pinnumber=2}
B 2 1837.5 -6282.5 1842.5 -6277.5 {name=p dir=inout}
B 2 1837.5 -6222.5 1842.5 -6217.5 {name=m dir=inout}
B 2 1758.75 -6311.25 1761.25 -6308.75 {name=p dir=out}
B 2 1727.5 -6202.5 1732.5 -6197.5 {name=p dir=inout goto=0}
B 2 1727.5 -6462.5 1732.5 -6457.5 {name=p dir=inout verilog_type=wire goto=0}
B 2 607.5 -6082.5 612.5 -6077.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 607.5 -6022.5 612.5 -6017.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 607.5 -5952.5 612.5 -5947.5 {name=p dir=inout pinnumber=1}
B 2 607.5 -5892.5 612.5 -5887.5 {name=m dir=inout pinnumber=2}
B 2 607.5 -5842.5 612.5 -5837.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 607.5 -5782.5 612.5 -5777.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 957.5 -6052.5 962.5 -6047.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 897.5 -6052.5 902.5 -6047.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 957.5 -5922.5 962.5 -5917.5 {name=p dir=inout pinnumber=1}
B 2 897.5 -5922.5 902.5 -5917.5 {name=m dir=inout pinnumber=2}
B 2 957.5 -5812.5 962.5 -5807.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 2 897.5 -5812.5 902.5 -5807.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1027.5 -9522.5 1032.5 -9517.5 {name=p dir=inout}
B 5 1027.5 -9462.5 1032.5 -9457.5 {name=m dir=inout}
B 5 1108.75 -9551.25 1111.25 -9548.75 {name=p dir=out}
B 5 1137.5 -9442.5 1142.5 -9437.5 {name=p dir=inout goto=0}
B 5 1137.5 -9702.5 1142.5 -9697.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -9581.25 1411.25 -9578.75 {name=p dir=in}
B 5 1567.5 -9522.5 1572.5 -9517.5 {name=p dir=inout}
B 5 1567.5 -9462.5 1572.5 -9457.5 {name=m dir=inout}
B 5 1648.75 -9551.25 1651.25 -9548.75 {name=p dir=out}
B 5 1677.5 -9442.5 1682.5 -9437.5 {name=p dir=inout goto=0}
B 5 1677.5 -9702.5 1682.5 -9697.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1948.75 -9581.25 1951.25 -9578.75 {name=p dir=in}
B 5 697.5 -9552.5 702.5 -9547.5 {name=g dir=in}
B 5 497.5 -9522.5 502.5 -9517.5 {name=p dir=inout}
B 5 497.5 -9462.5 502.5 -9457.5 {name=m dir=inout}
B 5 578.75 -9551.25 581.25 -9548.75 {name=p dir=out}
B 5 607.5 -9442.5 612.5 -9437.5 {name=p dir=inout goto=0}
B 5 607.5 -9702.5 612.5 -9697.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -9581.25 881.25 -9578.75 {name=p dir=in}
B 5 737.5 -9122.5 742.5 -9117.5 {name=d dir=inout}
B 5 697.5 -9092.5 702.5 -9087.5 {name=g dir=in}
B 5 737.5 -9062.5 742.5 -9057.5 {name=s dir=inout}
B 5 737.5 -9092.5 742.5 -9087.5 {name=b dir=in}
B 5 737.5 -9212.5 742.5 -9207.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -9152.5 742.5 -9147.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -9122.5 832.5 -9117.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -9062.5 832.5 -9057.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -9062.5 502.5 -9057.5 {name=p dir=inout}
B 5 497.5 -9002.5 502.5 -8997.5 {name=m dir=inout}
B 5 578.75 -9091.25 581.25 -9088.75 {name=p dir=out}
B 5 607.5 -8982.5 612.5 -8977.5 {name=p dir=inout goto=0}
B 5 607.5 -9242.5 612.5 -9237.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -9121.25 881.25 -9118.75 {name=p dir=in}
B 5 1277.5 -9122.5 1282.5 -9117.5 {name=d dir=inout}
B 5 1237.5 -9092.5 1242.5 -9087.5 {name=g dir=in}
B 5 1277.5 -9062.5 1282.5 -9057.5 {name=s dir=inout}
B 5 1277.5 -9092.5 1282.5 -9087.5 {name=b dir=in}
B 5 1367.5 -9122.5 1372.5 -9117.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -9062.5 1372.5 -9057.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -9062.5 1042.5 -9057.5 {name=p dir=inout}
B 5 1037.5 -9002.5 1042.5 -8997.5 {name=m dir=inout}
B 5 1118.75 -9091.25 1121.25 -9088.75 {name=p dir=out}
B 5 1147.5 -8982.5 1152.5 -8977.5 {name=p dir=inout goto=0}
B 5 1147.5 -9242.5 1152.5 -9237.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -9121.25 1421.25 -9118.75 {name=p dir=in}
B 5 737.5 -5532.5 742.5 -5527.5 {name=d dir=inout}
B 5 697.5 -5502.5 702.5 -5497.5 {name=g dir=in}
B 5 737.5 -5472.5 742.5 -5467.5 {name=s dir=inout}
B 5 737.5 -5502.5 742.5 -5497.5 {name=b dir=in}
B 5 737.5 -5622.5 742.5 -5617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -5562.5 742.5 -5557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -5532.5 832.5 -5527.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -5472.5 832.5 -5467.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -5472.5 502.5 -5467.5 {name=p dir=inout}
B 5 497.5 -5412.5 502.5 -5407.5 {name=m dir=inout}
B 5 578.75 -5501.25 581.25 -5498.75 {name=p dir=out}
B 5 607.5 -5392.5 612.5 -5387.5 {name=p dir=inout goto=0}
B 5 607.5 -5652.5 612.5 -5647.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -5531.25 881.25 -5528.75 {name=p dir=in}
B 5 1277.5 -5532.5 1282.5 -5527.5 {name=d dir=inout}
B 5 1237.5 -5502.5 1242.5 -5497.5 {name=g dir=in}
B 5 1277.5 -5472.5 1282.5 -5467.5 {name=s dir=inout}
B 5 1277.5 -5502.5 1282.5 -5497.5 {name=b dir=in}
B 5 1367.5 -5532.5 1372.5 -5527.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -5472.5 1372.5 -5467.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -5472.5 1042.5 -5467.5 {name=p dir=inout}
B 5 1037.5 -5412.5 1042.5 -5407.5 {name=m dir=inout}
B 5 1118.75 -5501.25 1121.25 -5498.75 {name=p dir=out}
B 5 1147.5 -5392.5 1152.5 -5387.5 {name=p dir=inout goto=0}
B 5 1147.5 -5652.5 1152.5 -5647.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -5531.25 1421.25 -5528.75 {name=p dir=in}
B 5 737.5 -5132.5 742.5 -5127.5 {name=d dir=inout}
B 5 697.5 -5102.5 702.5 -5097.5 {name=g dir=in}
B 5 737.5 -5072.5 742.5 -5067.5 {name=s dir=inout}
B 5 737.5 -5102.5 742.5 -5097.5 {name=b dir=in}
B 5 737.5 -5222.5 742.5 -5217.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 737.5 -5162.5 742.5 -5157.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 827.5 -5132.5 832.5 -5127.5 {name=p dir=inout pinnumber=1}
B 5 827.5 -5072.5 832.5 -5067.5 {name=m dir=inout pinnumber=2}
B 5 497.5 -5072.5 502.5 -5067.5 {name=p dir=inout}
B 5 497.5 -5012.5 502.5 -5007.5 {name=m dir=inout}
B 5 578.75 -5101.25 581.25 -5098.75 {name=p dir=out}
B 5 607.5 -4992.5 612.5 -4987.5 {name=p dir=inout goto=0}
B 5 607.5 -5252.5 612.5 -5247.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -5131.25 881.25 -5128.75 {name=p dir=in}
B 5 1277.5 -5132.5 1282.5 -5127.5 {name=d dir=inout}
B 5 1237.5 -5102.5 1242.5 -5097.5 {name=g dir=in}
B 5 1277.5 -5072.5 1282.5 -5067.5 {name=s dir=inout}
B 5 1277.5 -5102.5 1282.5 -5097.5 {name=b dir=in}
B 5 1367.5 -5132.5 1372.5 -5127.5 {name=p dir=inout pinnumber=1}
B 5 1367.5 -5072.5 1372.5 -5067.5 {name=m dir=inout pinnumber=2}
B 5 1037.5 -5072.5 1042.5 -5067.5 {name=p dir=inout}
B 5 1037.5 -5012.5 1042.5 -5007.5 {name=m dir=inout}
B 5 1118.75 -5101.25 1121.25 -5098.75 {name=p dir=out}
B 5 1147.5 -4992.5 1152.5 -4987.5 {name=p dir=inout goto=0}
B 5 1147.5 -5252.5 1152.5 -5247.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1418.75 -5131.25 1421.25 -5128.75 {name=p dir=in}
B 5 697.5 -4662.5 702.5 -4657.5 {name=g dir=in}
B 5 497.5 -4632.5 502.5 -4627.5 {name=p dir=inout}
B 5 497.5 -4572.5 502.5 -4567.5 {name=m dir=inout}
B 5 578.75 -4661.25 581.25 -4658.75 {name=p dir=out}
B 5 607.5 -4552.5 612.5 -4547.5 {name=p dir=inout goto=0}
B 5 607.5 -4812.5 612.5 -4807.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1687.5 -4632.5 1692.5 -4627.5 {name=p dir=inout}
B 5 1687.5 -4572.5 1692.5 -4567.5 {name=m dir=inout}
B 5 1768.75 -4661.25 1771.25 -4658.75 {name=p dir=out}
B 5 1797.5 -4552.5 1802.5 -4547.5 {name=p dir=inout goto=0}
B 5 1797.5 -4812.5 1802.5 -4807.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1057.5 -4632.5 1062.5 -4627.5 {name=p dir=inout}
B 5 1057.5 -4572.5 1062.5 -4567.5 {name=m dir=inout}
B 5 1138.75 -4661.25 1141.25 -4658.75 {name=p dir=out}
B 5 1167.5 -4552.5 1172.5 -4547.5 {name=p dir=inout goto=0}
B 5 1167.5 -4812.5 1172.5 -4807.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1027.5 -8692.5 1032.5 -8687.5 {name=p dir=inout}
B 5 1027.5 -8632.5 1032.5 -8627.5 {name=m dir=inout}
B 5 1108.75 -8721.25 1111.25 -8718.75 {name=p dir=out}
B 5 1137.5 -8612.5 1142.5 -8607.5 {name=p dir=inout goto=0}
B 5 1137.5 -8872.5 1142.5 -8867.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -8751.25 1411.25 -8748.75 {name=p dir=in}
B 5 697.5 -8722.5 702.5 -8717.5 {name=g dir=in}
B 5 497.5 -8692.5 502.5 -8687.5 {name=p dir=inout}
B 5 497.5 -8632.5 502.5 -8627.5 {name=m dir=inout}
B 5 578.75 -8721.25 581.25 -8718.75 {name=p dir=out}
B 5 607.5 -8612.5 612.5 -8607.5 {name=p dir=inout goto=0}
B 5 607.5 -8872.5 612.5 -8867.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 878.75 -8751.25 881.25 -8748.75 {name=p dir=in}
B 5 1767.5 -8752.5 1772.5 -8747.5 {name=d dir=inout}
B 5 1727.5 -8722.5 1732.5 -8717.5 {name=g dir=in}
B 5 1767.5 -8692.5 1772.5 -8687.5 {name=s dir=inout}
B 5 1767.5 -8722.5 1772.5 -8717.5 {name=b dir=in}
B 5 1767.5 -8842.5 1772.5 -8837.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1767.5 -8782.5 1772.5 -8777.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1857.5 -8752.5 1862.5 -8747.5 {name=p dir=inout pinnumber=1}
B 5 1857.5 -8692.5 1862.5 -8687.5 {name=m dir=inout pinnumber=2}
B 5 1527.5 -8692.5 1532.5 -8687.5 {name=p dir=inout}
B 5 1527.5 -8632.5 1532.5 -8627.5 {name=m dir=inout}
B 5 1608.75 -8721.25 1611.25 -8718.75 {name=p dir=out}
B 5 1637.5 -8612.5 1642.5 -8607.5 {name=p dir=inout goto=0}
B 5 1637.5 -8872.5 1642.5 -8867.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1908.75 -8751.25 1911.25 -8748.75 {name=p dir=in}
B 5 1648.75 -10021.25 1651.25 -10018.75 {name=p dir=out}
B 5 1677.5 -9912.5 1682.5 -9907.5 {name=p dir=inout goto=0}
B 5 1677.5 -10172.5 1682.5 -10167.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1948.75 -10051.25 1951.25 -10048.75 {name=p dir=in}
B 5 642.5 -10022.5 647.5 -10017.5 {name=g dir=in}
B 5 442.5 -9992.5 447.5 -9987.5 {name=p dir=inout}
B 5 442.5 -9932.5 447.5 -9927.5 {name=m dir=inout}
B 5 523.75 -10021.25 526.25 -10018.75 {name=p dir=out}
B 5 552.5 -9912.5 557.5 -9907.5 {name=p dir=inout goto=0}
B 5 552.5 -10172.5 557.5 -10167.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 823.75 -10051.25 826.25 -10048.75 {name=p dir=in}
B 5 2108.75 -10021.25 2111.25 -10018.75 {name=p dir=out}
B 5 2137.5 -9912.5 2142.5 -9907.5 {name=p dir=inout goto=0}
B 5 2137.5 -10172.5 2142.5 -10167.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2408.75 -10051.25 2411.25 -10048.75 {name=p dir=in}
B 5 2357.5 -10052.5 2362.5 -10047.5 {name=p dir=inout pinnumber=1}
B 5 2357.5 -9992.5 2362.5 -9987.5 {name=m dir=inout pinnumber=2}
B 5 757.5 -7912.5 762.5 -7907.5 {name=d dir=inout}
B 5 717.5 -7882.5 722.5 -7877.5 {name=g dir=in}
B 5 757.5 -7852.5 762.5 -7847.5 {name=s dir=inout}
B 5 757.5 -7882.5 762.5 -7877.5 {name=b dir=in}
B 5 757.5 -8002.5 762.5 -7997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -7942.5 762.5 -7937.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 847.5 -7912.5 852.5 -7907.5 {name=p dir=inout pinnumber=1}
B 5 847.5 -7852.5 852.5 -7847.5 {name=m dir=inout pinnumber=2}
B 5 517.5 -7852.5 522.5 -7847.5 {name=p dir=inout}
B 5 517.5 -7792.5 522.5 -7787.5 {name=m dir=inout}
B 5 598.75 -7881.25 601.25 -7878.75 {name=p dir=out}
B 5 627.5 -7772.5 632.5 -7767.5 {name=p dir=inout goto=0}
B 5 627.5 -8032.5 632.5 -8027.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 898.75 -7911.25 901.25 -7908.75 {name=p dir=in}
B 5 1297.5 -7912.5 1302.5 -7907.5 {name=d dir=inout}
B 5 1257.5 -7882.5 1262.5 -7877.5 {name=g dir=in}
B 5 1297.5 -7852.5 1302.5 -7847.5 {name=s dir=inout}
B 5 1297.5 -7882.5 1302.5 -7877.5 {name=b dir=in}
B 5 1297.5 -8002.5 1302.5 -7997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1297.5 -7942.5 1302.5 -7937.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1387.5 -7912.5 1392.5 -7907.5 {name=p dir=inout pinnumber=1}
B 5 1387.5 -7852.5 1392.5 -7847.5 {name=m dir=inout pinnumber=2}
B 5 1057.5 -7852.5 1062.5 -7847.5 {name=p dir=inout}
B 5 1057.5 -7792.5 1062.5 -7787.5 {name=m dir=inout}
B 5 1138.75 -7881.25 1141.25 -7878.75 {name=p dir=out}
B 5 1167.5 -7772.5 1172.5 -7767.5 {name=p dir=inout goto=0}
B 5 1167.5 -8032.5 1172.5 -8027.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1438.75 -7911.25 1441.25 -7908.75 {name=p dir=in}
B 5 2427.5 -7912.5 2432.5 -7907.5 {name=d dir=inout}
B 5 2387.5 -7882.5 2392.5 -7877.5 {name=g dir=in}
B 5 2427.5 -7852.5 2432.5 -7847.5 {name=s dir=inout}
B 5 2427.5 -7882.5 2432.5 -7877.5 {name=b dir=in}
B 5 2427.5 -8002.5 2432.5 -7997.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -7942.5 2432.5 -7937.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2517.5 -7912.5 2522.5 -7907.5 {name=p dir=inout pinnumber=1}
B 5 2517.5 -7852.5 2522.5 -7847.5 {name=m dir=inout pinnumber=2}
B 5 2187.5 -7852.5 2192.5 -7847.5 {name=p dir=inout}
B 5 2187.5 -7792.5 2192.5 -7787.5 {name=m dir=inout}
B 5 2268.75 -7881.25 2271.25 -7878.75 {name=p dir=out}
B 5 2297.5 -7772.5 2302.5 -7767.5 {name=p dir=inout goto=0}
B 5 2297.5 -8032.5 2302.5 -8027.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2568.75 -7911.25 2571.25 -7908.75 {name=p dir=in}
B 5 817.5 -3822.5 822.5 -3817.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -3762.5 822.5 -3757.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -3762.5 822.5 -3757.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -3702.5 822.5 -3697.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -3702.5 1362.5 -3697.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -3862.5 1902.5 -3857.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -3802.5 1902.5 -3797.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -3762.5 1902.5 -3757.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -3702.5 1902.5 -3697.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -2992.5 712.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -2932.5 712.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -2992.5 822.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -2932.5 822.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -2992.5 932.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -2932.5 932.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -2992.5 1252.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -2932.5 1252.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -2992.5 1362.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -2932.5 1362.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -2992.5 1472.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -2932.5 1472.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -2992.5 1792.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -2932.5 1792.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -2992.5 1902.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -2932.5 1902.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -2992.5 2012.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -2932.5 2012.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2317.5 -2992.5 2322.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2317.5 -2932.5 2322.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2427.5 -2992.5 2432.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2427.5 -2932.5 2432.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2537.5 -2992.5 2542.5 -2987.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2537.5 -2932.5 2542.5 -2927.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -1062.5 712.5 -1057.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -1002.5 712.5 -997.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -1062.5 822.5 -1057.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -1002.5 822.5 -997.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -1062.5 932.5 -1057.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -1002.5 932.5 -997.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -972.5 712.5 -967.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -912.5 712.5 -907.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -972.5 822.5 -967.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -912.5 822.5 -907.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -972.5 932.5 -967.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -912.5 932.5 -907.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -972.5 1252.5 -967.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -912.5 1252.5 -907.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -972.5 1362.5 -967.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -912.5 1362.5 -907.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -972.5 1472.5 -967.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -912.5 1472.5 -907.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -972.5 1792.5 -967.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -912.5 1792.5 -907.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -972.5 1902.5 -967.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -912.5 1902.5 -907.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -972.5 2012.5 -967.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -912.5 2012.5 -907.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1877.5 -2732.5 1882.5 -2727.5 {name=d dir=inout}
B 5 1837.5 -2702.5 1842.5 -2697.5 {name=g dir=in}
B 5 1877.5 -2672.5 1882.5 -2667.5 {name=s dir=inout}
B 5 1877.5 -2702.5 1882.5 -2697.5 {name=b dir=in}
B 5 1108.75 -10021.25 1111.25 -10018.75 {name=p dir=out}
B 5 1137.5 -9912.5 1142.5 -9907.5 {name=p dir=inout goto=0}
B 5 1137.5 -10172.5 1142.5 -10167.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -10051.25 1411.25 -10048.75 {name=p dir=in}
B 5 1027.5 -9992.5 1032.5 -9987.5 {name=p dir=inout}
B 5 1027.5 -9932.5 1032.5 -9927.5 {name=m dir=inout}
B 5 707.5 -682.5 712.5 -677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -622.5 712.5 -617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -682.5 822.5 -677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -622.5 822.5 -617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -682.5 932.5 -677.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -622.5 932.5 -617.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 707.5 -622.5 712.5 -617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 707.5 -562.5 712.5 -557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -622.5 822.5 -617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -562.5 822.5 -557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 927.5 -622.5 932.5 -617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 927.5 -562.5 932.5 -557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1247.5 -622.5 1252.5 -617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1247.5 -562.5 1252.5 -557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -622.5 1362.5 -617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1357.5 -562.5 1362.5 -557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1467.5 -622.5 1472.5 -617.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1467.5 -562.5 1472.5 -557.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -592.5 1792.5 -587.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1787.5 -532.5 1792.5 -527.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1897.5 -592.5 1902.5 -587.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1897.5 -532.5 1902.5 -527.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2007.5 -592.5 2012.5 -587.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2007.5 -532.5 2012.5 -527.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1757.5 -1372.5 1762.5 -1367.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1757.5 -1312.5 1762.5 -1307.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1877.5 -1372.5 1882.5 -1367.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1877.5 -1312.5 1882.5 -1307.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 797.5 -1442.5 802.5 -1437.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 817.5 -222.5 822.5 -217.5 {name=d dir=inout}
B 5 777.5 -192.5 782.5 -187.5 {name=g dir=in}
B 5 817.5 -162.5 822.5 -157.5 {name=s dir=inout}
B 5 817.5 -192.5 822.5 -187.5 {name=b dir=in}
B 5 817.5 -312.5 822.5 -307.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 817.5 -252.5 822.5 -247.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 907.5 -222.5 912.5 -217.5 {name=p dir=inout pinnumber=1}
B 5 907.5 -162.5 912.5 -157.5 {name=m dir=inout pinnumber=2}
B 5 577.5 -162.5 582.5 -157.5 {name=p dir=inout}
B 5 577.5 -102.5 582.5 -97.5 {name=m dir=inout}
B 5 658.75 -191.25 661.25 -188.75 {name=p dir=out}
B 5 687.5 -82.5 692.5 -77.5 {name=p dir=inout goto=0}
B 5 687.5 -342.5 692.5 -337.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 958.75 -221.25 961.25 -218.75 {name=p dir=in}
B 5 1417.5 -222.5 1422.5 -217.5 {name=d dir=inout}
B 5 1377.5 -192.5 1382.5 -187.5 {name=g dir=in}
B 5 1417.5 -162.5 1422.5 -157.5 {name=s dir=inout}
B 5 1417.5 -192.5 1422.5 -187.5 {name=b dir=in}
B 5 1417.5 -312.5 1422.5 -307.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1417.5 -252.5 1422.5 -247.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1177.5 -162.5 1182.5 -157.5 {name=p dir=inout}
B 5 1177.5 -102.5 1182.5 -97.5 {name=m dir=inout}
B 5 1258.75 -191.25 1261.25 -188.75 {name=p dir=out}
B 5 1287.5 -82.5 1292.5 -77.5 {name=p dir=inout goto=0}
B 5 1287.5 -342.5 1292.5 -337.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1558.75 -221.25 1561.25 -218.75 {name=p dir=in}
B 5 2027.5 -222.5 2032.5 -217.5 {name=d dir=inout}
B 5 1987.5 -192.5 1992.5 -187.5 {name=g dir=in}
B 5 2027.5 -162.5 2032.5 -157.5 {name=s dir=inout}
B 5 2027.5 -192.5 2032.5 -187.5 {name=b dir=in}
B 5 2027.5 -312.5 2032.5 -307.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2027.5 -252.5 2032.5 -247.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1787.5 -162.5 1792.5 -157.5 {name=p dir=inout}
B 5 1787.5 -102.5 1792.5 -97.5 {name=m dir=inout}
B 5 1868.75 -191.25 1871.25 -188.75 {name=p dir=out}
B 5 1897.5 -82.5 1902.5 -77.5 {name=p dir=inout goto=0}
B 5 1897.5 -342.5 1902.5 -337.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2168.75 -221.25 2171.25 -218.75 {name=p dir=in}
B 5 357.5 -7522.5 362.5 -7517.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 557.5 -7522.5 562.5 -7517.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 797.5 -7522.5 802.5 -7517.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1087.5 -7522.5 1092.5 -7517.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1317.5 -7522.5 1322.5 -7517.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 357.5 -7462.5 362.5 -7457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 557.5 -7462.5 562.5 -7457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 797.5 -7462.5 802.5 -7457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1087.5 -7462.5 1092.5 -7457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1317.5 -7462.5 1322.5 -7457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1607.5 -7522.5 1612.5 -7517.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1607.5 -7462.5 1612.5 -7457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1847.5 -7522.5 1852.5 -7517.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1847.5 -7462.5 1852.5 -7457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2147.5 -7522.5 2152.5 -7517.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2147.5 -7462.5 2152.5 -7457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -4282.5 762.5 -4277.5 {name=d dir=inout}
B 5 717.5 -4252.5 722.5 -4247.5 {name=g dir=in}
B 5 757.5 -4222.5 762.5 -4217.5 {name=s dir=inout}
B 5 757.5 -4252.5 762.5 -4247.5 {name=b dir=in}
B 5 757.5 -4372.5 762.5 -4367.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 757.5 -4312.5 762.5 -4307.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 517.5 -4222.5 522.5 -4217.5 {name=p dir=inout}
B 5 517.5 -4162.5 522.5 -4157.5 {name=m dir=inout}
B 5 598.75 -4251.25 601.25 -4248.75 {name=p dir=out}
B 5 627.5 -4142.5 632.5 -4137.5 {name=p dir=inout goto=0}
B 5 627.5 -4402.5 632.5 -4397.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 898.75 -4281.25 901.25 -4278.75 {name=p dir=in}
B 5 1317.5 -4282.5 1322.5 -4277.5 {name=d dir=inout}
B 5 1277.5 -4252.5 1282.5 -4247.5 {name=g dir=in}
B 5 1317.5 -4222.5 1322.5 -4217.5 {name=s dir=inout}
B 5 1317.5 -4252.5 1322.5 -4247.5 {name=b dir=in}
B 5 1317.5 -4372.5 1322.5 -4367.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1317.5 -4312.5 1322.5 -4307.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1077.5 -4222.5 1082.5 -4217.5 {name=p dir=inout}
B 5 1077.5 -4162.5 1082.5 -4157.5 {name=m dir=inout}
B 5 1158.75 -4251.25 1161.25 -4248.75 {name=p dir=out}
B 5 1187.5 -4142.5 1192.5 -4137.5 {name=p dir=inout goto=0}
B 5 1187.5 -4402.5 1192.5 -4397.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1458.75 -4281.25 1461.25 -4278.75 {name=p dir=in}
B 5 702.5 -8332.5 707.5 -8327.5 {name=d dir=inout}
B 5 662.5 -8302.5 667.5 -8297.5 {name=g dir=in}
B 5 702.5 -8272.5 707.5 -8267.5 {name=s dir=inout}
B 5 702.5 -8302.5 707.5 -8297.5 {name=b dir=in}
B 5 702.5 -8422.5 707.5 -8417.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 702.5 -8362.5 707.5 -8357.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 792.5 -8332.5 797.5 -8327.5 {name=p dir=inout pinnumber=1}
B 5 792.5 -8272.5 797.5 -8267.5 {name=m dir=inout pinnumber=2}
B 5 462.5 -8272.5 467.5 -8267.5 {name=p dir=inout}
B 5 462.5 -8212.5 467.5 -8207.5 {name=m dir=inout}
B 5 543.75 -8301.25 546.25 -8298.75 {name=p dir=out}
B 5 572.5 -8192.5 577.5 -8187.5 {name=p dir=inout goto=0}
B 5 572.5 -8452.5 577.5 -8447.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 843.75 -8331.25 846.25 -8328.75 {name=p dir=in}
B 5 1267.5 -8332.5 1272.5 -8327.5 {name=d dir=inout}
B 5 1227.5 -8302.5 1232.5 -8297.5 {name=g dir=in}
B 5 1267.5 -8272.5 1272.5 -8267.5 {name=s dir=inout}
B 5 1267.5 -8302.5 1272.5 -8297.5 {name=b dir=in}
B 5 1267.5 -8422.5 1272.5 -8417.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1267.5 -8362.5 1272.5 -8357.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1357.5 -8332.5 1362.5 -8327.5 {name=p dir=inout pinnumber=1}
B 5 1357.5 -8272.5 1362.5 -8267.5 {name=m dir=inout pinnumber=2}
B 5 1027.5 -8272.5 1032.5 -8267.5 {name=p dir=inout}
B 5 1027.5 -8212.5 1032.5 -8207.5 {name=m dir=inout}
B 5 1108.75 -8301.25 1111.25 -8298.75 {name=p dir=out}
B 5 1137.5 -8192.5 1142.5 -8187.5 {name=p dir=inout goto=0}
B 5 1137.5 -8452.5 1142.5 -8447.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1408.75 -8331.25 1411.25 -8328.75 {name=p dir=in}
B 5 1767.5 -8332.5 1772.5 -8327.5 {name=d dir=inout}
B 5 1727.5 -8302.5 1732.5 -8297.5 {name=g dir=in}
B 5 1767.5 -8272.5 1772.5 -8267.5 {name=s dir=inout}
B 5 1767.5 -8302.5 1772.5 -8297.5 {name=b dir=in}
B 5 1767.5 -8422.5 1772.5 -8417.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 1767.5 -8362.5 1772.5 -8357.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 1857.5 -8332.5 1862.5 -8327.5 {name=p dir=inout pinnumber=1}
B 5 1857.5 -8272.5 1862.5 -8267.5 {name=m dir=inout pinnumber=2}
B 5 1527.5 -8272.5 1532.5 -8267.5 {name=p dir=inout}
B 5 1527.5 -8212.5 1532.5 -8207.5 {name=m dir=inout}
B 5 1608.75 -8301.25 1611.25 -8298.75 {name=p dir=out}
B 5 1637.5 -8192.5 1642.5 -8187.5 {name=p dir=inout goto=0}
B 5 1637.5 -8452.5 1642.5 -8447.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 1908.75 -8331.25 1911.25 -8328.75 {name=p dir=in}
B 5 2257.5 -8332.5 2262.5 -8327.5 {name=d dir=inout}
B 5 2217.5 -8302.5 2222.5 -8297.5 {name=g dir=in}
B 5 2257.5 -8272.5 2262.5 -8267.5 {name=s dir=inout}
B 5 2257.5 -8302.5 2262.5 -8297.5 {name=b dir=in}
B 5 2257.5 -8422.5 2262.5 -8417.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2257.5 -8362.5 2262.5 -8357.5 {name=M dir=inout propag=0 pinnumber=2 goto=0}
B 5 2347.5 -8332.5 2352.5 -8327.5 {name=p dir=inout pinnumber=1}
B 5 2347.5 -8272.5 2352.5 -8267.5 {name=m dir=inout pinnumber=2}
B 5 2017.5 -8272.5 2022.5 -8267.5 {name=p dir=inout}
B 5 2017.5 -8212.5 2022.5 -8207.5 {name=m dir=inout}
B 5 2098.75 -8301.25 2101.25 -8298.75 {name=p dir=out}
B 5 2127.5 -8192.5 2132.5 -8187.5 {name=p dir=inout goto=0}
B 5 2127.5 -8452.5 2132.5 -8447.5 {name=p dir=inout verilog_type=wire goto=0}
B 5 2398.75 -8331.25 2401.25 -8328.75 {name=p dir=in}
B 5 417.5 -7522.5 422.5 -7517.5 {name=p dir=inout pinnumber=1}
B 5 417.5 -7462.5 422.5 -7457.5 {name=m dir=inout pinnumber=2}
B 5 617.5 -7522.5 622.5 -7517.5 {name=p dir=inout pinnumber=1}
B 5 617.5 -7462.5 622.5 -7457.5 {name=m dir=inout pinnumber=2}
B 5 857.5 -7522.5 862.5 -7517.5 {name=p dir=inout pinnumber=1}
B 5 857.5 -7462.5 862.5 -7457.5 {name=m dir=inout pinnumber=2}
B 5 1147.5 -7522.5 1152.5 -7517.5 {name=p dir=inout pinnumber=1}
B 5 1147.5 -7462.5 1152.5 -7457.5 {name=m dir=inout pinnumber=2}
B 5 1377.5 -7522.5 1382.5 -7517.5 {name=p dir=inout pinnumber=1}
B 5 1377.5 -7462.5 1382.5 -7457.5 {name=m dir=inout pinnumber=2}
B 5 1667.5 -7522.5 1672.5 -7517.5 {name=p dir=inout pinnumber=1}
B 5 1667.5 -7462.5 1672.5 -7457.5 {name=m dir=inout pinnumber=2}
B 5 1907.5 -7522.5 1912.5 -7517.5 {name=p dir=inout pinnumber=1}
B 5 1907.5 -7462.5 1912.5 -7457.5 {name=m dir=inout pinnumber=2}
B 5 2207.5 -7522.5 2212.5 -7517.5 {name=p dir=inout pinnumber=1}
B 5 2207.5 -7462.5 2212.5 -7457.5 {name=m dir=inout pinnumber=2}
B 5 2357.5 -7522.5 2362.5 -7517.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2357.5 -7462.5 2362.5 -7457.5 {name=P dir=inout propag=1 pinnumber=1 goto=1}
B 5 2417.5 -7522.5 2422.5 -7517.5 {name=p dir=inout pinnumber=1}
B 5 2417.5 -7462.5 2422.5 -7457.5 {name=m dir=inout pinnumber=2}
A 1 1220 -2360 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1340 -2360 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1850 -2360 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1970 -2360 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1280 -2080 5.590169943749475 333.434948822922 360 {fill=1}
A 1 1910 -2080 5.590169943749475 333.434948822922 360 {fill=1}
A 1 740 -1680 5.590169943749475 333.434948822922 360 {fill=1}
A 2 1570 -9960 15 270 360 {}
A 2 2030 -9960 15 270 360 {}
A 2 530 -6680 15 270 360 {}
A 2 1005 -6680 15 270 360 {}
A 2 1640 -6890 15 180 360 {}
A 2 530 -6250 15 270 360 {}
A 2 980 -6250 15 270 360 {}
A 2 1840 -6250 15 270 360 {}
A 4 1030 -9490 15 270 360 {}
A 4 1570 -9490 15 270 360 {}
A 4 500 -9490 15 270 360 {}
A 4 500 -9030 15 270 360 {}
A 4 1040 -9030 15 270 360 {}
A 4 500 -5440 15 270 360 {}
A 4 1040 -5440 15 270 360 {}
A 4 500 -5040 15 270 360 {}
A 4 1040 -5040 15 270 360 {}
A 4 500 -4600 15 270 360 {}
A 4 1690 -4600 15 270 360 {}
A 4 1060 -4600 15 270 360 {}
A 4 1030 -8660 15 270 360 {}
A 4 500 -8660 15 270 360 {}
A 4 1530 -8660 15 270 360 {}
A 4 445 -9960 15 270 360 {}
A 4 520 -7820 15 270 360 {}
A 4 1060 -7820 15 270 360 {}
A 4 2190 -7820 15 270 360 {}
A 4 1030 -9960 15 270 360 {}
A 4 580 -130 15 270 360 {}
A 4 1180 -130 15 270 360 {}
A 4 1790 -130 15 270 360 {}
A 4 520 -4190 15 270 360 {}
A 4 1080 -4190 15 270 360 {}
A 4 465 -8240 15 270 360 {}
A 4 1030 -8240 15 270 360 {}
A 4 1530 -8240 15 270 360 {}
A 4 2020 -8240 15 270 360 {}
A 5 1360 -3440 5.590169943749475 333.434948822922 360 {fill=1}
P 1 14 920 -9410 942.5 -9410 947.5 -9410 947.5 -9405 947.5 -9362.5 940 -9337.5 935 -9337.5 905 -9337.5 900 -9337.5 892.5 -9362.5 892.5 -9405 892.5 -9410 897.5 -9410 920 -9410 {bezier=1}
P 1 14 935 -9407.5 940 -9407.5 945 -9407.5 945 -9402.5 945 -9382.5 945 -9377.5 940 -9377.5 930 -9377.5 925 -9377.5 925 -9382.5 925 -9402.5 925 -9407.5 930 -9407.5 935 -9407.5 {bezier=1}
P 1 5 917.5 -9405 922.5 -9405 922.5 -9380 917.5 -9380 917.5 -9405 {}
P 1 14 1350 -9410 1372.5 -9410 1377.5 -9410 1377.5 -9405 1377.5 -9362.5 1370 -9337.5 1365 -9337.5 1335 -9337.5 1330 -9337.5 1322.5 -9362.5 1322.5 -9405 1322.5 -9410 1327.5 -9410 1350 -9410 {bezier=1}
P 1 14 1365 -9407.5 1370 -9407.5 1375 -9407.5 1375 -9402.5 1375 -9382.5 1375 -9377.5 1370 -9377.5 1360 -9377.5 1355 -9377.5 1355 -9382.5 1355 -9402.5 1355 -9407.5 1360 -9407.5 1365 -9407.5 {bezier=1}
P 1 5 1347.5 -9405 1352.5 -9405 1352.5 -9380 1347.5 -9380 1347.5 -9405 {}
P 1 14 2120 -9410 2142.5 -9410 2147.5 -9410 2147.5 -9405 2147.5 -9362.5 2140 -9337.5 2135 -9337.5 2105 -9337.5 2100 -9337.5 2092.5 -9362.5 2092.5 -9405 2092.5 -9410 2097.5 -9410 2120 -9410 {bezier=1}
P 1 14 2135 -9407.5 2140 -9407.5 2145 -9407.5 2145 -9402.5 2145 -9382.5 2145 -9377.5 2140 -9377.5 2130 -9377.5 2125 -9377.5 2125 -9382.5 2125 -9402.5 2125 -9407.5 2130 -9407.5 2135 -9407.5 {bezier=1}
P 1 5 2117.5 -9405 2122.5 -9405 2122.5 -9380 2117.5 -9380 2117.5 -9405 {}
P 1 14 1420 -9220 1442.5 -9220 1447.5 -9220 1447.5 -9215 1447.5 -9172.5 1440 -9147.5 1435 -9147.5 1405 -9147.5 1400 -9147.5 1392.5 -9172.5 1392.5 -9215 1392.5 -9220 1397.5 -9220 1420 -9220 {bezier=1}
P 1 14 1435 -9217.5 1440 -9217.5 1445 -9217.5 1445 -9212.5 1445 -9192.5 1445 -9187.5 1440 -9187.5 1430 -9187.5 1425 -9187.5 1425 -9192.5 1425 -9212.5 1425 -9217.5 1430 -9217.5 1435 -9217.5 {bezier=1}
P 1 5 1417.5 -9215 1422.5 -9215 1422.5 -9190 1417.5 -9190 1417.5 -9215 {}
P 1 14 1440 -5640 1462.5 -5640 1467.5 -5640 1467.5 -5635 1467.5 -5592.5 1460 -5567.5 1455 -5567.5 1425 -5567.5 1420 -5567.5 1412.5 -5592.5 1412.5 -5635 1412.5 -5640 1417.5 -5640 1440 -5640 {bezier=1}
P 1 14 1455 -5637.5 1460 -5637.5 1465 -5637.5 1465 -5632.5 1465 -5612.5 1465 -5607.5 1460 -5607.5 1450 -5607.5 1445 -5607.5 1445 -5612.5 1445 -5632.5 1445 -5637.5 1450 -5637.5 1455 -5637.5 {bezier=1}
P 1 5 1437.5 -5635 1442.5 -5635 1442.5 -5610 1437.5 -5610 1437.5 -5635 {}
P 1 10 1520 -5595 1545 -5595 1555 -5585 1555 -5555 1545 -5545 1495 -5545 1485 -5555 1485 -5585 1495 -5595 1520 -5595 {bezier=1}
P 1 10 1520 -5600 1550 -5600 1560 -5590 1560 -5550 1550 -5540 1490 -5540 1480 -5550 1480 -5590 1490 -5600 1520 -5600 {bezier=1}
P 1 14 1440 -5240 1462.5 -5240 1467.5 -5240 1467.5 -5235 1467.5 -5192.5 1460 -5167.5 1455 -5167.5 1425 -5167.5 1420 -5167.5 1412.5 -5192.5 1412.5 -5235 1412.5 -5240 1417.5 -5240 1440 -5240 {bezier=1}
P 1 14 1455 -5237.5 1460 -5237.5 1465 -5237.5 1465 -5232.5 1465 -5212.5 1465 -5207.5 1460 -5207.5 1450 -5207.5 1445 -5207.5 1445 -5212.5 1445 -5232.5 1445 -5237.5 1450 -5237.5 1455 -5237.5 {bezier=1}
P 1 5 1437.5 -5235 1442.5 -5235 1442.5 -5210 1437.5 -5210 1437.5 -5235 {}
P 1 10 1520 -5665 1545 -5665 1555 -5655 1555 -5625 1545 -5615 1495 -5615 1485 -5625 1485 -5655 1495 -5665 1520 -5665 {bezier=1}
P 1 10 1520 -5670 1550 -5670 1560 -5660 1560 -5620 1550 -5610 1490 -5610 1480 -5620 1480 -5660 1490 -5670 1520 -5670 {bezier=1}
P 1 14 950 -4560 972.5 -4560 977.5 -4560 977.5 -4555 977.5 -4512.5 970 -4487.5 965 -4487.5 935 -4487.5 930 -4487.5 922.5 -4512.5 922.5 -4555 922.5 -4560 927.5 -4560 950 -4560 {bezier=1}
P 1 14 965 -4557.5 970 -4557.5 975 -4557.5 975 -4552.5 975 -4532.5 975 -4527.5 970 -4527.5 960 -4527.5 955 -4527.5 955 -4532.5 955 -4552.5 955 -4557.5 960 -4557.5 965 -4557.5 {bezier=1}
P 1 5 947.5 -4555 952.5 -4555 952.5 -4530 947.5 -4530 947.5 -4555 {}
P 1 14 1450 -4570 1472.5 -4570 1477.5 -4570 1477.5 -4565 1477.5 -4522.5 1470 -4497.5 1465 -4497.5 1435 -4497.5 1430 -4497.5 1422.5 -4522.5 1422.5 -4565 1422.5 -4570 1427.5 -4570 1450 -4570 {bezier=1}
P 1 14 1465 -4567.5 1470 -4567.5 1475 -4567.5 1475 -4562.5 1475 -4542.5 1475 -4537.5 1470 -4537.5 1460 -4537.5 1455 -4537.5 1455 -4542.5 1455 -4562.5 1455 -4567.5 1460 -4567.5 1465 -4567.5 {bezier=1}
P 1 5 1447.5 -4565 1452.5 -4565 1452.5 -4540 1447.5 -4540 1447.5 -4565 {}
P 1 10 1540 -4555 1565 -4555 1575 -4545 1575 -4515 1565 -4505 1515 -4505 1505 -4515 1505 -4545 1515 -4555 1540 -4555 {bezier=1}
P 1 10 1540 -4560 1570 -4560 1580 -4550 1580 -4510 1570 -4500 1510 -4500 1500 -4510 1500 -4550 1510 -4560 1540 -4560 {bezier=1}
P 1 14 920 -8580 942.5 -8580 947.5 -8580 947.5 -8575 947.5 -8532.5 940 -8507.5 935 -8507.5 905 -8507.5 900 -8507.5 892.5 -8532.5 892.5 -8575 892.5 -8580 897.5 -8580 920 -8580 {bezier=1}
P 1 14 935 -8577.5 940 -8577.5 945 -8577.5 945 -8572.5 945 -8552.5 945 -8547.5 940 -8547.5 930 -8547.5 925 -8547.5 925 -8552.5 925 -8572.5 925 -8577.5 930 -8577.5 935 -8577.5 {bezier=1}
P 1 5 917.5 -8575 922.5 -8575 922.5 -8550 917.5 -8550 917.5 -8575 {}
P 1 14 1350 -8580 1372.5 -8580 1377.5 -8580 1377.5 -8575 1377.5 -8532.5 1370 -8507.5 1365 -8507.5 1335 -8507.5 1330 -8507.5 1322.5 -8532.5 1322.5 -8575 1322.5 -8580 1327.5 -8580 1350 -8580 {bezier=1}
P 1 14 1365 -8577.5 1370 -8577.5 1375 -8577.5 1375 -8572.5 1375 -8552.5 1375 -8547.5 1370 -8547.5 1360 -8547.5 1355 -8547.5 1355 -8552.5 1355 -8572.5 1355 -8577.5 1360 -8577.5 1365 -8577.5 {bezier=1}
P 1 5 1347.5 -8575 1352.5 -8575 1352.5 -8550 1347.5 -8550 1347.5 -8575 {}
P 1 14 2120 -8580 2142.5 -8580 2147.5 -8580 2147.5 -8575 2147.5 -8532.5 2140 -8507.5 2135 -8507.5 2105 -8507.5 2100 -8507.5 2092.5 -8532.5 2092.5 -8575 2092.5 -8580 2097.5 -8580 2120 -8580 {bezier=1}
P 1 14 2135 -8577.5 2140 -8577.5 2145 -8577.5 2145 -8572.5 2145 -8552.5 2145 -8547.5 2140 -8547.5 2130 -8547.5 2125 -8547.5 2125 -8552.5 2125 -8572.5 2125 -8577.5 2130 -8577.5 2135 -8577.5 {bezier=1}
P 1 5 2117.5 -8575 2122.5 -8575 2122.5 -8550 2117.5 -8550 2117.5 -8575 {}
P 1 10 1270 -8575 1295 -8575 1305 -8565 1305 -8535 1295 -8525 1245 -8525 1235 -8535 1235 -8565 1245 -8575 1270 -8575 {bezier=1}
P 1 10 1270 -8580 1300 -8580 1310 -8570 1310 -8530 1300 -8520 1240 -8520 1230 -8530 1230 -8570 1240 -8580 1270 -8580 {bezier=1}
P 1 14 865 -9880 887.5 -9880 892.5 -9880 892.5 -9875 892.5 -9832.5 885 -9807.5 880 -9807.5 850 -9807.5 845 -9807.5 837.5 -9832.5 837.5 -9875 837.5 -9880 842.5 -9880 865 -9880 {bezier=1}
P 1 14 880 -9877.5 885 -9877.5 890 -9877.5 890 -9872.5 890 -9852.5 890 -9847.5 885 -9847.5 875 -9847.5 870 -9847.5 870 -9852.5 870 -9872.5 870 -9877.5 875 -9877.5 880 -9877.5 {bezier=1}
P 1 5 862.5 -9875 867.5 -9875 867.5 -9850 862.5 -9850 862.5 -9875 {}
P 1 14 1630 -9870 1652.5 -9870 1657.5 -9870 1657.5 -9865 1657.5 -9822.5 1650 -9797.5 1645 -9797.5 1615 -9797.5 1610 -9797.5 1602.5 -9822.5 1602.5 -9865 1602.5 -9870 1607.5 -9870 1630 -9870 {bezier=1}
P 1 14 1645 -9867.5 1650 -9867.5 1655 -9867.5 1655 -9862.5 1655 -9842.5 1655 -9837.5 1650 -9837.5 1640 -9837.5 1635 -9837.5 1635 -9842.5 1635 -9862.5 1635 -9867.5 1640 -9867.5 1645 -9867.5 {bezier=1}
P 1 5 1627.5 -9865 1632.5 -9865 1632.5 -9840 1627.5 -9840 1627.5 -9865 {}
P 1 10 1710 -9855 1735 -9855 1745 -9845 1745 -9815 1735 -9805 1685 -9805 1675 -9815 1675 -9845 1685 -9855 1710 -9855 {bezier=1}
P 1 10 1710 -9860 1740 -9860 1750 -9850 1750 -9810 1740 -9800 1680 -9800 1670 -9810 1670 -9850 1680 -9860 1710 -9860 {bezier=1}
P 1 14 2410 -9860 2432.5 -9860 2437.5 -9860 2437.5 -9855 2437.5 -9812.5 2430 -9787.5 2425 -9787.5 2395 -9787.5 2390 -9787.5 2382.5 -9812.5 2382.5 -9855 2382.5 -9860 2387.5 -9860 2410 -9860 {bezier=1}
P 1 14 2425 -9857.5 2430 -9857.5 2435 -9857.5 2435 -9852.5 2435 -9832.5 2435 -9827.5 2430 -9827.5 2420 -9827.5 2415 -9827.5 2415 -9832.5 2415 -9852.5 2415 -9857.5 2420 -9857.5 2425 -9857.5 {bezier=1}
P 1 5 2407.5 -9855 2412.5 -9855 2412.5 -9830 2407.5 -9830 2407.5 -9855 {}
P 1 10 2490 -9845 2515 -9845 2525 -9835 2525 -9805 2515 -9795 2465 -9795 2455 -9805 2455 -9835 2465 -9845 2490 -9845 {bezier=1}
P 1 10 2490 -9850 2520 -9850 2530 -9840 2530 -9800 2520 -9790 2460 -9790 2450 -9800 2450 -9840 2460 -9850 2490 -9850 {bezier=1}
P 1 14 690 -8000 712.5 -8000 717.5 -8000 717.5 -7995 717.5 -7952.5 710 -7927.5 705 -7927.5 675 -7927.5 670 -7927.5 662.5 -7952.5 662.5 -7995 662.5 -8000 667.5 -8000 690 -8000 {bezier=1}
P 1 14 705 -7997.5 710 -7997.5 715 -7997.5 715 -7992.5 715 -7972.5 715 -7967.5 710 -7967.5 700 -7967.5 695 -7967.5 695 -7972.5 695 -7992.5 695 -7997.5 700 -7997.5 705 -7997.5 {bezier=1}
P 1 5 687.5 -7995 692.5 -7995 692.5 -7970 687.5 -7970 687.5 -7995 {}
P 1 14 1350 -8020 1372.5 -8020 1377.5 -8020 1377.5 -8015 1377.5 -7972.5 1370 -7947.5 1365 -7947.5 1335 -7947.5 1330 -7947.5 1322.5 -7972.5 1322.5 -8015 1322.5 -8020 1327.5 -8020 1350 -8020 {bezier=1}
P 1 14 1365 -8017.5 1370 -8017.5 1375 -8017.5 1375 -8012.5 1375 -7992.5 1375 -7987.5 1370 -7987.5 1360 -7987.5 1355 -7987.5 1355 -7992.5 1355 -8012.5 1355 -8017.5 1360 -8017.5 1365 -8017.5 {bezier=1}
P 1 5 1347.5 -8015 1352.5 -8015 1352.5 -7990 1347.5 -7990 1347.5 -8015 {}
P 1 14 2540 -8070 2562.5 -8070 2567.5 -8070 2567.5 -8065 2567.5 -8022.5 2560 -7997.5 2555 -7997.5 2525 -7997.5 2520 -7997.5 2512.5 -8022.5 2512.5 -8065 2512.5 -8070 2517.5 -8070 2540 -8070 {bezier=1}
P 1 14 2555 -8067.5 2560 -8067.5 2565 -8067.5 2565 -8062.5 2565 -8042.5 2565 -8037.5 2560 -8037.5 2550 -8037.5 2545 -8037.5 2545 -8042.5 2545 -8062.5 2545 -8067.5 2550 -8067.5 2555 -8067.5 {bezier=1}
P 1 5 2537.5 -8065 2542.5 -8065 2542.5 -8040 2537.5 -8040 2537.5 -8065 {}
P 1 14 1430 -3780 1452.5 -3780 1457.5 -3780 1457.5 -3775 1457.5 -3732.5 1450 -3707.5 1445 -3707.5 1415 -3707.5 1410 -3707.5 1402.5 -3732.5 1402.5 -3775 1402.5 -3780 1407.5 -3780 1430 -3780 {bezier=1}
P 1 14 1445 -3777.5 1450 -3777.5 1455 -3777.5 1455 -3772.5 1455 -3752.5 1455 -3747.5 1450 -3747.5 1440 -3747.5 1435 -3747.5 1435 -3752.5 1435 -3772.5 1435 -3777.5 1440 -3777.5 1445 -3777.5 {bezier=1}
P 1 5 1427.5 -3775 1432.5 -3775 1432.5 -3750 1427.5 -3750 1427.5 -3775 {}
P 1 10 1430 -3935 1455 -3935 1465 -3925 1465 -3895 1455 -3885 1405 -3885 1395 -3895 1395 -3925 1405 -3935 1430 -3935 {bezier=1}
P 1 10 1430 -3940 1460 -3940 1470 -3930 1470 -3890 1460 -3880 1400 -3880 1390 -3890 1390 -3930 1400 -3940 1430 -3940 {bezier=1}
P 1 10 1430 -3855 1455 -3855 1465 -3845 1465 -3815 1455 -3805 1405 -3805 1395 -3815 1395 -3845 1405 -3855 1430 -3855 {bezier=1}
P 1 10 1430 -3860 1460 -3860 1470 -3850 1470 -3810 1460 -3800 1400 -3800 1390 -3810 1390 -3850 1400 -3860 1430 -3860 {bezier=1}
P 1 14 2080 -1050 2102.5 -1050 2107.5 -1050 2107.5 -1045 2107.5 -1002.5 2100 -977.5 2095 -977.5 2065 -977.5 2060 -977.5 2052.5 -1002.5 2052.5 -1045 2052.5 -1050 2057.5 -1050 2080 -1050 {bezier=1}
P 1 14 2095 -1047.5 2100 -1047.5 2105 -1047.5 2105 -1042.5 2105 -1022.5 2105 -1017.5 2100 -1017.5 2090 -1017.5 2085 -1017.5 2085 -1022.5 2085 -1042.5 2085 -1047.5 2090 -1047.5 2095 -1047.5 {bezier=1}
P 1 5 2077.5 -1045 2082.5 -1045 2082.5 -1020 2077.5 -1020 2077.5 -1045 {}
P 1 10 2080 -1115 2105 -1115 2115 -1105 2115 -1075 2105 -1065 2055 -1065 2045 -1075 2045 -1105 2055 -1115 2080 -1115 {bezier=1}
P 1 10 2080 -1120 2110 -1120 2120 -1110 2120 -1070 2110 -1060 2050 -1060 2040 -1070 2040 -1110 2050 -1120 2080 -1120 {bezier=1}
P 1 14 1570 -1020 1592.5 -1020 1597.5 -1020 1597.5 -1015 1597.5 -972.5 1590 -947.5 1585 -947.5 1555 -947.5 1550 -947.5 1542.5 -972.5 1542.5 -1015 1542.5 -1020 1547.5 -1020 1570 -1020 {bezier=1}
P 1 14 1585 -1017.5 1590 -1017.5 1595 -1017.5 1595 -1012.5 1595 -992.5 1595 -987.5 1590 -987.5 1580 -987.5 1575 -987.5 1575 -992.5 1575 -1012.5 1575 -1017.5 1580 -1017.5 1585 -1017.5 {bezier=1}
P 1 5 1567.5 -1015 1572.5 -1015 1572.5 -990 1567.5 -990 1567.5 -1015 {}
P 1 14 1430 -3420 1452.5 -3420 1457.5 -3420 1457.5 -3415 1457.5 -3372.5 1450 -3347.5 1445 -3347.5 1415 -3347.5 1410 -3347.5 1402.5 -3372.5 1402.5 -3415 1402.5 -3420 1407.5 -3420 1430 -3420 {bezier=1}
P 1 14 1415 -3417.5 1410 -3417.5 1405 -3417.5 1405 -3412.5 1405 -3392.5 1405 -3387.5 1410 -3387.5 1420 -3387.5 1425 -3387.5 1425 -3392.5 1425 -3412.5 1425 -3417.5 1420 -3417.5 1415 -3417.5 {bezier=1}
P 1 5 1427.5 -3415 1432.5 -3415 1432.5 -3390 1427.5 -3390 1427.5 -3415 {}
P 1 10 1430 -3485 1455 -3485 1465 -3475 1465 -3445 1455 -3435 1405 -3435 1395 -3445 1395 -3475 1405 -3485 1430 -3485 {bezier=1}
P 1 10 1430 -3490 1460 -3490 1470 -3480 1470 -3440 1460 -3430 1400 -3430 1390 -3440 1390 -3480 1400 -3490 1430 -3490 {bezier=1}
P 1 14 1960 -3530 1982.5 -3530 1987.5 -3530 1987.5 -3525 1987.5 -3482.5 1980 -3457.5 1975 -3457.5 1945 -3457.5 1940 -3457.5 1932.5 -3482.5 1932.5 -3525 1932.5 -3530 1937.5 -3530 1960 -3530 {bezier=1}
P 1 14 1975 -3527.5 1980 -3527.5 1985 -3527.5 1985 -3522.5 1985 -3502.5 1985 -3497.5 1980 -3497.5 1970 -3497.5 1965 -3497.5 1965 -3502.5 1965 -3522.5 1965 -3527.5 1970 -3527.5 1975 -3527.5 {bezier=1}
P 1 5 1957.5 -3525 1962.5 -3525 1962.5 -3500 1957.5 -3500 1957.5 -3525 {}
P 1 14 1580 -3010 1602.5 -3010 1607.5 -3010 1607.5 -3005 1607.5 -2962.5 1600 -2937.5 1595 -2937.5 1565 -2937.5 1560 -2937.5 1552.5 -2962.5 1552.5 -3005 1552.5 -3010 1557.5 -3010 1580 -3010 {bezier=1}
P 1 14 1595 -3007.5 1600 -3007.5 1605 -3007.5 1605 -3002.5 1605 -2982.5 1605 -2977.5 1600 -2977.5 1590 -2977.5 1585 -2977.5 1585 -2982.5 1585 -3002.5 1585 -3007.5 1590 -3007.5 1595 -3007.5 {bezier=1}
P 1 5 1577.5 -3005 1582.5 -3005 1582.5 -2980 1577.5 -2980 1577.5 -3005 {}
P 1 10 1580 -3075 1605 -3075 1615 -3065 1615 -3035 1605 -3025 1555 -3025 1545 -3035 1545 -3065 1555 -3075 1580 -3075 {bezier=1}
P 1 10 1580 -3080 1610 -3080 1620 -3070 1620 -3030 1610 -3020 1550 -3020 1540 -3030 1540 -3070 1550 -3080 1580 -3080 {bezier=1}
P 1 14 2070 -3070 2092.5 -3070 2097.5 -3070 2097.5 -3065 2097.5 -3022.5 2090 -2997.5 2085 -2997.5 2055 -2997.5 2050 -2997.5 2042.5 -3022.5 2042.5 -3065 2042.5 -3070 2047.5 -3070 2070 -3070 {bezier=1}
P 1 14 2085 -3067.5 2090 -3067.5 2095 -3067.5 2095 -3062.5 2095 -3042.5 2095 -3037.5 2090 -3037.5 2080 -3037.5 2075 -3037.5 2075 -3042.5 2075 -3062.5 2075 -3067.5 2080 -3067.5 2085 -3067.5 {bezier=1}
P 1 5 2067.5 -3065 2072.5 -3065 2072.5 -3040 2067.5 -3040 2067.5 -3065 {}
P 1 14 2600 -3200 2622.5 -3200 2627.5 -3200 2627.5 -3195 2627.5 -3152.5 2620 -3127.5 2615 -3127.5 2585 -3127.5 2580 -3127.5 2572.5 -3152.5 2572.5 -3195 2572.5 -3200 2577.5 -3200 2600 -3200 {bezier=1}
P 1 14 2615 -3197.5 2620 -3197.5 2625 -3197.5 2625 -3192.5 2625 -3172.5 2625 -3167.5 2620 -3167.5 2610 -3167.5 2605 -3167.5 2605 -3172.5 2605 -3192.5 2605 -3197.5 2610 -3197.5 2615 -3197.5 {bezier=1}
P 1 5 2597.5 -3195 2602.5 -3195 2602.5 -3170 2597.5 -3170 2597.5 -3195 {}
P 1 10 1960 -2775 1985 -2775 1995 -2765 1995 -2735 1985 -2725 1935 -2725 1925 -2735 1925 -2765 1935 -2775 1960 -2775 {bezier=1}
P 1 10 1960 -2780 1990 -2780 2000 -2770 2000 -2730 1990 -2720 1930 -2720 1920 -2730 1920 -2770 1930 -2780 1960 -2780 {bezier=1}
P 1 10 1960 -2695 1985 -2695 1995 -2685 1995 -2655 1985 -2645 1935 -2645 1925 -2655 1925 -2685 1935 -2695 1960 -2695 {bezier=1}
P 1 10 1960 -2700 1990 -2700 2000 -2690 2000 -2650 1990 -2640 1930 -2640 1920 -2650 1920 -2690 1930 -2700 1960 -2700 {bezier=1}
P 1 14 990 -10150 1012.5 -10150 1017.5 -10150 1017.5 -10145 1017.5 -10102.5 1010 -10077.5 1005 -10077.5 975 -10077.5 970 -10077.5 962.5 -10102.5 962.5 -10145 962.5 -10150 967.5 -10150 990 -10150 {bezier=1}
P 1 14 1005 -10147.5 1010 -10147.5 1015 -10147.5 1015 -10142.5 1015 -10122.5 1015 -10117.5 1010 -10117.5 1000 -10117.5 995 -10117.5 995 -10122.5 995 -10142.5 995 -10147.5 1000 -10147.5 1005 -10147.5 {bezier=1}
P 1 5 987.5 -10145 992.5 -10145 992.5 -10120 987.5 -10120 987.5 -10145 {}
P 1 10 1080 -10135 1105 -10135 1115 -10125 1115 -10095 1105 -10085 1055 -10085 1045 -10095 1045 -10125 1055 -10135 1080 -10135 {bezier=1}
P 1 10 1080 -10140 1110 -10140 1120 -10130 1120 -10090 1110 -10080 1050 -10080 1040 -10090 1040 -10130 1050 -10140 1080 -10140 {bezier=1}
P 1 14 1570 -640 1592.5 -640 1597.5 -640 1597.5 -635 1597.5 -592.5 1590 -567.5 1585 -567.5 1555 -567.5 1550 -567.5 1542.5 -592.5 1542.5 -635 1542.5 -640 1547.5 -640 1570 -640 {bezier=1}
P 1 14 1585 -637.5 1590 -637.5 1595 -637.5 1595 -632.5 1595 -612.5 1595 -607.5 1590 -607.5 1580 -607.5 1575 -607.5 1575 -612.5 1575 -632.5 1575 -637.5 1580 -637.5 1585 -637.5 {bezier=1}
P 1 5 1567.5 -635 1572.5 -635 1572.5 -610 1567.5 -610 1567.5 -635 {}
P 1 14 2080 -590 2102.5 -590 2107.5 -590 2107.5 -585 2107.5 -542.5 2100 -517.5 2095 -517.5 2065 -517.5 2060 -517.5 2052.5 -542.5 2052.5 -585 2052.5 -590 2057.5 -590 2080 -590 {bezier=1}
P 1 14 2095 -587.5 2100 -587.5 2105 -587.5 2105 -582.5 2105 -562.5 2105 -557.5 2100 -557.5 2090 -557.5 2085 -557.5 2085 -562.5 2085 -582.5 2085 -587.5 2090 -587.5 2095 -587.5 {bezier=1}
P 1 5 2077.5 -585 2082.5 -585 2082.5 -560 2077.5 -560 2077.5 -585 {}
P 1 10 2080 -735 2105 -735 2115 -725 2115 -695 2105 -685 2055 -685 2045 -695 2045 -725 2055 -735 2080 -735 {bezier=1}
P 1 10 2080 -740 2110 -740 2120 -730 2120 -690 2110 -680 2050 -680 2040 -690 2040 -730 2050 -740 2080 -740 {bezier=1}
P 1 10 2080 -665 2105 -665 2115 -655 2115 -625 2105 -615 2055 -615 2045 -625 2045 -655 2055 -665 2080 -665 {bezier=1}
P 1 10 2080 -670 2110 -670 2120 -660 2120 -620 2110 -610 2050 -610 2040 -620 2040 -660 2050 -670 2080 -670 {bezier=1}
P 1 10 1920 -2475 1945 -2475 1955 -2465 1955 -2435 1945 -2425 1895 -2425 1885 -2435 1885 -2465 1895 -2475 1920 -2475 {bezier=1}
P 1 10 1920 -2480 1950 -2480 1960 -2470 1960 -2430 1950 -2420 1890 -2420 1880 -2430 1880 -2470 1890 -2480 1920 -2480 {bezier=1}
P 1 10 1830 -2045 1855 -2045 1865 -2035 1865 -2005 1855 -1995 1805 -1995 1795 -2005 1795 -2035 1805 -2045 1830 -2045 {bezier=1}
P 1 10 1830 -2050 1860 -2050 1870 -2040 1870 -2000 1860 -1990 1800 -1990 1790 -2000 1790 -2040 1800 -2050 1830 -2050 {bezier=1}
P 1 14 2500 -3450 2522.5 -3450 2527.5 -3450 2527.5 -3445 2527.5 -3402.5 2520 -3377.5 2515 -3377.5 2485 -3377.5 2480 -3377.5 2472.5 -3402.5 2472.5 -3445 2472.5 -3450 2477.5 -3450 2500 -3450 {bezier=1}
P 1 14 2515 -3447.5 2520 -3447.5 2525 -3447.5 2525 -3442.5 2525 -3422.5 2525 -3417.5 2520 -3417.5 2510 -3417.5 2505 -3417.5 2505 -3422.5 2505 -3442.5 2505 -3447.5 2510 -3447.5 2515 -3447.5 {bezier=1}
P 1 5 2497.5 -3445 2502.5 -3445 2502.5 -3420 2497.5 -3420 2497.5 -3445 {}
P 1 10 1290 -1395 1315 -1395 1325 -1385 1325 -1355 1315 -1345 1265 -1345 1255 -1355 1255 -1385 1265 -1395 1290 -1395 {bezier=1}
P 1 10 1290 -1400 1320 -1400 1330 -1390 1330 -1350 1320 -1340 1260 -1340 1250 -1350 1250 -1390 1260 -1400 1290 -1400 {bezier=1}
P 1 14 1820 -1490 1842.5 -1490 1847.5 -1490 1847.5 -1485 1847.5 -1442.5 1840 -1417.5 1835 -1417.5 1805 -1417.5 1800 -1417.5 1792.5 -1442.5 1792.5 -1485 1792.5 -1490 1797.5 -1490 1820 -1490 {bezier=1}
P 1 14 1835 -1487.5 1840 -1487.5 1845 -1487.5 1845 -1482.5 1845 -1462.5 1845 -1457.5 1840 -1457.5 1830 -1457.5 1825 -1457.5 1825 -1462.5 1825 -1482.5 1825 -1487.5 1830 -1487.5 1835 -1487.5 {bezier=1}
P 1 5 1817.5 -1485 1822.5 -1485 1822.5 -1460 1817.5 -1460 1817.5 -1485 {}
P 1 14 670 -1420 692.5 -1420 697.5 -1420 697.5 -1415 697.5 -1372.5 690 -1347.5 685 -1347.5 655 -1347.5 650 -1347.5 642.5 -1372.5 642.5 -1415 642.5 -1420 647.5 -1420 670 -1420 {bezier=1}
P 1 14 685 -1417.5 690 -1417.5 695 -1417.5 695 -1412.5 695 -1392.5 695 -1387.5 690 -1387.5 680 -1387.5 675 -1387.5 675 -1392.5 675 -1412.5 675 -1417.5 680 -1417.5 685 -1417.5 {bezier=1}
P 1 5 667.5 -1415 672.5 -1415 672.5 -1390 667.5 -1390 667.5 -1415 {}
P 1 14 790 -1420 812.5 -1420 817.5 -1420 817.5 -1415 817.5 -1372.5 810 -1347.5 805 -1347.5 775 -1347.5 770 -1347.5 762.5 -1372.5 762.5 -1415 762.5 -1420 767.5 -1420 790 -1420 {bezier=1}
P 1 14 805 -1417.5 810 -1417.5 815 -1417.5 815 -1412.5 815 -1392.5 815 -1387.5 810 -1387.5 800 -1387.5 795 -1387.5 795 -1392.5 795 -1412.5 795 -1417.5 800 -1417.5 805 -1417.5 {bezier=1}
P 1 5 787.5 -1415 792.5 -1415 792.5 -1390 787.5 -1390 787.5 -1415 {}
P 1 10 790 -1325 815 -1325 825 -1315 825 -1285 815 -1275 765 -1275 755 -1285 755 -1315 765 -1325 790 -1325 {bezier=1}
P 1 10 790 -1330 820 -1330 830 -1320 830 -1280 820 -1270 760 -1270 750 -1280 750 -1320 760 -1330 790 -1330 {bezier=1}
P 1 14 1600 -90 1622.5 -90 1627.5 -90 1627.5 -85 1627.5 -42.5 1620 -17.5 1615 -17.5 1585 -17.5 1580 -17.5 1572.5 -42.5 1572.5 -85 1572.5 -90 1577.5 -90 1600 -90 {bezier=1}
P 1 14 1585 -87.5 1580 -87.5 1575 -87.5 1575 -82.5 1575 -62.5 1575 -57.5 1580 -57.5 1590 -57.5 1595 -57.5 1595 -62.5 1595 -82.5 1595 -87.5 1590 -87.5 1585 -87.5 {bezier=1}
P 1 5 1597.5 -85 1602.5 -85 1602.5 -60 1597.5 -60 1597.5 -85 {}
P 1 10 1600 -165 1625 -165 1635 -155 1635 -125 1625 -115 1575 -115 1565 -125 1565 -155 1575 -165 1600 -165 {bezier=1}
P 1 10 1600 -170 1630 -170 1640 -160 1640 -120 1630 -110 1570 -110 1560 -120 1560 -160 1570 -170 1600 -170 {bezier=1}
P 1 10 1920 -1905 1945 -1905 1955 -1895 1955 -1865 1945 -1855 1895 -1855 1885 -1865 1885 -1895 1895 -1905 1920 -1905 {bezier=1}
P 1 10 1920 -1910 1950 -1910 1960 -1900 1960 -1860 1950 -1850 1890 -1850 1880 -1860 1880 -1900 1890 -1910 1920 -1910 {bezier=1}
P 1 14 2280 -4570 2302.5 -4570 2307.5 -4570 2307.5 -4565 2307.5 -4522.5 2300 -4497.5 2295 -4497.5 2265 -4497.5 2260 -4497.5 2252.5 -4522.5 2252.5 -4565 2252.5 -4570 2257.5 -4570 2280 -4570 {bezier=1}
P 1 14 2295 -4567.5 2300 -4567.5 2305 -4567.5 2305 -4562.5 2305 -4542.5 2305 -4537.5 2300 -4537.5 2290 -4537.5 2285 -4537.5 2285 -4542.5 2285 -4562.5 2285 -4567.5 2290 -4567.5 2295 -4567.5 {bezier=1}
P 1 5 2277.5 -4565 2282.5 -4565 2282.5 -4540 2277.5 -4540 2277.5 -4565 {}
P 1 10 2370 -4555 2395 -4555 2405 -4545 2405 -4515 2395 -4505 2345 -4505 2335 -4515 2335 -4545 2345 -4555 2370 -4555 {bezier=1}
P 1 10 2370 -4560 2400 -4560 2410 -4550 2410 -4510 2400 -4500 2340 -4500 2330 -4510 2330 -4550 2340 -4560 2370 -4560 {bezier=1}
P 1 14 1980 -3780 2002.5 -3780 2007.5 -3780 2007.5 -3775 2007.5 -3732.5 2000 -3707.5 1995 -3707.5 1965 -3707.5 1960 -3707.5 1952.5 -3732.5 1952.5 -3775 1952.5 -3780 1957.5 -3780 1980 -3780 {bezier=1}
P 1 14 1995 -3777.5 2000 -3777.5 2005 -3777.5 2005 -3772.5 2005 -3752.5 2005 -3747.5 2000 -3747.5 1990 -3747.5 1985 -3747.5 1985 -3752.5 1985 -3772.5 1985 -3777.5 1990 -3777.5 1995 -3777.5 {bezier=1}
P 1 5 1977.5 -3775 1982.5 -3775 1982.5 -3750 1977.5 -3750 1977.5 -3775 {}
P 1 10 1980 -3935 2005 -3935 2015 -3925 2015 -3895 2005 -3885 1955 -3885 1945 -3895 1945 -3925 1955 -3935 1980 -3935 {bezier=1}
P 1 10 1980 -3940 2010 -3940 2020 -3930 2020 -3890 2010 -3880 1950 -3880 1940 -3890 1940 -3930 1950 -3940 1980 -3940 {bezier=1}
P 1 10 1980 -3855 2005 -3855 2015 -3845 2015 -3815 2005 -3805 1955 -3805 1945 -3815 1945 -3845 1955 -3855 1980 -3855 {bezier=1}
P 1 10 1980 -3860 2010 -3860 2020 -3850 2020 -3810 2010 -3800 1950 -3800 1940 -3810 1940 -3850 1950 -3860 1980 -3860 {bezier=1}
P 1 14 2340 -2080 2362.5 -2080 2367.5 -2080 2367.5 -2075 2367.5 -2032.5 2360 -2007.5 2355 -2007.5 2325 -2007.5 2320 -2007.5 2312.5 -2032.5 2312.5 -2075 2312.5 -2080 2317.5 -2080 2340 -2080 {bezier=1}
P 1 14 2355 -2077.5 2360 -2077.5 2365 -2077.5 2365 -2072.5 2365 -2052.5 2365 -2047.5 2360 -2047.5 2350 -2047.5 2345 -2047.5 2345 -2052.5 2345 -2072.5 2345 -2077.5 2350 -2077.5 2355 -2077.5 {bezier=1}
P 1 5 2337.5 -2075 2342.5 -2075 2342.5 -2050 2337.5 -2050 2337.5 -2075 {}
P 1 14 810 -2200 832.5 -2200 837.5 -2200 837.5 -2195 837.5 -2152.5 830 -2127.5 825 -2127.5 795 -2127.5 790 -2127.5 782.5 -2152.5 782.5 -2195 782.5 -2200 787.5 -2200 810 -2200 {bezier=1}
P 1 14 825 -2197.5 830 -2197.5 835 -2197.5 835 -2192.5 835 -2172.5 835 -2167.5 830 -2167.5 820 -2167.5 815 -2167.5 815 -2172.5 815 -2192.5 815 -2197.5 820 -2197.5 825 -2197.5 {bezier=1}
P 1 5 807.5 -2195 812.5 -2195 812.5 -2170 807.5 -2170 807.5 -2195 {}
P 1 14 1350 -2180 1372.5 -2180 1377.5 -2180 1377.5 -2175 1377.5 -2132.5 1370 -2107.5 1365 -2107.5 1335 -2107.5 1330 -2107.5 1322.5 -2132.5 1322.5 -2175 1322.5 -2180 1327.5 -2180 1350 -2180 {bezier=1}
P 1 14 1365 -2177.5 1370 -2177.5 1375 -2177.5 1375 -2172.5 1375 -2152.5 1375 -2147.5 1370 -2147.5 1360 -2147.5 1355 -2147.5 1355 -2152.5 1355 -2172.5 1355 -2177.5 1360 -2177.5 1365 -2177.5 {bezier=1}
P 1 5 1347.5 -2175 1352.5 -2175 1352.5 -2150 1347.5 -2150 1347.5 -2175 {}
P 1 14 1260 -1800 1282.5 -1800 1287.5 -1800 1287.5 -1795 1287.5 -1752.5 1280 -1727.5 1275 -1727.5 1245 -1727.5 1240 -1727.5 1232.5 -1752.5 1232.5 -1795 1232.5 -1800 1237.5 -1800 1260 -1800 {bezier=1}
P 1 14 1275 -1797.5 1280 -1797.5 1285 -1797.5 1285 -1792.5 1285 -1772.5 1285 -1767.5 1280 -1767.5 1270 -1767.5 1265 -1767.5 1265 -1772.5 1265 -1792.5 1265 -1797.5 1270 -1797.5 1275 -1797.5 {bezier=1}
P 1 5 1257.5 -1795 1262.5 -1795 1262.5 -1770 1257.5 -1770 1257.5 -1795 {}
P 1 14 2520 -1750 2542.5 -1750 2547.5 -1750 2547.5 -1745 2547.5 -1702.5 2540 -1677.5 2535 -1677.5 2505 -1677.5 2500 -1677.5 2492.5 -1702.5 2492.5 -1745 2492.5 -1750 2497.5 -1750 2520 -1750 {bezier=1}
P 1 14 2535 -1747.5 2540 -1747.5 2545 -1747.5 2545 -1742.5 2545 -1722.5 2545 -1717.5 2540 -1717.5 2530 -1717.5 2525 -1717.5 2525 -1722.5 2525 -1742.5 2525 -1747.5 2530 -1747.5 2535 -1747.5 {bezier=1}
P 1 5 2517.5 -1745 2522.5 -1745 2522.5 -1720 2517.5 -1720 2517.5 -1745 {}
P 1 14 2480 -340 2502.5 -340 2507.5 -340 2507.5 -335 2507.5 -292.5 2500 -267.5 2495 -267.5 2465 -267.5 2460 -267.5 2452.5 -292.5 2452.5 -335 2452.5 -340 2457.5 -340 2480 -340 {bezier=1}
P 1 14 2495 -337.5 2490 -337.5 2485 -337.5 2485 -332.5 2485 -312.5 2485 -307.5 2490 -307.5 2500 -307.5 2505 -307.5 2505 -312.5 2505 -332.5 2505 -337.5 2500 -337.5 2495 -337.5 {bezier=1}
P 1 5 2477.5 -335 2482.5 -335 2482.5 -310 2477.5 -310 2477.5 -335 {}
P 1 14 370 -7430 392.5 -7430 397.5 -7430 397.5 -7425 397.5 -7382.5 390 -7357.5 385 -7357.5 355 -7357.5 350 -7357.5 342.5 -7382.5 342.5 -7425 342.5 -7430 347.5 -7430 370 -7430 {bezier=1}
P 1 14 385 -7427.5 390 -7427.5 395 -7427.5 395 -7422.5 395 -7402.5 395 -7397.5 390 -7397.5 380 -7397.5 375 -7397.5 375 -7402.5 375 -7422.5 375 -7427.5 380 -7427.5 385 -7427.5 {bezier=1}
P 1 5 367.5 -7425 372.5 -7425 372.5 -7400 367.5 -7400 367.5 -7425 {}
P 1 14 900 -7600 922.5 -7600 927.5 -7600 927.5 -7595 927.5 -7552.5 920 -7527.5 915 -7527.5 885 -7527.5 880 -7527.5 872.5 -7552.5 872.5 -7595 872.5 -7600 877.5 -7600 900 -7600 {bezier=1}
P 1 14 915 -7597.5 920 -7597.5 925 -7597.5 925 -7592.5 925 -7572.5 925 -7567.5 920 -7567.5 910 -7567.5 905 -7567.5 905 -7572.5 905 -7592.5 905 -7597.5 910 -7597.5 915 -7597.5 {bezier=1}
P 1 5 897.5 -7595 902.5 -7595 902.5 -7570 897.5 -7570 897.5 -7595 {}
P 1 14 1150 -7640 1172.5 -7640 1177.5 -7640 1177.5 -7635 1177.5 -7592.5 1170 -7567.5 1165 -7567.5 1135 -7567.5 1130 -7567.5 1122.5 -7592.5 1122.5 -7635 1122.5 -7640 1127.5 -7640 1150 -7640 {bezier=1}
P 1 14 1165 -7637.5 1170 -7637.5 1175 -7637.5 1175 -7632.5 1175 -7612.5 1175 -7607.5 1170 -7607.5 1160 -7607.5 1155 -7607.5 1155 -7612.5 1155 -7632.5 1155 -7637.5 1160 -7637.5 1165 -7637.5 {bezier=1}
P 1 5 1147.5 -7635 1152.5 -7635 1152.5 -7610 1147.5 -7610 1147.5 -7635 {}
P 1 14 1440 -7640 1462.5 -7640 1467.5 -7640 1467.5 -7635 1467.5 -7592.5 1460 -7567.5 1455 -7567.5 1425 -7567.5 1420 -7567.5 1412.5 -7592.5 1412.5 -7635 1412.5 -7640 1417.5 -7640 1440 -7640 {bezier=1}
P 1 14 1455 -7637.5 1460 -7637.5 1465 -7637.5 1465 -7632.5 1465 -7612.5 1465 -7607.5 1460 -7607.5 1450 -7607.5 1445 -7607.5 1445 -7612.5 1445 -7632.5 1445 -7637.5 1450 -7637.5 1455 -7637.5 {bezier=1}
P 1 5 1437.5 -7635 1442.5 -7635 1442.5 -7610 1437.5 -7610 1437.5 -7635 {}
P 1 14 1900 -7600 1922.5 -7600 1927.5 -7600 1927.5 -7595 1927.5 -7552.5 1920 -7527.5 1915 -7527.5 1885 -7527.5 1880 -7527.5 1872.5 -7552.5 1872.5 -7595 1872.5 -7600 1877.5 -7600 1900 -7600 {bezier=1}
P 1 14 1915 -7597.5 1920 -7597.5 1925 -7597.5 1925 -7592.5 1925 -7572.5 1925 -7567.5 1920 -7567.5 1910 -7567.5 1905 -7567.5 1905 -7572.5 1905 -7592.5 1905 -7597.5 1910 -7597.5 1915 -7597.5 {bezier=1}
P 1 5 1897.5 -7595 1902.5 -7595 1902.5 -7570 1897.5 -7570 1897.5 -7595 {}
P 1 14 930 -4150 952.5 -4150 957.5 -4150 957.5 -4145 957.5 -4102.5 950 -4077.5 945 -4077.5 915 -4077.5 910 -4077.5 902.5 -4102.5 902.5 -4145 902.5 -4150 907.5 -4150 930 -4150 {bezier=1}
P 1 14 945 -4147.5 950 -4147.5 955 -4147.5 955 -4142.5 955 -4122.5 955 -4117.5 950 -4117.5 940 -4117.5 935 -4117.5 935 -4122.5 935 -4142.5 935 -4147.5 940 -4147.5 945 -4147.5 {bezier=1}
P 1 5 927.5 -4145 932.5 -4145 932.5 -4120 927.5 -4120 927.5 -4145 {}
P 1 14 1770 -4200 1792.5 -4200 1797.5 -4200 1797.5 -4195 1797.5 -4152.5 1790 -4127.5 1785 -4127.5 1755 -4127.5 1750 -4127.5 1742.5 -4152.5 1742.5 -4195 1742.5 -4200 1747.5 -4200 1770 -4200 {bezier=1}
P 1 14 1785 -4197.5 1790 -4197.5 1795 -4197.5 1795 -4192.5 1795 -4172.5 1795 -4167.5 1790 -4167.5 1780 -4167.5 1775 -4167.5 1775 -4172.5 1775 -4192.5 1775 -4197.5 1780 -4197.5 1785 -4197.5 {bezier=1}
P 1 5 1767.5 -4195 1772.5 -4195 1772.5 -4170 1767.5 -4170 1767.5 -4195 {}
P 1 14 2530 -4200 2552.5 -4200 2557.5 -4200 2557.5 -4195 2557.5 -4152.5 2550 -4127.5 2545 -4127.5 2515 -4127.5 2510 -4127.5 2502.5 -4152.5 2502.5 -4195 2502.5 -4200 2507.5 -4200 2530 -4200 {bezier=1}
P 1 14 2545 -4197.5 2550 -4197.5 2555 -4197.5 2555 -4192.5 2555 -4172.5 2555 -4167.5 2550 -4167.5 2540 -4167.5 2535 -4167.5 2535 -4172.5 2535 -4192.5 2535 -4197.5 2540 -4197.5 2545 -4197.5 {bezier=1}
P 1 5 2527.5 -4195 2532.5 -4195 2532.5 -4170 2527.5 -4170 2527.5 -4195 {}
P 1 14 905 -8420 927.5 -8420 932.5 -8420 932.5 -8415 932.5 -8372.5 925 -8347.5 920 -8347.5 890 -8347.5 885 -8347.5 877.5 -8372.5 877.5 -8415 877.5 -8420 882.5 -8420 905 -8420 {bezier=1}
P 1 14 920 -8417.5 925 -8417.5 930 -8417.5 930 -8412.5 930 -8392.5 930 -8387.5 925 -8387.5 915 -8387.5 910 -8387.5 910 -8392.5 910 -8412.5 910 -8417.5 915 -8417.5 920 -8417.5 {bezier=1}
P 1 5 902.5 -8415 907.5 -8415 907.5 -8390 902.5 -8390 902.5 -8415 {}
P 1 14 1440 -8300 1462.5 -8300 1467.5 -8300 1467.5 -8295 1467.5 -8252.5 1460 -8227.5 1455 -8227.5 1425 -8227.5 1420 -8227.5 1412.5 -8252.5 1412.5 -8295 1412.5 -8300 1417.5 -8300 1440 -8300 {bezier=1}
P 1 14 1455 -8297.5 1460 -8297.5 1465 -8297.5 1465 -8292.5 1465 -8272.5 1465 -8267.5 1460 -8267.5 1450 -8267.5 1445 -8267.5 1445 -8272.5 1445 -8292.5 1445 -8297.5 1450 -8297.5 1455 -8297.5 {bezier=1}
P 1 5 1437.5 -8295 1442.5 -8295 1442.5 -8270 1437.5 -8270 1437.5 -8295 {}
P 1 14 1810 -8300 1832.5 -8300 1837.5 -8300 1837.5 -8295 1837.5 -8252.5 1830 -8227.5 1825 -8227.5 1795 -8227.5 1790 -8227.5 1782.5 -8252.5 1782.5 -8295 1782.5 -8300 1787.5 -8300 1810 -8300 {bezier=1}
P 1 14 1825 -8297.5 1830 -8297.5 1835 -8297.5 1835 -8292.5 1835 -8272.5 1835 -8267.5 1830 -8267.5 1820 -8267.5 1815 -8267.5 1815 -8272.5 1815 -8292.5 1815 -8297.5 1820 -8297.5 1825 -8297.5 {bezier=1}
P 1 5 1807.5 -8295 1812.5 -8295 1812.5 -8270 1807.5 -8270 1807.5 -8295 {}
P 1 14 2300 -8300 2322.5 -8300 2327.5 -8300 2327.5 -8295 2327.5 -8252.5 2320 -8227.5 2315 -8227.5 2285 -8227.5 2280 -8227.5 2272.5 -8252.5 2272.5 -8295 2272.5 -8300 2277.5 -8300 2300 -8300 {bezier=1}
P 1 14 2315 -8297.5 2320 -8297.5 2325 -8297.5 2325 -8292.5 2325 -8272.5 2325 -8267.5 2320 -8267.5 2310 -8267.5 2305 -8267.5 2305 -8272.5 2305 -8292.5 2305 -8297.5 2310 -8297.5 2315 -8297.5 {bezier=1}
P 1 5 2297.5 -8295 2302.5 -8295 2302.5 -8270 2297.5 -8270 2297.5 -8295 {}
P 1 14 2250 -7450 2272.5 -7450 2277.5 -7450 2277.5 -7445 2277.5 -7402.5 2270 -7377.5 2265 -7377.5 2235 -7377.5 2230 -7377.5 2222.5 -7402.5 2222.5 -7445 2222.5 -7450 2227.5 -7450 2250 -7450 {bezier=1}
P 1 14 2265 -7447.5 2270 -7447.5 2275 -7447.5 2275 -7442.5 2275 -7422.5 2275 -7417.5 2270 -7417.5 2260 -7417.5 2255 -7417.5 2255 -7422.5 2255 -7442.5 2255 -7447.5 2260 -7447.5 2265 -7447.5 {bezier=1}
P 1 5 2247.5 -7445 2252.5 -7445 2252.5 -7420 2247.5 -7420 2247.5 -7445 {}
P 1 10 1980 -7595 2005 -7595 2015 -7585 2015 -7555 2005 -7545 1955 -7545 1945 -7555 1945 -7585 1955 -7595 1980 -7595 {bezier=1}
P 1 10 1980 -7600 2010 -7600 2020 -7590 2020 -7550 2010 -7540 1950 -7540 1940 -7550 1940 -7590 1950 -7600 1980 -7600 {bezier=1}
P 1 10 510 -7105 535 -7105 545 -7095 545 -7065 535 -7055 485 -7055 475 -7065 475 -7095 485 -7105 510 -7105 {bezier=1}
P 1 10 510 -7110 540 -7110 550 -7100 550 -7060 540 -7050 480 -7050 470 -7060 470 -7100 480 -7110 510 -7110 {bezier=1}
P 1 10 510 -7035 535 -7035 545 -7025 545 -6995 535 -6985 485 -6985 475 -6995 475 -7025 485 -7035 510 -7035 {bezier=1}
P 1 10 510 -7040 540 -7040 550 -7030 550 -6990 540 -6980 480 -6980 470 -6990 470 -7030 480 -7040 510 -7040 {bezier=1}
P 1 10 820 -7105 845 -7105 855 -7095 855 -7065 845 -7055 795 -7055 785 -7065 785 -7095 795 -7105 820 -7105 {bezier=1}
P 1 10 820 -7110 850 -7110 860 -7100 860 -7060 850 -7050 790 -7050 780 -7060 780 -7100 790 -7110 820 -7110 {bezier=1}
P 1 10 820 -7035 845 -7035 855 -7025 855 -6995 845 -6985 795 -6985 785 -6995 785 -7025 795 -7035 820 -7035 {bezier=1}
P 1 10 820 -7040 850 -7040 860 -7030 860 -6990 850 -6980 790 -6980 780 -6990 780 -7030 790 -7040 820 -7040 {bezier=1}
P 1 10 1120 -7105 1145 -7105 1155 -7095 1155 -7065 1145 -7055 1095 -7055 1085 -7065 1085 -7095 1095 -7105 1120 -7105 {bezier=1}
P 1 10 1120 -7110 1150 -7110 1160 -7100 1160 -7060 1150 -7050 1090 -7050 1080 -7060 1080 -7100 1090 -7110 1120 -7110 {bezier=1}
P 1 10 1120 -7035 1145 -7035 1155 -7025 1155 -6995 1145 -6985 1095 -6985 1085 -6995 1085 -7025 1095 -7035 1120 -7035 {bezier=1}
P 1 10 1120 -7040 1150 -7040 1160 -7030 1160 -6990 1150 -6980 1090 -6980 1080 -6990 1080 -7030 1090 -7040 1120 -7040 {bezier=1}
P 1 10 1430 -7105 1455 -7105 1465 -7095 1465 -7065 1455 -7055 1405 -7055 1395 -7065 1395 -7095 1405 -7105 1430 -7105 {bezier=1}
P 1 10 1430 -7110 1460 -7110 1470 -7100 1470 -7060 1460 -7050 1400 -7050 1390 -7060 1390 -7100 1400 -7110 1430 -7110 {bezier=1}
P 1 10 1430 -7035 1455 -7035 1465 -7025 1465 -6995 1455 -6985 1405 -6985 1395 -6995 1395 -7025 1405 -7035 1430 -7035 {bezier=1}
P 1 10 1430 -7040 1460 -7040 1470 -7030 1470 -6990 1460 -6980 1400 -6980 1390 -6990 1390 -7030 1400 -7040 1430 -7040 {bezier=1}
P 1 10 1750 -7105 1775 -7105 1785 -7095 1785 -7065 1775 -7055 1725 -7055 1715 -7065 1715 -7095 1725 -7105 1750 -7105 {bezier=1}
P 1 10 1750 -7110 1780 -7110 1790 -7100 1790 -7060 1780 -7050 1720 -7050 1710 -7060 1710 -7100 1720 -7110 1750 -7110 {bezier=1}
P 1 10 1750 -7035 1775 -7035 1785 -7025 1785 -6995 1775 -6985 1725 -6985 1715 -6995 1715 -7025 1725 -7035 1750 -7035 {bezier=1}
P 1 10 1750 -7040 1780 -7040 1790 -7030 1790 -6990 1780 -6980 1720 -6980 1710 -6990 1710 -7030 1720 -7040 1750 -7040 {bezier=1}
P 1 10 2080 -7105 2105 -7105 2115 -7095 2115 -7065 2105 -7055 2055 -7055 2045 -7065 2045 -7095 2055 -7105 2080 -7105 {bezier=1}
P 1 10 2080 -7110 2110 -7110 2120 -7100 2120 -7060 2110 -7050 2050 -7050 2040 -7060 2040 -7100 2050 -7110 2080 -7110 {bezier=1}
P 1 10 2080 -7035 2105 -7035 2115 -7025 2115 -6995 2105 -6985 2055 -6985 2045 -6995 2045 -7025 2055 -7035 2080 -7035 {bezier=1}
P 1 10 2080 -7040 2110 -7040 2120 -7030 2120 -6990 2110 -6980 2050 -6980 2040 -6990 2040 -7030 2050 -7040 2080 -7040 {bezier=1}
P 1 10 1940 -6915 1965 -6915 1975 -6905 1975 -6875 1965 -6865 1915 -6865 1905 -6875 1905 -6905 1915 -6915 1940 -6915 {bezier=1}
P 1 10 1940 -6920 1970 -6920 1980 -6910 1980 -6870 1970 -6860 1910 -6860 1900 -6870 1900 -6910 1910 -6920 1940 -6920 {bezier=1}
P 1 10 1940 -6845 1965 -6845 1975 -6835 1975 -6805 1965 -6795 1915 -6795 1905 -6805 1905 -6835 1915 -6845 1940 -6845 {bezier=1}
P 1 10 1940 -6850 1970 -6850 1980 -6840 1980 -6800 1970 -6790 1910 -6790 1900 -6800 1900 -6840 1910 -6850 1940 -6850 {bezier=1}
P 1 14 2050 -6900 2072.5 -6900 2077.5 -6900 2077.5 -6895 2077.5 -6852.5 2070 -6827.5 2065 -6827.5 2035 -6827.5 2030 -6827.5 2022.5 -6852.5 2022.5 -6895 2022.5 -6900 2027.5 -6900 2050 -6900 {bezier=1}
P 1 14 2065 -6897.5 2070 -6897.5 2075 -6897.5 2075 -6892.5 2075 -6872.5 2075 -6867.5 2070 -6867.5 2060 -6867.5 2055 -6867.5 2055 -6872.5 2055 -6892.5 2055 -6897.5 2060 -6897.5 2065 -6897.5 {bezier=1}
P 1 5 2047.5 -6895 2052.5 -6895 2052.5 -6870 2047.5 -6870 2047.5 -6895 {}
P 1 14 2035 -6897.5 2040 -6897.5 2045 -6897.5 2045 -6892.5 2045 -6872.5 2045 -6867.5 2040 -6867.5 2030 -6867.5 2025 -6867.5 2025 -6872.5 2025 -6892.5 2025 -6897.5 2030 -6897.5 2035 -6897.5 {bezier=1}
P 1 10 1940 -6485 1965 -6485 1975 -6475 1975 -6445 1965 -6435 1915 -6435 1905 -6445 1905 -6475 1915 -6485 1940 -6485 {bezier=1}
P 1 10 1940 -6490 1970 -6490 1980 -6480 1980 -6440 1970 -6430 1910 -6430 1900 -6440 1900 -6480 1910 -6490 1940 -6490 {bezier=1}
P 1 10 1940 -6415 1965 -6415 1975 -6405 1975 -6375 1965 -6365 1915 -6365 1905 -6375 1905 -6405 1915 -6415 1940 -6415 {bezier=1}
P 1 10 1940 -6420 1970 -6420 1980 -6410 1980 -6370 1970 -6360 1910 -6360 1900 -6370 1900 -6410 1910 -6420 1940 -6420 {bezier=1}
P 1 14 2050 -6470 2072.5 -6470 2077.5 -6470 2077.5 -6465 2077.5 -6422.5 2070 -6397.5 2065 -6397.5 2035 -6397.5 2030 -6397.5 2022.5 -6422.5 2022.5 -6465 2022.5 -6470 2027.5 -6470 2050 -6470 {bezier=1}
P 1 14 2065 -6467.5 2070 -6467.5 2075 -6467.5 2075 -6462.5 2075 -6442.5 2075 -6437.5 2070 -6437.5 2060 -6437.5 2055 -6437.5 2055 -6442.5 2055 -6462.5 2055 -6467.5 2060 -6467.5 2065 -6467.5 {bezier=1}
P 1 5 2047.5 -6465 2052.5 -6465 2052.5 -6440 2047.5 -6440 2047.5 -6465 {}
P 1 14 2035 -6467.5 2040 -6467.5 2045 -6467.5 2045 -6462.5 2045 -6442.5 2045 -6437.5 2040 -6437.5 2030 -6437.5 2025 -6437.5 2025 -6442.5 2025 -6462.5 2025 -6467.5 2030 -6467.5 2035 -6467.5 {bezier=1}
P 1 10 1050 -6005 1075 -6005 1085 -5995 1085 -5965 1075 -5955 1025 -5955 1015 -5965 1015 -5995 1025 -6005 1050 -6005 {bezier=1}
P 1 10 1050 -6010 1080 -6010 1090 -6000 1090 -5960 1080 -5950 1020 -5950 1010 -5960 1010 -6000 1020 -6010 1050 -6010 {bezier=1}
P 1 10 1050 -5935 1075 -5935 1085 -5925 1085 -5895 1075 -5885 1025 -5885 1015 -5895 1015 -5925 1025 -5935 1050 -5935 {bezier=1}
P 1 10 1050 -5940 1080 -5940 1090 -5930 1090 -5890 1080 -5880 1020 -5880 1010 -5890 1010 -5930 1020 -5940 1050 -5940 {bezier=1}
P 1 14 1160 -5990 1182.5 -5990 1187.5 -5990 1187.5 -5985 1187.5 -5942.5 1180 -5917.5 1175 -5917.5 1145 -5917.5 1140 -5917.5 1132.5 -5942.5 1132.5 -5985 1132.5 -5990 1137.5 -5990 1160 -5990 {bezier=1}
P 1 14 1175 -5987.5 1180 -5987.5 1185 -5987.5 1185 -5982.5 1185 -5962.5 1185 -5957.5 1180 -5957.5 1170 -5957.5 1165 -5957.5 1165 -5962.5 1165 -5982.5 1165 -5987.5 1170 -5987.5 1175 -5987.5 {bezier=1}
P 1 5 1157.5 -5985 1162.5 -5985 1162.5 -5960 1157.5 -5960 1157.5 -5985 {}
P 1 14 1145 -5987.5 1150 -5987.5 1155 -5987.5 1155 -5982.5 1155 -5962.5 1155 -5957.5 1150 -5957.5 1140 -5957.5 1135 -5957.5 1135 -5962.5 1135 -5982.5 1135 -5987.5 1140 -5987.5 1145 -5987.5 {bezier=1}
P 1 14 2480 -7510 2502.5 -7510 2507.5 -7510 2507.5 -7505 2507.5 -7462.5 2500 -7437.5 2495 -7437.5 2465 -7437.5 2460 -7437.5 2452.5 -7462.5 2452.5 -7505 2452.5 -7510 2457.5 -7510 2480 -7510 {bezier=1}
P 1 14 2495 -7507.5 2500 -7507.5 2505 -7507.5 2505 -7502.5 2505 -7482.5 2505 -7477.5 2500 -7477.5 2490 -7477.5 2485 -7477.5 2485 -7482.5 2485 -7502.5 2485 -7507.5 2490 -7507.5 2495 -7507.5 {bezier=1}
P 1 5 2477.5 -7505 2482.5 -7505 2482.5 -7480 2477.5 -7480 2477.5 -7505 {}
P 1 10 1520 -5235 1545 -5235 1555 -5225 1555 -5195 1545 -5185 1495 -5185 1485 -5195 1485 -5225 1495 -5235 1520 -5235 {bezier=1}
P 1 10 1520 -5240 1550 -5240 1560 -5230 1560 -5190 1550 -5180 1490 -5180 1480 -5190 1480 -5230 1490 -5240 1520 -5240 {bezier=1}
P 1 14 620 -7640 642.5 -7640 647.5 -7640 647.5 -7635 647.5 -7592.5 640 -7567.5 635 -7567.5 605 -7567.5 600 -7567.5 592.5 -7592.5 592.5 -7635 592.5 -7640 597.5 -7640 620 -7640 {bezier=1}
P 1 14 635 -7637.5 640 -7637.5 645 -7637.5 645 -7632.5 645 -7612.5 645 -7607.5 640 -7607.5 630 -7607.5 625 -7607.5 625 -7612.5 625 -7632.5 625 -7637.5 630 -7637.5 635 -7637.5 {bezier=1}
P 1 5 617.5 -7635 622.5 -7635 622.5 -7610 617.5 -7610 617.5 -7635 {}
P 2 7 897.5 -4690 893.75 -4695 885 -4695 888.75 -4690 885 -4685 893.75 -4685 897.5 -4690 {fill=true}
P 2 7 1457.5 -4690 1453.75 -4695 1445 -4695 1448.75 -4690 1445 -4685 1453.75 -4685 1457.5 -4690 {fill=true}
P 2 7 2277.5 -4690 2273.75 -4695 2265 -4695 2268.75 -4690 2265 -4685 2273.75 -4685 2277.5 -4690 {fill=true}
P 2 7 2030 -1070 2020 -1080 2030 -1080 2030 -1080 2010 -1090 2020 -1070 2020 -1080 {}
P 2 7 1520 -970 1510 -980 1520 -980 1520 -980 1500 -990 1510 -970 1510 -980 {}
P 2 7 2030 -690 2020 -700 2030 -700 2030 -700 2010 -710 2020 -690 2020 -700 {}
P 2 7 1520 -590 1510 -600 1520 -600 1520 -600 1500 -610 1510 -590 1510 -600 {}
P 2 7 455 -7240 451.25 -7245 442.5 -7245 446.25 -7240 442.5 -7235 451.25 -7235 455 -7240 {fill=true}
P 2 7 820 -7245 825 -7248.75 825 -7257.5 820 -7253.75 815 -7257.5 815 -7248.75 820 -7245 {fill=true}
P 2 7 1175 -7170 1178.75 -7165 1187.5 -7165 1183.75 -7170 1187.5 -7175 1178.75 -7175 1175 -7170 {fill=true}
P 2 7 1410 -7175 1405 -7171.25 1405 -7162.5 1410 -7166.25 1415 -7162.5 1415 -7171.25 1410 -7175 {fill=true}
P 2 7 1750 -7175 1755 -7171.25 1755 -7162.5 1750 -7166.25 1745 -7162.5 1745 -7171.25 1750 -7175 {fill=true}
P 2 7 2080 -7255 2085 -7258.75 2085 -7267.5 2080 -7263.75 2075 -7267.5 2075 -7258.75 2080 -7255 {fill=true}
P 2 7 605 -6740 601.25 -6745 592.5 -6745 596.25 -6740 592.5 -6735 601.25 -6735 605 -6740 {fill=true}
P 2 7 1080 -6740 1076.25 -6745 1067.5 -6745 1071.25 -6740 1067.5 -6735 1076.25 -6735 1080 -6740 {fill=true}
P 2 7 1700 -6815 1705 -6818.75 1705 -6827.5 1700 -6823.75 1695 -6827.5 1695 -6818.75 1700 -6815 {fill=true}
P 2 7 605 -6310 601.25 -6315 592.5 -6315 596.25 -6310 592.5 -6305 601.25 -6305 605 -6310 {fill=true}
P 2 7 1055 -6310 1051.25 -6315 1042.5 -6315 1046.25 -6310 1042.5 -6305 1051.25 -6305 1055 -6310 {fill=true}
P 2 7 1765 -6310 1768.75 -6315 1777.5 -6315 1773.75 -6310 1777.5 -6305 1768.75 -6305 1765 -6310 {fill=true}
P 3 6 1280 -1650 1280 -1660 1270 -1660 1280 -1680 1290 -1660 1280 -1660 {}
P 3 6 740 -1650 740 -1660 730 -1660 740 -1680 750 -1660 740 -1660 {}
P 3 6 1750 -4250 1860 -4250 1860 -4260 1900 -4250 1860 -4240 1860 -4250 {}
P 3 6 1680 -4250 1570 -4250 1570 -4260 1530 -4250 1570 -4240 1570 -4250 {}
P 3 6 2420 -4250 2420 -4140 2430 -4140 2420 -4100 2410 -4140 2420 -4140 {}
P 3 6 2420 -4270 2420 -4380 2430 -4380 2420 -4420 2410 -4380 2420 -4380 {}
P 4 4 1115 -6870 1185 -6840 1185 -6730 1125 -6700 {bezier=1}
P 4 4 1122.5 -6705 1127.5 -6695 1105 -6692.5 1122.5 -6705 {fill=1}
P 4 7 1120 -6380 1170 -6380 1170 -6385 1190 -6380 1170 -6375 1170 -6380 1120 -6380 {fill=1}
P 4 7 1120 -6380 1070 -6380 1070 -6385 1050 -6380 1070 -6375 1070 -6380 1120 -6380 {fill=1}
P 5 7 1105 -9550 1101.25 -9555 1092.5 -9555 1096.25 -9550 1092.5 -9545 1101.25 -9545 1105 -9550 {fill=true}
P 5 7 1427.5 -9580 1423.75 -9585 1415 -9585 1418.75 -9580 1415 -9575 1423.75 -9575 1427.5 -9580 {fill=true}
P 5 7 1645 -9550 1641.25 -9555 1632.5 -9555 1636.25 -9550 1632.5 -9545 1641.25 -9545 1645 -9550 {fill=true}
P 5 7 1967.5 -9580 1963.75 -9585 1955 -9585 1958.75 -9580 1955 -9575 1963.75 -9575 1967.5 -9580 {fill=true}
P 5 7 575 -9550 571.25 -9555 562.5 -9555 566.25 -9550 562.5 -9545 571.25 -9545 575 -9550 {fill=true}
P 5 7 897.5 -9580 893.75 -9585 885 -9585 888.75 -9580 885 -9575 893.75 -9575 897.5 -9580 {fill=true}
P 5 7 575 -9090 571.25 -9095 562.5 -9095 566.25 -9090 562.5 -9085 571.25 -9085 575 -9090 {fill=true}
P 5 7 897.5 -9120 893.75 -9125 885 -9125 888.75 -9120 885 -9115 893.75 -9115 897.5 -9120 {fill=true}
P 5 7 1115 -9090 1111.25 -9095 1102.5 -9095 1106.25 -9090 1102.5 -9085 1111.25 -9085 1115 -9090 {fill=true}
P 5 7 1437.5 -9120 1433.75 -9125 1425 -9125 1428.75 -9120 1425 -9115 1433.75 -9115 1437.5 -9120 {fill=true}
P 5 7 575 -5500 571.25 -5505 562.5 -5505 566.25 -5500 562.5 -5495 571.25 -5495 575 -5500 {fill=true}
P 5 7 897.5 -5530 893.75 -5535 885 -5535 888.75 -5530 885 -5525 893.75 -5525 897.5 -5530 {fill=true}
P 5 7 1115 -5500 1111.25 -5505 1102.5 -5505 1106.25 -5500 1102.5 -5495 1111.25 -5495 1115 -5500 {fill=true}
P 5 7 1437.5 -5530 1433.75 -5535 1425 -5535 1428.75 -5530 1425 -5525 1433.75 -5525 1437.5 -5530 {fill=true}
P 5 7 575 -5100 571.25 -5105 562.5 -5105 566.25 -5100 562.5 -5095 571.25 -5095 575 -5100 {fill=true}
P 5 7 897.5 -5130 893.75 -5135 885 -5135 888.75 -5130 885 -5125 893.75 -5125 897.5 -5130 {fill=true}
P 5 7 1115 -5100 1111.25 -5105 1102.5 -5105 1106.25 -5100 1102.5 -5095 1111.25 -5095 1115 -5100 {fill=true}
P 5 7 1437.5 -5130 1433.75 -5135 1425 -5135 1428.75 -5130 1425 -5125 1433.75 -5125 1437.5 -5130 {fill=true}
P 5 7 575 -4660 571.25 -4665 562.5 -4665 566.25 -4660 562.5 -4655 571.25 -4655 575 -4660 {fill=true}
P 5 7 1765 -4660 1761.25 -4665 1752.5 -4665 1756.25 -4660 1752.5 -4655 1761.25 -4655 1765 -4660 {fill=true}
P 5 7 1135 -4660 1131.25 -4665 1122.5 -4665 1126.25 -4660 1122.5 -4655 1131.25 -4655 1135 -4660 {fill=true}
P 5 7 1105 -8720 1101.25 -8725 1092.5 -8725 1096.25 -8720 1092.5 -8715 1101.25 -8715 1105 -8720 {fill=true}
P 5 7 1427.5 -8750 1423.75 -8755 1415 -8755 1418.75 -8750 1415 -8745 1423.75 -8745 1427.5 -8750 {fill=true}
P 5 7 575 -8720 571.25 -8725 562.5 -8725 566.25 -8720 562.5 -8715 571.25 -8715 575 -8720 {fill=true}
P 5 7 897.5 -8750 893.75 -8755 885 -8755 888.75 -8750 885 -8745 893.75 -8745 897.5 -8750 {fill=true}
P 5 7 1605 -8720 1601.25 -8725 1592.5 -8725 1596.25 -8720 1592.5 -8715 1601.25 -8715 1605 -8720 {fill=true}
P 5 7 1927.5 -8750 1923.75 -8755 1915 -8755 1918.75 -8750 1915 -8745 1923.75 -8745 1927.5 -8750 {fill=true}
P 5 7 1645 -10020 1641.25 -10025 1632.5 -10025 1636.25 -10020 1632.5 -10015 1641.25 -10015 1645 -10020 {fill=true}
P 5 7 1967.5 -10050 1963.75 -10055 1955 -10055 1958.75 -10050 1955 -10045 1963.75 -10045 1967.5 -10050 {fill=true}
P 5 7 520 -10020 516.25 -10025 507.5 -10025 511.25 -10020 507.5 -10015 516.25 -10015 520 -10020 {fill=true}
P 5 7 842.5 -10050 838.75 -10055 830 -10055 833.75 -10050 830 -10045 838.75 -10045 842.5 -10050 {fill=true}
P 5 7 2105 -10020 2101.25 -10025 2092.5 -10025 2096.25 -10020 2092.5 -10015 2101.25 -10015 2105 -10020 {fill=true}
P 5 7 2427.5 -10050 2423.75 -10055 2415 -10055 2418.75 -10050 2415 -10045 2423.75 -10045 2427.5 -10050 {fill=true}
P 5 7 595 -7880 591.25 -7885 582.5 -7885 586.25 -7880 582.5 -7875 591.25 -7875 595 -7880 {fill=true}
P 5 7 917.5 -7910 913.75 -7915 905 -7915 908.75 -7910 905 -7905 913.75 -7905 917.5 -7910 {fill=true}
P 5 7 1135 -7880 1131.25 -7885 1122.5 -7885 1126.25 -7880 1122.5 -7875 1131.25 -7875 1135 -7880 {fill=true}
P 5 7 1457.5 -7910 1453.75 -7915 1445 -7915 1448.75 -7910 1445 -7905 1453.75 -7905 1457.5 -7910 {fill=true}
P 5 7 2265 -7880 2261.25 -7885 2252.5 -7885 2256.25 -7880 2252.5 -7875 2261.25 -7875 2265 -7880 {fill=true}
P 5 7 2587.5 -7910 2583.75 -7915 2575 -7915 2578.75 -7910 2575 -7905 2583.75 -7905 2587.5 -7910 {fill=true}
P 5 7 1105 -10020 1101.25 -10025 1092.5 -10025 1096.25 -10020 1092.5 -10015 1101.25 -10015 1105 -10020 {fill=true}
P 5 7 1427.5 -10050 1423.75 -10055 1415 -10055 1418.75 -10050 1415 -10045 1423.75 -10045 1427.5 -10050 {fill=true}
P 5 7 655 -190 651.25 -195 642.5 -195 646.25 -190 642.5 -185 651.25 -185 655 -190 {fill=true}
P 5 7 977.5 -220 973.75 -225 965 -225 968.75 -220 965 -215 973.75 -215 977.5 -220 {fill=true}
P 5 7 1255 -190 1251.25 -195 1242.5 -195 1246.25 -190 1242.5 -185 1251.25 -185 1255 -190 {fill=true}
P 5 7 1577.5 -220 1573.75 -225 1565 -225 1568.75 -220 1565 -215 1573.75 -215 1577.5 -220 {fill=true}
P 5 7 1865 -190 1861.25 -195 1852.5 -195 1856.25 -190 1852.5 -185 1861.25 -185 1865 -190 {fill=true}
P 5 7 2187.5 -220 2183.75 -225 2175 -225 2178.75 -220 2175 -215 2183.75 -215 2187.5 -220 {fill=true}
P 5 7 595 -4250 591.25 -4255 582.5 -4255 586.25 -4250 582.5 -4245 591.25 -4245 595 -4250 {fill=true}
P 5 7 917.5 -4280 913.75 -4285 905 -4285 908.75 -4280 905 -4275 913.75 -4275 917.5 -4280 {fill=true}
P 5 7 1155 -4250 1151.25 -4255 1142.5 -4255 1146.25 -4250 1142.5 -4245 1151.25 -4245 1155 -4250 {fill=true}
P 5 7 1477.5 -4280 1473.75 -4285 1465 -4285 1468.75 -4280 1465 -4275 1473.75 -4275 1477.5 -4280 {fill=true}
P 5 7 540 -8300 536.25 -8305 527.5 -8305 531.25 -8300 527.5 -8295 536.25 -8295 540 -8300 {fill=true}
P 5 7 862.5 -8330 858.75 -8335 850 -8335 853.75 -8330 850 -8325 858.75 -8325 862.5 -8330 {fill=true}
P 5 7 1105 -8300 1101.25 -8305 1092.5 -8305 1096.25 -8300 1092.5 -8295 1101.25 -8295 1105 -8300 {fill=true}
P 5 7 1427.5 -8330 1423.75 -8335 1415 -8335 1418.75 -8330 1415 -8325 1423.75 -8325 1427.5 -8330 {fill=true}
P 5 7 1605 -8300 1601.25 -8305 1592.5 -8305 1596.25 -8300 1592.5 -8295 1601.25 -8295 1605 -8300 {fill=true}
P 5 7 1927.5 -8330 1923.75 -8335 1915 -8335 1918.75 -8330 1915 -8325 1923.75 -8325 1927.5 -8330 {fill=true}
P 5 7 2095 -8300 2091.25 -8305 2082.5 -8305 2086.25 -8300 2082.5 -8295 2091.25 -8295 2095 -8300 {fill=true}
P 5 7 2417.5 -8330 2413.75 -8335 2405 -8335 2408.75 -8330 2405 -8325 2413.75 -8325 2417.5 -8330 {fill=true}
P 7 14 905 -9407.5 910 -9407.5 915 -9407.5 915 -9402.5 915 -9382.5 915 -9377.5 910 -9377.5 900 -9377.5 895 -9377.5 895 -9382.5 895 -9402.5 895 -9407.5 900 -9407.5 905 -9407.5 {fill=1
bezier=1}
P 7 14 1335 -9407.5 1340 -9407.5 1345 -9407.5 1345 -9402.5 1345 -9382.5 1345 -9377.5 1340 -9377.5 1330 -9377.5 1325 -9377.5 1325 -9382.5 1325 -9402.5 1325 -9407.5 1330 -9407.5 1335 -9407.5 {fill=1
bezier=1}
P 7 14 1405 -9217.5 1410 -9217.5 1415 -9217.5 1415 -9212.5 1415 -9192.5 1415 -9187.5 1410 -9187.5 1400 -9187.5 1395 -9187.5 1395 -9192.5 1395 -9212.5 1395 -9217.5 1400 -9217.5 1405 -9217.5 {fill=1
bezier=1}
P 7 14 1425 -5637.5 1430 -5637.5 1435 -5637.5 1435 -5632.5 1435 -5612.5 1435 -5607.5 1430 -5607.5 1420 -5607.5 1415 -5607.5 1415 -5612.5 1415 -5632.5 1415 -5637.5 1420 -5637.5 1425 -5637.5 {fill=1
bezier=1}
P 7 14 1425 -5237.5 1430 -5237.5 1435 -5237.5 1435 -5232.5 1435 -5212.5 1435 -5207.5 1430 -5207.5 1420 -5207.5 1415 -5207.5 1415 -5212.5 1415 -5232.5 1415 -5237.5 1420 -5237.5 1425 -5237.5 {fill=1
bezier=1}
P 7 14 935 -4557.5 940 -4557.5 945 -4557.5 945 -4552.5 945 -4532.5 945 -4527.5 940 -4527.5 930 -4527.5 925 -4527.5 925 -4532.5 925 -4552.5 925 -4557.5 930 -4557.5 935 -4557.5 {fill=1
bezier=1}
P 7 14 1435 -4567.5 1440 -4567.5 1445 -4567.5 1445 -4562.5 1445 -4542.5 1445 -4537.5 1440 -4537.5 1430 -4537.5 1425 -4537.5 1425 -4542.5 1425 -4562.5 1425 -4567.5 1430 -4567.5 1435 -4567.5 {fill=1
bezier=1}
P 7 14 905 -8577.5 910 -8577.5 915 -8577.5 915 -8572.5 915 -8552.5 915 -8547.5 910 -8547.5 900 -8547.5 895 -8547.5 895 -8552.5 895 -8572.5 895 -8577.5 900 -8577.5 905 -8577.5 {fill=1
bezier=1}
P 7 14 850 -9877.5 855 -9877.5 860 -9877.5 860 -9872.5 860 -9852.5 860 -9847.5 855 -9847.5 845 -9847.5 840 -9847.5 840 -9852.5 840 -9872.5 840 -9877.5 845 -9877.5 850 -9877.5 {fill=1
bezier=1}
P 7 14 1615 -9867.5 1620 -9867.5 1625 -9867.5 1625 -9862.5 1625 -9842.5 1625 -9837.5 1620 -9837.5 1610 -9837.5 1605 -9837.5 1605 -9842.5 1605 -9862.5 1605 -9867.5 1610 -9867.5 1615 -9867.5 {fill=1
bezier=1}
P 7 14 2395 -9857.5 2400 -9857.5 2405 -9857.5 2405 -9852.5 2405 -9832.5 2405 -9827.5 2400 -9827.5 2390 -9827.5 2385 -9827.5 2385 -9832.5 2385 -9852.5 2385 -9857.5 2390 -9857.5 2395 -9857.5 {fill=1
bezier=1}
P 7 14 675 -7997.5 680 -7997.5 685 -7997.5 685 -7992.5 685 -7972.5 685 -7967.5 680 -7967.5 670 -7967.5 665 -7967.5 665 -7972.5 665 -7992.5 665 -7997.5 670 -7997.5 675 -7997.5 {fill=1
bezier=1}
P 7 14 1335 -8017.5 1340 -8017.5 1345 -8017.5 1345 -8012.5 1345 -7992.5 1345 -7987.5 1340 -7987.5 1330 -7987.5 1325 -7987.5 1325 -7992.5 1325 -8012.5 1325 -8017.5 1330 -8017.5 1335 -8017.5 {fill=1
bezier=1}
P 7 14 1415 -3777.5 1420 -3777.5 1425 -3777.5 1425 -3772.5 1425 -3752.5 1425 -3747.5 1420 -3747.5 1410 -3747.5 1405 -3747.5 1405 -3752.5 1405 -3772.5 1405 -3777.5 1410 -3777.5 1415 -3777.5 {fill=1
bezier=1}
P 7 14 2065 -1047.5 2070 -1047.5 2075 -1047.5 2075 -1042.5 2075 -1022.5 2075 -1017.5 2070 -1017.5 2060 -1017.5 2055 -1017.5 2055 -1022.5 2055 -1042.5 2055 -1047.5 2060 -1047.5 2065 -1047.5 {fill=1
bezier=1}
P 7 14 1555 -1017.5 1560 -1017.5 1565 -1017.5 1565 -1012.5 1565 -992.5 1565 -987.5 1560 -987.5 1550 -987.5 1545 -987.5 1545 -992.5 1545 -1012.5 1545 -1017.5 1550 -1017.5 1555 -1017.5 {fill=1
bezier=1}
P 7 14 1445 -3417.5 1440 -3417.5 1435 -3417.5 1435 -3412.5 1435 -3392.5 1435 -3387.5 1440 -3387.5 1450 -3387.5 1455 -3387.5 1455 -3392.5 1455 -3412.5 1455 -3417.5 1450 -3417.5 1445 -3417.5 {fill=1
bezier=1}
P 7 14 1945 -3527.5 1950 -3527.5 1955 -3527.5 1955 -3522.5 1955 -3502.5 1955 -3497.5 1950 -3497.5 1940 -3497.5 1935 -3497.5 1935 -3502.5 1935 -3522.5 1935 -3527.5 1940 -3527.5 1945 -3527.5 {fill=1
bezier=1}
P 7 14 1565 -3007.5 1570 -3007.5 1575 -3007.5 1575 -3002.5 1575 -2982.5 1575 -2977.5 1570 -2977.5 1560 -2977.5 1555 -2977.5 1555 -2982.5 1555 -3002.5 1555 -3007.5 1560 -3007.5 1565 -3007.5 {fill=1
bezier=1}
P 7 14 2055 -3067.5 2060 -3067.5 2065 -3067.5 2065 -3062.5 2065 -3042.5 2065 -3037.5 2060 -3037.5 2050 -3037.5 2045 -3037.5 2045 -3042.5 2045 -3062.5 2045 -3067.5 2050 -3067.5 2055 -3067.5 {fill=1
bezier=1}
P 7 14 975 -10147.5 980 -10147.5 985 -10147.5 985 -10142.5 985 -10122.5 985 -10117.5 980 -10117.5 970 -10117.5 965 -10117.5 965 -10122.5 965 -10142.5 965 -10147.5 970 -10147.5 975 -10147.5 {fill=1
bezier=1}
P 7 14 1555 -637.5 1560 -637.5 1565 -637.5 1565 -632.5 1565 -612.5 1565 -607.5 1560 -607.5 1550 -607.5 1545 -607.5 1545 -612.5 1545 -632.5 1545 -637.5 1550 -637.5 1555 -637.5 {fill=1
bezier=1}
P 7 14 2065 -587.5 2070 -587.5 2075 -587.5 2075 -582.5 2075 -562.5 2075 -557.5 2070 -557.5 2060 -557.5 2055 -557.5 2055 -562.5 2055 -582.5 2055 -587.5 2060 -587.5 2065 -587.5 {fill=1
bezier=1}
P 7 14 2485 -3447.5 2490 -3447.5 2495 -3447.5 2495 -3442.5 2495 -3422.5 2495 -3417.5 2490 -3417.5 2480 -3417.5 2475 -3417.5 2475 -3422.5 2475 -3442.5 2475 -3447.5 2480 -3447.5 2485 -3447.5 {fill=1
bezier=1}
P 7 14 1805 -1487.5 1810 -1487.5 1815 -1487.5 1815 -1482.5 1815 -1462.5 1815 -1457.5 1810 -1457.5 1800 -1457.5 1795 -1457.5 1795 -1462.5 1795 -1482.5 1795 -1487.5 1800 -1487.5 1805 -1487.5 {fill=1
bezier=1}
P 7 14 655 -1417.5 660 -1417.5 665 -1417.5 665 -1412.5 665 -1392.5 665 -1387.5 660 -1387.5 650 -1387.5 645 -1387.5 645 -1392.5 645 -1412.5 645 -1417.5 650 -1417.5 655 -1417.5 {fill=1
bezier=1}
P 7 14 775 -1417.5 780 -1417.5 785 -1417.5 785 -1412.5 785 -1392.5 785 -1387.5 780 -1387.5 770 -1387.5 765 -1387.5 765 -1392.5 765 -1412.5 765 -1417.5 770 -1417.5 775 -1417.5 {fill=1
bezier=1}
P 7 14 1615 -87.5 1610 -87.5 1605 -87.5 1605 -82.5 1605 -62.5 1605 -57.5 1610 -57.5 1620 -57.5 1625 -57.5 1625 -62.5 1625 -82.5 1625 -87.5 1620 -87.5 1615 -87.5 {fill=1
bezier=1}
P 7 14 2265 -4567.5 2270 -4567.5 2275 -4567.5 2275 -4562.5 2275 -4542.5 2275 -4537.5 2270 -4537.5 2260 -4537.5 2255 -4537.5 2255 -4542.5 2255 -4562.5 2255 -4567.5 2260 -4567.5 2265 -4567.5 {fill=1
bezier=1}
P 7 14 1965 -3777.5 1970 -3777.5 1975 -3777.5 1975 -3772.5 1975 -3752.5 1975 -3747.5 1970 -3747.5 1960 -3747.5 1955 -3747.5 1955 -3752.5 1955 -3772.5 1955 -3777.5 1960 -3777.5 1965 -3777.5 {fill=1
bezier=1}
P 7 14 2325 -2077.5 2330 -2077.5 2335 -2077.5 2335 -2072.5 2335 -2052.5 2335 -2047.5 2330 -2047.5 2320 -2047.5 2315 -2047.5 2315 -2052.5 2315 -2072.5 2315 -2077.5 2320 -2077.5 2325 -2077.5 {fill=1
bezier=1}
P 7 14 795 -2197.5 800 -2197.5 805 -2197.5 805 -2192.5 805 -2172.5 805 -2167.5 800 -2167.5 790 -2167.5 785 -2167.5 785 -2172.5 785 -2192.5 785 -2197.5 790 -2197.5 795 -2197.5 {fill=1
bezier=1}
P 7 14 1335 -2177.5 1340 -2177.5 1345 -2177.5 1345 -2172.5 1345 -2152.5 1345 -2147.5 1340 -2147.5 1330 -2147.5 1325 -2147.5 1325 -2152.5 1325 -2172.5 1325 -2177.5 1330 -2177.5 1335 -2177.5 {fill=1
bezier=1}
P 7 14 1245 -1797.5 1250 -1797.5 1255 -1797.5 1255 -1792.5 1255 -1772.5 1255 -1767.5 1250 -1767.5 1240 -1767.5 1235 -1767.5 1235 -1772.5 1235 -1792.5 1235 -1797.5 1240 -1797.5 1245 -1797.5 {fill=1
bezier=1}
P 7 14 2505 -1747.5 2510 -1747.5 2515 -1747.5 2515 -1742.5 2515 -1722.5 2515 -1717.5 2510 -1717.5 2500 -1717.5 2495 -1717.5 2495 -1722.5 2495 -1742.5 2495 -1747.5 2500 -1747.5 2505 -1747.5 {fill=1
bezier=1}
P 7 14 2465 -337.5 2460 -337.5 2455 -337.5 2455 -332.5 2455 -312.5 2455 -307.5 2460 -307.5 2470 -307.5 2475 -307.5 2475 -312.5 2475 -332.5 2475 -337.5 2470 -337.5 2465 -337.5 {fill=1
bezier=1}
P 7 14 2525 -8067.5 2530 -8067.5 2535 -8067.5 2535 -8062.5 2535 -8042.5 2535 -8037.5 2530 -8037.5 2520 -8037.5 2515 -8037.5 2515 -8042.5 2515 -8062.5 2515 -8067.5 2520 -8067.5 2525 -8067.5 {fill=1
bezier=1}
P 7 14 1335 -8577.5 1340 -8577.5 1345 -8577.5 1345 -8572.5 1345 -8552.5 1345 -8547.5 1340 -8547.5 1330 -8547.5 1325 -8547.5 1325 -8552.5 1325 -8572.5 1325 -8577.5 1330 -8577.5 1335 -8577.5 {fill=1
bezier=1}
P 7 14 2105 -8577.5 2110 -8577.5 2115 -8577.5 2115 -8572.5 2115 -8552.5 2115 -8547.5 2110 -8547.5 2100 -8547.5 2095 -8547.5 2095 -8552.5 2095 -8572.5 2095 -8577.5 2100 -8577.5 2105 -8577.5 {fill=1
bezier=1}
P 7 14 355 -7427.5 360 -7427.5 365 -7427.5 365 -7422.5 365 -7402.5 365 -7397.5 360 -7397.5 350 -7397.5 345 -7397.5 345 -7402.5 345 -7422.5 345 -7427.5 350 -7427.5 355 -7427.5 {fill=1
bezier=1}
P 7 14 885 -7597.5 890 -7597.5 895 -7597.5 895 -7592.5 895 -7572.5 895 -7567.5 890 -7567.5 880 -7567.5 875 -7567.5 875 -7572.5 875 -7592.5 875 -7597.5 880 -7597.5 885 -7597.5 {fill=1
bezier=1}
P 7 14 1135 -7637.5 1140 -7637.5 1145 -7637.5 1145 -7632.5 1145 -7612.5 1145 -7607.5 1140 -7607.5 1130 -7607.5 1125 -7607.5 1125 -7612.5 1125 -7632.5 1125 -7637.5 1130 -7637.5 1135 -7637.5 {fill=1
bezier=1}
P 7 14 1425 -7637.5 1430 -7637.5 1435 -7637.5 1435 -7632.5 1435 -7612.5 1435 -7607.5 1430 -7607.5 1420 -7607.5 1415 -7607.5 1415 -7612.5 1415 -7632.5 1415 -7637.5 1420 -7637.5 1425 -7637.5 {fill=1
bezier=1}
P 7 14 1885 -7597.5 1890 -7597.5 1895 -7597.5 1895 -7592.5 1895 -7572.5 1895 -7567.5 1890 -7567.5 1880 -7567.5 1875 -7567.5 1875 -7572.5 1875 -7592.5 1875 -7597.5 1880 -7597.5 1885 -7597.5 {fill=1
bezier=1}
P 7 14 2105 -9407.5 2110 -9407.5 2115 -9407.5 2115 -9402.5 2115 -9382.5 2115 -9377.5 2110 -9377.5 2100 -9377.5 2095 -9377.5 2095 -9382.5 2095 -9402.5 2095 -9407.5 2100 -9407.5 2105 -9407.5 {fill=1
bezier=1}
P 7 14 2585 -3197.5 2590 -3197.5 2595 -3197.5 2595 -3192.5 2595 -3172.5 2595 -3167.5 2590 -3167.5 2580 -3167.5 2575 -3167.5 2575 -3172.5 2575 -3192.5 2575 -3197.5 2580 -3197.5 2585 -3197.5 {fill=1
bezier=1}
P 7 14 915 -4147.5 920 -4147.5 925 -4147.5 925 -4142.5 925 -4122.5 925 -4117.5 920 -4117.5 910 -4117.5 905 -4117.5 905 -4122.5 905 -4142.5 905 -4147.5 910 -4147.5 915 -4147.5 {fill=1
bezier=1}
P 7 14 1755 -4197.5 1760 -4197.5 1765 -4197.5 1765 -4192.5 1765 -4172.5 1765 -4167.5 1760 -4167.5 1750 -4167.5 1745 -4167.5 1745 -4172.5 1745 -4192.5 1745 -4197.5 1750 -4197.5 1755 -4197.5 {fill=1
bezier=1}
P 7 14 2515 -4197.5 2520 -4197.5 2525 -4197.5 2525 -4192.5 2525 -4172.5 2525 -4167.5 2520 -4167.5 2510 -4167.5 2505 -4167.5 2505 -4172.5 2505 -4192.5 2505 -4197.5 2510 -4197.5 2515 -4197.5 {fill=1
bezier=1}
P 7 14 890 -8417.5 895 -8417.5 900 -8417.5 900 -8412.5 900 -8392.5 900 -8387.5 895 -8387.5 885 -8387.5 880 -8387.5 880 -8392.5 880 -8412.5 880 -8417.5 885 -8417.5 890 -8417.5 {fill=1
bezier=1}
P 7 14 1425 -8297.5 1430 -8297.5 1435 -8297.5 1435 -8292.5 1435 -8272.5 1435 -8267.5 1430 -8267.5 1420 -8267.5 1415 -8267.5 1415 -8272.5 1415 -8292.5 1415 -8297.5 1420 -8297.5 1425 -8297.5 {fill=1
bezier=1}
P 7 14 1795 -8297.5 1800 -8297.5 1805 -8297.5 1805 -8292.5 1805 -8272.5 1805 -8267.5 1800 -8267.5 1790 -8267.5 1785 -8267.5 1785 -8272.5 1785 -8292.5 1785 -8297.5 1790 -8297.5 1795 -8297.5 {fill=1
bezier=1}
P 7 14 2285 -8297.5 2290 -8297.5 2295 -8297.5 2295 -8292.5 2295 -8272.5 2295 -8267.5 2290 -8267.5 2280 -8267.5 2275 -8267.5 2275 -8272.5 2275 -8292.5 2275 -8297.5 2280 -8297.5 2285 -8297.5 {fill=1
bezier=1}
P 7 14 2235 -7447.5 2240 -7447.5 2245 -7447.5 2245 -7442.5 2245 -7422.5 2245 -7417.5 2240 -7417.5 2230 -7417.5 2225 -7417.5 2225 -7422.5 2225 -7442.5 2225 -7447.5 2230 -7447.5 2235 -7447.5 {fill=1
bezier=1}
P 7 14 2465 -7507.5 2470 -7507.5 2475 -7507.5 2475 -7502.5 2475 -7482.5 2475 -7477.5 2470 -7477.5 2460 -7477.5 2455 -7477.5 2455 -7482.5 2455 -7502.5 2455 -7507.5 2460 -7507.5 2465 -7507.5 {fill=1
bezier=1}
P 7 14 605 -7637.5 610 -7637.5 615 -7637.5 615 -7632.5 615 -7612.5 615 -7607.5 610 -7607.5 600 -7607.5 595 -7607.5 595 -7612.5 595 -7632.5 595 -7637.5 600 -7637.5 605 -7637.5 {fill=1
bezier=1}
P 9 8 1770 -7960 1912.5 -7932.5 1890 -7900 1980 -7840 1960 -7810 1870 -7870 1845 -7835 1770 -7960 {fill=0}
P 10 7 880 -9380 872.5 -9387.5 877.5 -9392.5 862.5 -9397.5 867.5 -9382.5 872.5 -9387.5 880 -9380 {fill=1}
P 10 7 2110 -9430 2102.5 -9437.5 2107.5 -9442.5 2092.5 -9447.5 2097.5 -9432.5 2102.5 -9437.5 2110 -9430 {fill=1}
P 10 7 1330 -9420 1322.5 -9427.5 1327.5 -9432.5 1312.5 -9437.5 1317.5 -9422.5 1322.5 -9427.5 1330 -9420 {fill=1}
P 10 7 760 -9160 752.5 -9167.5 757.5 -9172.5 742.5 -9177.5 747.5 -9162.5 752.5 -9167.5 760 -9160 {fill=1}
P 10 7 1380 -9160 1372.5 -9167.5 1377.5 -9172.5 1362.5 -9177.5 1367.5 -9162.5 1372.5 -9167.5 1380 -9160 {fill=1}
P 10 7 760 -5570 752.5 -5577.5 757.5 -5582.5 742.5 -5587.5 747.5 -5572.5 752.5 -5577.5 760 -5570 {fill=1}
P 10 7 1380 -5570 1372.5 -5577.5 1377.5 -5582.5 1362.5 -5587.5 1367.5 -5572.5 1372.5 -5577.5 1380 -5570 {fill=1}
P 10 7 760 -5170 752.5 -5177.5 757.5 -5182.5 742.5 -5187.5 747.5 -5172.5 752.5 -5177.5 760 -5170 {fill=1}
P 10 7 1380 -5170 1372.5 -5177.5 1377.5 -5182.5 1362.5 -5187.5 1367.5 -5172.5 1372.5 -5177.5 1380 -5170 {fill=1}
P 10 7 920 -4500 912.5 -4507.5 917.5 -4512.5 902.5 -4517.5 907.5 -4502.5 912.5 -4507.5 920 -4500 {fill=1}
P 10 7 1410 -4560 1402.5 -4567.5 1407.5 -4572.5 1392.5 -4577.5 1397.5 -4562.5 1402.5 -4567.5 1410 -4560 {fill=1}
P 10 7 2230 -4560 2222.5 -4567.5 2227.5 -4572.5 2212.5 -4577.5 2217.5 -4562.5 2222.5 -4567.5 2230 -4560 {fill=1}
P 10 7 880 -8550 872.5 -8557.5 877.5 -8562.5 862.5 -8567.5 867.5 -8552.5 872.5 -8557.5 880 -8550 {fill=1}
P 10 7 2110 -8600 2102.5 -8607.5 2107.5 -8612.5 2092.5 -8617.5 2097.5 -8602.5 2102.5 -8607.5 2110 -8600 {fill=1}
P 10 7 1330 -8590 1322.5 -8597.5 1327.5 -8602.5 1312.5 -8607.5 1317.5 -8592.5 1322.5 -8597.5 1330 -8590 {fill=1}
P 10 7 825 -9850 817.5 -9857.5 822.5 -9862.5 807.5 -9867.5 812.5 -9852.5 817.5 -9857.5 825 -9850 {fill=1}
P 10 7 1630 -9880 1622.5 -9887.5 1627.5 -9892.5 1612.5 -9897.5 1617.5 -9882.5 1622.5 -9887.5 1630 -9880 {fill=1}
P 10 7 2410 -9870 2402.5 -9877.5 2407.5 -9882.5 2392.5 -9887.5 2397.5 -9872.5 2402.5 -9877.5 2410 -9870 {fill=1}
P 10 7 730 -8010 722.5 -8017.5 727.5 -8022.5 712.5 -8027.5 717.5 -8012.5 722.5 -8017.5 730 -8010 {fill=1}
P 10 7 1310 -8010 1302.5 -8017.5 1307.5 -8022.5 1292.5 -8027.5 1297.5 -8012.5 1302.5 -8017.5 1310 -8010 {fill=1}
P 10 7 2520 -8080 2512.5 -8087.5 2517.5 -8092.5 2502.5 -8097.5 2507.5 -8082.5 2512.5 -8087.5 2520 -8080 {fill=1}
P 10 7 1380 -3770 1372.5 -3777.5 1377.5 -3782.5 1362.5 -3787.5 1367.5 -3772.5 1372.5 -3777.5 1380 -3770 {fill=1}
P 10 7 1920 -3810 1912.5 -3817.5 1917.5 -3822.5 1902.5 -3827.5 1907.5 -3812.5 1912.5 -3817.5 1920 -3810 {fill=1}
P 10 7 660 -2670 652.5 -2677.5 657.5 -2682.5 642.5 -2687.5 647.5 -2672.5 652.5 -2677.5 660 -2670 {fill=1}
P 10 7 1240 -2670 1232.5 -2677.5 1237.5 -2682.5 1222.5 -2687.5 1227.5 -2672.5 1232.5 -2677.5 1240 -2670 {fill=1}
P 10 7 1010 -10160 1002.5 -10167.5 1007.5 -10172.5 992.5 -10177.5 997.5 -10162.5 1002.5 -10167.5 1010 -10160 {fill=1}
P 10 7 680 -2430 672.5 -2437.5 677.5 -2442.5 662.5 -2447.5 667.5 -2432.5 672.5 -2437.5 680 -2430 {fill=1}
P 10 7 1300 -2340 1292.5 -2347.5 1297.5 -2352.5 1282.5 -2357.5 1287.5 -2342.5 1292.5 -2347.5 1300 -2340 {fill=1}
P 10 7 760 -2160 752.5 -2167.5 757.5 -2172.5 742.5 -2177.5 747.5 -2162.5 752.5 -2167.5 760 -2160 {fill=1}
P 10 7 1300 -2130 1292.5 -2137.5 1297.5 -2142.5 1282.5 -2147.5 1287.5 -2132.5 1292.5 -2137.5 1300 -2130 {fill=1}
P 10 7 2350 -2100 2342.5 -2107.5 2347.5 -2112.5 2332.5 -2117.5 2337.5 -2102.5 2342.5 -2107.5 2350 -2100 {fill=1}
P 10 7 1830 -1380 1822.5 -1387.5 1827.5 -1392.5 1812.5 -1397.5 1817.5 -1382.5 1822.5 -1387.5 1830 -1380 {fill=1}
P 10 7 700 -1450 692.5 -1457.5 697.5 -1462.5 682.5 -1467.5 687.5 -1452.5 692.5 -1457.5 700 -1450 {fill=1}
P 10 7 820 -1450 812.5 -1457.5 817.5 -1462.5 802.5 -1467.5 807.5 -1452.5 812.5 -1457.5 820 -1450 {fill=1}
P 10 7 930 -170 922.5 -177.5 927.5 -182.5 912.5 -187.5 917.5 -172.5 922.5 -177.5 930 -170 {fill=1}
P 10 7 1530 -170 1522.5 -177.5 1527.5 -182.5 1512.5 -187.5 1517.5 -172.5 1522.5 -177.5 1530 -170 {fill=1}
P 10 7 760 -1730 752.5 -1737.5 757.5 -1742.5 742.5 -1747.5 747.5 -1732.5 752.5 -1737.5 760 -1730 {fill=1}
P 10 7 1220 -1780 1212.5 -1787.5 1217.5 -1792.5 1202.5 -1797.5 1207.5 -1782.5 1212.5 -1787.5 1220 -1780 {fill=1}
P 10 7 840 -3420 832.5 -3427.5 837.5 -3432.5 822.5 -3437.5 827.5 -3422.5 832.5 -3427.5 840 -3420 {fill=1}
P 10 7 1380 -3420 1372.5 -3427.5 1377.5 -3432.5 1362.5 -3437.5 1367.5 -3422.5 1372.5 -3427.5 1380 -3420 {fill=1}
P 10 7 1920 -3500 1912.5 -3507.5 1917.5 -3512.5 1902.5 -3517.5 1907.5 -3502.5 1912.5 -3507.5 1920 -3500 {fill=1}
P 10 7 2460 -3420 2452.5 -3427.5 2457.5 -3432.5 2442.5 -3437.5 2447.5 -3422.5 2452.5 -3427.5 2460 -3420 {fill=1}
P 10 7 2560 -3170 2552.5 -3177.5 2557.5 -3182.5 2542.5 -3187.5 2547.5 -3172.5 2552.5 -3177.5 2560 -3170 {fill=1}
P 10 7 2030 -3070 2022.5 -3077.5 2027.5 -3082.5 2012.5 -3087.5 2017.5 -3072.5 2022.5 -3077.5 2030 -3070 {fill=1}
P 10 7 1520 -3060 1512.5 -3067.5 1517.5 -3072.5 1502.5 -3077.5 1507.5 -3062.5 1512.5 -3067.5 1520 -3060 {fill=1}
P 10 8 1770 -7960 1912.5 -7932.5 1890 -7900 1980 -7840 1960 -7810 1870 -7870 1845 -7835 1770 -7960 {fill=1}
P 10 7 2470 -1740 2462.5 -1747.5 2467.5 -1752.5 2452.5 -1757.5 2457.5 -1742.5 2462.5 -1747.5 2470 -1740 {fill=1}
P 10 7 2450 -350 2442.5 -357.5 2447.5 -362.5 2432.5 -367.5 2437.5 -352.5 2442.5 -357.5 2450 -350 {fill=1}
P 10 7 380 -7500 372.5 -7507.5 377.5 -7512.5 362.5 -7517.5 367.5 -7502.5 372.5 -7507.5 380 -7500 {fill=1}
P 10 7 860 -7570 852.5 -7577.5 857.5 -7582.5 842.5 -7587.5 847.5 -7572.5 852.5 -7577.5 860 -7570 {fill=1}
P 10 7 1110 -7610 1102.5 -7617.5 1107.5 -7622.5 1092.5 -7627.5 1097.5 -7612.5 1102.5 -7617.5 1110 -7610 {fill=1}
P 10 7 1400 -7610 1392.5 -7617.5 1397.5 -7622.5 1382.5 -7627.5 1387.5 -7612.5 1392.5 -7617.5 1400 -7610 {fill=1}
P 10 7 1900 -7610 1892.5 -7617.5 1897.5 -7622.5 1882.5 -7627.5 1887.5 -7612.5 1892.5 -7617.5 1900 -7610 {fill=1}
P 10 7 890 -4100 882.5 -4107.5 887.5 -4112.5 872.5 -4117.5 877.5 -4102.5 882.5 -4107.5 890 -4100 {fill=1}
P 10 7 1730 -4150 1722.5 -4157.5 1727.5 -4162.5 1712.5 -4167.5 1717.5 -4152.5 1722.5 -4157.5 1730 -4150 {fill=1}
P 10 7 2490 -4150 2482.5 -4157.5 2487.5 -4162.5 2472.5 -4167.5 2477.5 -4152.5 2482.5 -4157.5 2490 -4150 {fill=1}
P 10 7 875 -8420 867.5 -8427.5 872.5 -8432.5 857.5 -8437.5 862.5 -8422.5 867.5 -8427.5 875 -8420 {fill=1}
P 10 7 1400 -8310 1392.5 -8317.5 1397.5 -8322.5 1382.5 -8327.5 1387.5 -8312.5 1392.5 -8317.5 1400 -8310 {fill=1}
P 10 7 1850 -8310 1842.5 -8317.5 1847.5 -8322.5 1832.5 -8327.5 1837.5 -8312.5 1842.5 -8317.5 1850 -8310 {fill=1}
P 10 7 2280 -8310 2272.5 -8317.5 2277.5 -8322.5 2262.5 -8327.5 2267.5 -8312.5 2272.5 -8317.5 2280 -8310 {fill=1}
P 10 7 2200 -7440 2192.5 -7447.5 2197.5 -7452.5 2182.5 -7457.5 2187.5 -7442.5 2192.5 -7447.5 2200 -7440 {fill=1}
P 10 7 1025 -6870 1017.5 -6877.5 1022.5 -6882.5 1007.5 -6887.5 1012.5 -6872.5 1017.5 -6877.5 1025 -6870 {fill=1}
P 10 7 1870 -6870 1862.5 -6877.5 1867.5 -6882.5 1852.5 -6887.5 1857.5 -6872.5 1862.5 -6877.5 1870 -6870 {fill=1}
P 10 7 1000 -6440 992.5 -6447.5 997.5 -6452.5 982.5 -6457.5 987.5 -6442.5 992.5 -6447.5 1000 -6440 {fill=1}
P 10 7 1860 -6440 1852.5 -6447.5 1857.5 -6452.5 1842.5 -6457.5 1847.5 -6442.5 1852.5 -6447.5 1860 -6440 {fill=1}
P 10 7 2440 -7500 2432.5 -7507.5 2437.5 -7512.5 2422.5 -7517.5 2427.5 -7502.5 2432.5 -7507.5 2440 -7500 {fill=1}
P 10 7 580 -7610 572.5 -7617.5 577.5 -7622.5 562.5 -7627.5 567.5 -7612.5 572.5 -7617.5 580 -7610 {fill=1}
T {INTUITIVE_INTERFACE CHEAT SHEET} 1110 -10600 0 0 2 2 {hcenter=1}
T {D} 1275 -9577.5 0 0 0.15 0.15 { layer=2}
T {D} 2055 -9587.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -9577.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -9117.5 0 0 0.15 0.15 {}
T {D} 1285 -9117.5 0 0 0.15 0.15 {}
T {D} 745 -5527.5 0 0 0.15 0.15 {}
T {D} 1285 -5527.5 0 0 0.15 0.15 {}
T {D} 745 -5127.5 0 0 0.15 0.15 {}
T {D} 1285 -5127.5 0 0 0.15 0.15 {}
T {D} 745 -4687.5 0 0 0.15 0.15 { layer=2}
T {D} 2125 -4687.5 0 0 0.15 0.15 { layer=2}
T {D} 1305 -4687.5 0 0 0.15 0.15 { layer=2}
T {(Enable Options-> Intuitive Click & Drag interface
or add: `set intuitive_interface 1` in xschemrc file).} 1090 -10460 0 0 1 1 {hcenter=1 layer=1}
T {Move objects} 0 -9650 0 0 1 1 {}
T {Move objects} 0 -9240 0 0 1 1 {}
T {Move objects,
create wires} 0 -5650 0 0 1 1 {}
T {Move objects,
keep attached
wires
} 0 -5250 0 0 1 1 {}
T {Move objects,
keep attached
wires / stretch
circuit
} 0 -4850 0 0 1 1 {}
T {Shift} 1520 -5585 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1520 -5655 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1540 -4545 0 0 0.5 0.5 {hcenter=1}
T {Duplicate objects} 0 -8800 0 0 1 1 {}
T {D} 1275 -8747.5 0 0 0.15 0.15 { layer=2}
T {D} 2055 -8757.5 0 0 0.15 0.15 { layer=2}
T {D} 745 -8747.5 0 0 0.15 0.15 { layer=2}
T {D} 1775 -8747.5 0 0 0.15 0.15 {}
T {Shift} 1270 -8565 0 0 0.5 0.5 {hcenter=1}
T {D} 1815 -10047.5 0 0 0.15 0.15 { layer=2}
T {D} 690 -10047.5 0 0 0.15 0.15 { layer=2}
T {Select
and unselect
objects} 0 -10100 0 0 1 1 {}
T {Shift} 1710 -9845 0 0 0.5 0.5 {hcenter=1}
T {D} 2275 -10047.5 0 0 0.15 0.15 { layer=2}
T {Alt} 2490 -9835 0 0 0.5 0.5 {hcenter=1}
T {Select} 695 -9850 0 0 0.5 0.5 {}
T {Add
Selection} 1770 -9860 0 0 0.5 0.5 {}
T {Remove
Selection} 2220 -9860 0 0 0.5 0.5 {}
T {D} 765 -7907.5 0 0 0.15 0.15 {}
T {D} 1305 -7907.5 0 0 0.15 0.15 {}
T {D} 2435 -7907.5 0 0 0.15 0.15 {}
T {Resize wires} 0 -8030 0 0 1 1 {}
T {Constrained move
horizontal / 
vertical} 0 -4380 0 0 1 1 {}
T {Move components, 
create wires,
resize wires} 0 -3920 0 0 1 1 {}
T {Cut wires} 0 -3570 0 0 1 1 {}
T {Stretch multiple
shapes} 0 -3150 0 0 1 1 {}
T {Ctrl} 1430 -3925 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1430 -3845 0 0 0.5 0.5 {hcenter=1}
T {Accurately position closer
to the wire end to be moved
so it will not be unselected} 1610 -8120 0 0 0.5 0.5 {}
T {Move multiple
objects keeping
connections} 0 -1130 0 0 1 1 {}
T {Ctrl} 2080 -1105 0 0 0.5 0.5 {hcenter=1}
T {Alt} 1430 -3475 0 0 0.5 0.5 {hcenter=1}
T {Click to select wire, release button
click wire endpoint and drag it away} 660 -8120 0 0 0.5 0.5 {}
T {Ctrl} 1580 -3065 0 0 0.5 0.5 {hcenter=1}
T {D} 655 -2727.5 0 0 0.15 0.15 { layer=2}
T {D} 1235 -2727.5 0 0 0.15 0.15 { layer=2}
T {D} 1885 -2727.5 0 0 0.15 0.15 {}
T {Ctrl} 1960 -2765 0 0 0.5 0.5 {hcenter=1}
T {!} 1960 -2685 0 0 0.5 0.5 {hcenter=1}
T {Remove wires
under component
} 0 -2800 0 0 1 1 {}
T {If Shift key is needed for ! 
use also Shift} 2020 -2740 0 0 0.5 0.5 {}
T {D} 1275 -10047.5 0 0 0.15 0.15 { layer=2}
T {Add
Selection} 1090 -9870 0 0 0.5 0.5 {}
T {Shift} 1080 -10125 0 0 0.5 0.5 {hcenter=1}
T {Move multiple
objects keeping
connections,
adding wires} 0 -750 0 0 1 1 {}
T {Ctrl} 2080 -725 0 0 0.5 0.5 {hcenter=1}
T {Shift} 2080 -655 0 0 0.5 0.5 {hcenter=1}
T {Join / Trim wires} 0 -2460 0 0 1 1 {}
T {&} 1920 -2465 0 0 0.5 0.5 {hcenter=1}
T {This wire will not be broken} 1120 -2050 0 0 0.5 0.5 {}
T {&} 1830 -2035 0 0 0.5 0.5 {hcenter=1}
T {This wire is now 
broken} 1890 -2050 0 0 0.5 0.5 {}
T {break wires
at instance
pins} 0 -1530 0 0 1 1 {}
T {!} 1290 -1385 0 0 0.5 0.5 {hcenter=1}
T {Shift} 790 -1315 0 0 0.5 0.5 {hcenter=1}
T {+} 720 -1390 0 0 0.5 0.5 {}
T {The single wire line will be
broken at selected instance pins} 1640 -1560 0 0 0.5 0.5 {}
T {Single wire line} 640 -1550 0 0 0.5 0.5 {}
T {D} 825 -217.5 0 0 0.15 0.15 {}
T {D} 1425 -217.5 0 0 0.15 0.15 {}
T {Shift} 1600 -155 0 0 0.5 0.5 {hcenter=1}
T {Select instance
and all connected
wires} 0 -350 0 0 1 1 {}
T {Join / Trim wires} 0 -2180 0 0 1 1 {}
T {Options->Auto join / trim wires to perform this function automatically} 840 -2280 0 0 0.5 0.5 {}
T {Join / Trim wires} 0 -1790 0 0 1 1 {}
T {This wire is broken} 630 -1650 0 0 0.5 0.5 {}
T {This wire is still broken} 1170 -1650 0 0 0.5 0.5 {}
T {This wire is now joined} 1800 -1650 0 0 0.5 0.5 {}
T {&} 1920 -1895 0 0 0.5 0.5 {hcenter=1}
T {Options->Auto join / trim wires to perform this function automatically} 840 -1910 0 0 0.5 0.5 {}
T {Options->Auto join / trim wires to perform this function automatically} 840 -2520 0 0 0.5 0.5 {}
T {multiple overlayed wires create
unneeded connecting dots} 1110 -2440 0 0 0.5 0.5 {}
T {overlayed wires are removed} 2270 -2420 0 0 0.5 0.5 {}
T {Ctrl} 2370 -4545 0 0 0.5 0.5 {hcenter=1}
T {Ctrl} 1980 -3925 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1980 -3845 0 0 0.5 0.5 {hcenter=1}
T {you can now 
select one of
the cut segments...} 1930 -3440 0 0 0.4 0.4 {}
T {... and move it.} 2420 -3360 0 0 0.4 0.4 {}
T {D} 2035 -217.5 0 0 0.15 0.15 {}
T {Component
wiring} 0 -7550 0 0 1 1 {}
T {Click to
unselect} 850 -7670 0 0 0.5 0.5 {}
T {Click to select} 1810 -7670 0 0 0.5 0.5 {}
T {Click one of the
selected objects
and drag it away.} 2330 -250 0 0 0.4 0.4 {}
T {This command will work also on multiple selected objects.} 1710 -2590 0 0 0.5 0.5 {}
T {D} 765 -4277.5 0 0 0.15 0.15 {}
T {D} 1325 -4277.5 0 0 0.15 0.15 {}
T {Press and release 'h'
while keeping left mouse
button pressed.
move will be horizontal only} 1550 -4430 0 0 0.5 0.5 {}
T {Press and release 'v'
while keeping left mouse
button pressed.
move will be vertical only} 2050 -4300 0 0 0.5 0.5 {}
T {D} 710 -8327.5 0 0 0.15 0.15 {}
T {Move and
extend
wires} 0 -8420 0 0 1 1 {}
T {D} 1275 -8327.5 0 0 0.15 0.15 {}
T {D} 1775 -8327.5 0 0 0.15 0.15 {}
T {D} 2265 -8327.5 0 0 0.15 0.15 {}
T {Shift} 1980 -7585 0 0 0.5 0.5 {hcenter=1}
T {Rotate / Flip} 0 -7210 0 0 1 1 {}
T {Shift} 510 -7095 0 0 0.5 0.5 {hcenter=1}
T {R} 510 -7025 0 0 0.5 0.5 {hcenter=1}
T {Shift} 820 -7095 0 0 0.5 0.5 {hcenter=1}
T {R} 820 -7025 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1120 -7095 0 0 0.5 0.5 {hcenter=1}
T {R} 1120 -7025 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1430 -7095 0 0 0.5 0.5 {hcenter=1}
T {R} 1430 -7025 0 0 0.5 0.5 {hcenter=1}
T {Shift} 1750 -7095 0 0 0.5 0.5 {hcenter=1}
T {F} 1750 -7025 0 0 0.5 0.5 {hcenter=1}
T {Shift} 2080 -7095 0 0 0.5 0.5 {hcenter=1}
T {V} 2080 -7025 0 0 0.5 0.5 {hcenter=1}
T {D} 775 -6767.5 0 0 0.15 0.15 { layer=2}
T {D} 1727.5 -6645 1 0 0.15 0.15 { layer=2}
T {D} 1250 -6767.5 0 0 0.15 0.15 { layer=2}
T {Shift} 1940 -6905 0 0 0.5 0.5 {hcenter=1}
T {R} 1940 -6835 0 0 0.5 0.5 {hcenter=1}
T {Selected shapes rotate around mouse pointer} 1920 -6760 0 0 0.5 0.5 {}
T {Rotate} 0 -6790 0 0 1 1 {}
T {D} 775 -6337.5 0 0 0.15 0.15 { layer=2}
T {D} 1225 -6337.5 0 0 0.15 0.15 { layer=2}
T {Shift} 1940 -6475 0 0 0.5 0.5 {hcenter=1}
T {F} 1940 -6405 0 0 0.5 0.5 {hcenter=1}
T {Selected shapes flip around mouse pointer} 1920 -6330 0 0 0.5 0.5 {}
T {Flip} 0 -6360 0 0 1 1 {}
T {D} 1595 -6337.5 0 1 0.15 0.15 { layer=2}
T {Rotate around
center point} 0 -5960 0 0 1 1 {}
T {Alt} 1050 -5995 0 0 0.5 0.5 {hcenter=1}
T {R} 1050 -5925 0 0 0.5 0.5 {hcenter=1}
T {Same commands are available for
vertical flip (Alt-v) and
horizontal flip (Alt-f)} 1350 -5970 0 0 0.5 0.5 {}
T {get existing wire} 750 -8485 0 0 0.5 0.5 {}
T {move} 1335 -8375 0 0 0.5 0.5 {}
T {extend} 2310 -8380 0 0 0.5 0.5 {}
T {duplicated} 2070 -7390 0 0 0.5 0.5 {}
T {Ctrl} 1520 -5225 0 0 0.5 0.5 {hcenter=1}
