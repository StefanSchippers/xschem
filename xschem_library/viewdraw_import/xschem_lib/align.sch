v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
T {TEXT1} 800 -590 0 0 0.333333 0.333333 { hcenter=true }
T {TEXT3} 1040 -590 0 1 0.333333 0.333333 {  }
T {TEXT4} 800 -670 0 0 0.333333 0.333333 { hcenter=true }
T {TEXT5} 570 -670 0 0 0.333333 0.333333 { vcenter=true }
T {TEXT6} 1040 -670 0 1 0.333333 0.333333 { vcenter=true }
T {TEXT7} 800 -750 0 0 0.333333 0.333333 { hcenter=true }
T {TEXT2} 570 -590 0 0 0.333333 0.333333 {  }
T {TEXT9} 1040 -750 0 1 0.333333 0.333333 {  }
T {TEXT8} 570 -750 0 0 0.333333 0.333333 {  }
C {xschem_lib/sheet_b.sym} 0 0 0 0 {}
