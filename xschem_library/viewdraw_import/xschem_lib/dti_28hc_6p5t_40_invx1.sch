** sch_path: xschem_library/viewdraw_import/xschem_lib/dti_28hc_6p5t_40_invx1.sch
**.subckt dti_28hc_6p5t_40_invx1
**.ends
.end
