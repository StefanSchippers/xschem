** sch_path: xschem_library/viewdraw_import/xschem_lib/dti_gen_inv.sch
**.subckt dti_gen_inv
**.ends
.end
