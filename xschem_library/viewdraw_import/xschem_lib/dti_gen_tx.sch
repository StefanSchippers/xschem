** sch_path: xschem_library/viewdraw_import/xschem_lib/dti_gen_tx.sch
**.subckt dti_gen_tx
**.ends
.end
