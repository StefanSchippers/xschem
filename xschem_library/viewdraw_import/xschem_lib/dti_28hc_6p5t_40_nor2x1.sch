** sch_path: xschem_library/viewdraw_import/xschem_lib/dti_28hc_6p5t_40_nor2x1.sch
**.subckt dti_28hc_6p5t_40_nor2x1
**.ends
.end
