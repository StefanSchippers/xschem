** sch_path: xschem_library/examples/test_parametric_ports/inv.sch
**.subckt inv IN[expr(@width - 1):0] OUT[expr(@width - 1):0]
*.ipin IN[@width - 1:0]
*.opin OUT[@width - 1:0]
M1[@width - 1:0] OUT[@width - 1:0] IN[@width - 1:0] GND GND nmos w=5u l=0.18u m=1
M2[@width -1:0] OUT[@width - 1:0] IN[@width - 1:0] VDD VDD pmos w=5u l=0.18u m=1
**.ends
.GLOBAL VDD
.GLOBAL GND
.end
