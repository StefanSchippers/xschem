** sch_path: xschem_library/examples/test_parametric_ports/buffer.sch
**.subckt buffer IN OUT
*.ipin IN
*.opin OUT
M1 X1 IN 0 0 cmosn w=@Wn_1x l=@nl m=1
M2 X1 IN VCC VCC cmosp w=round(@mos_ratio * (@Wn_1x / @nl ) * @pl / 0.005) * 0.005 l=@pl m=1
M3 OUT X3 0 0 cmosn w=round(@Wn_1x * @stage_ratio ^3 / 0.005) * 0.005 l=@nl m=1
M4 OUT X3 VCC VCC cmosp w=round(@mos_ratio * @stage_ratio ^3 * (@Wn_1x / @nl ) * @pl / 0.005) *
+ 0.005 l=@pl m=1
M5 X3 X2 0 0 cmosn w=round(@Wn_1x * @stage_ratio ^2 / 0.005) * 0.005 l=@nl m=1
M6 X3 X2 VCC VCC cmosp w=round(@mos_ratio * @stage_ratio ^2 * (@Wn_1x / @nl ) * @pl / 0.005) * 0.005
+ l=@pl m=1
M7 X2 X1 0 0 cmosn w=round(@Wn_1x * @stage_ratio / 0.005) * 0.005 l=@nl m=1
M8 X2 X1 VCC VCC cmosp w=round(@mos_ratio * @stage_ratio * (@Wn_1x / @nl ) * @pl / 0.005) * 0.005
+ l=@pl m=1
**.ends
.GLOBAL VCC
.end
