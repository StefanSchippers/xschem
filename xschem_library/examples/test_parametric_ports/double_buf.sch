** sch_path: xschem_library/examples/test_parametric_ports/double_buf.sch
**.subckt double_buf IN[expr(@width - 1):0] OUT[expr(@width - 1):0]
*.ipin IN[@width - 1:0]
*.opin OUT[@width - 1:0]
x1 N[@width - 1:0] IN[@width - 1:0] @buf
x2 OUT[@width - 1:0] N[@width - 1:0] @buf
**.ends
.end
