v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {test_parametric_ports/test_param_model.sym} 290 -140 0 0 {name=x1 vccpin=vccb vsspin=vssb}
C {lab_pin.sym} 140 -140 0 0 {name=p1 lab=LDCP}
C {lab_pin.sym} 440 -140 0 1 {name=p2 lab=LDCP_B}
C {opin.sym} 300 -310 0 0 { name=p3 lab=LDCP_B }
C {ipin.sym} 210 -310 0 0 { name=p4 lab=LDCP }
