** sch_path: xschem_library/examples/test_parametric_ports/inv4.sch
* Copyright (C) 1998-2023 Stefan Frederik Schippers
* This program is free software; you can redistribute it and/or modify
* it under the terms of the GNU General Public License as published by
* the Free Software Foundation; either version 2 of the License, or
* (at your option) any later version.
* This program is distributed in the hope that it will be useful,
* but WITHOUT ANY WARRANTY; without even the implied warranty of
* MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
* GNU General Public License for more details.
* You should have received a copy of the GNU General Public License
* along with this program; if not, write to the Free Software
**.subckt inv4 y a
*.opin y
*.ipin a
m2 y a VCCPIN VCCPIN modp@modeltag w=wp l=lp ad='wp *4.6u' as='wp *4.6u' pd='wp *2+9.2u' ps='wp *2+9.2u'
+ m=1
m1 y a VSSPIN VSSPIN modn@modeltag w=wn l=lln ad='wn *4.3u' as='wn *4.3u' pd='wn *2+8.6u' ps='wn *2+8.6u'
+ m=1
**.ends
.end
