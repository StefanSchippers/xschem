** sch_path: xschem_library/examples/test_parametric_ports/test_param_model.sch
**.subckt test_param_model LDCP_B LDCP
*.opin LDCP_B
*.ipin LDCP
x2 LDCP_B LDCP vccpin vsspin inv3_1 wn=8.4u lln=2.4u wp=20u lp=2.4u m=1
.save v(ldcp_b)
x3 LDCP2_B LDCP vccpin vsspin inv3_2 wn=8.4u lln=2.4u wp=20u lp=2.4u m=1
.save v(ldcp2_b)
x1 LDCP3_B LDCP vccpin vsspin inv3 wn=8.4u lln=2.4u wp=20u lp=2.4u m=1
.save v(ldcp3_b)
x4 LDCP4_B LDCP vccpin vsspin inv4 wn=8.4u lln=2.4u wp=20u lp=2.4u m=1
.save v(ldcp4_b)
x5 LDCP5_B LDCP vccpin vsspin inv4_1 wn=8.4u lln=2.4u wp=20u lp=2.4u m=1
x6 LDCP2_B LDCP vccpin vsspin inv3_2 wn=7.4u lln=1.4u wp=10u lp=1.4u m=1
.save v(ldcp2_b)
**.ends
.end
