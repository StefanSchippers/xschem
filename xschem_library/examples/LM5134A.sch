v {xschem version=2.9.5_RC5 file_version=1.1}
G {}
V {}
S {}
E {}
C {ipin.sym} -500 20 0 0 {name=p0 lab=VDD}
C {ipin.sym} -500 40 0 0 {name=p1 lab=PILOT}
C {ipin.sym} -500 60 0 0 {name=p2 lab=OUT}
C {opin.sym} -200 20 0 0 {name=p3 lab=IN}
C {opin.sym} -200 40 0 0 {name=p4 lab=INB}
C {opin.sym} -200 60 0 0 {name=p5 lab=VSS}
