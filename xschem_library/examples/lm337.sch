v {xschem version=2.9.5_RC5 file_version=1.1}
G {}
V {}
S {}
E {}
C {ipin.sym} -500 20 0 0 {name=p0 lab=IN}
C {ipin.sym} -500 40 0 0 {name=p1 lab=ADJ}
C {opin.sym} -200 20 0 0 {name=p2 lab=OUT}
