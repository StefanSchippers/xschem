v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {iopin.sym} 10 -80 0 0 {name=p1 lab=A}
C {iopin.sym} 10 -20 0 0 {name=p1 lab=B}
