v {xschem version=3.4.5 file_version=1.2}
G {}
V {}
E {}
S {}
C {ipin.sym} -120 0 0 0 {name=g0 lab=A }
C {ipin.sym} -120 20 0 0 {name=g1 lab=B }
C {ipin.sym} -120 40 0 0 {name=g2 lab=C }
C {ipin.sym} -120 60 0 0 {name=g3 lab=VCC }
C {ipin.sym} -120 80 0 0 {name=g4 lab=VSS }
C {opin.sym} 120 0 0 0 {name=g5 lab=Z }
