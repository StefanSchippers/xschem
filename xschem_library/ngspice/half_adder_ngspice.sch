v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {ipin.sym} 110 -220 0 0 {name=p1 lab=A}
C {ipin.sym} 110 -190 0 0 {name=p2 lab=B}
C {opin.sym} 210 -220 0 0 {name=p4 lab=S}
C {opin.sym} 210 -190 0 0 {name=p5 lab=COUT}
C {title.sym} 160 -30 0 0 {name=l2}
C {lab_pin.sym} 470 -270 0 0 {name=l6 lab=A}
C {lab_pin.sym} 470 -230 0 0 {name=l7 lab=B}
C {lab_pin.sym} 570 -160 0 1 {name=p7 lab=COUT}
C {lab_pin.sym} 470 -180 0 0 {name=p3 lab=A}
C {lab_pin.sym} 470 -140 0 0 {name=p6 lab=B}
C {lab_pin.sym} 570 -250 0 1 {name=l3 lab=S}
C {xor_ngspice.sym} 510 -250 0 0 {name=x1 ROUT=1000}
C {and_ngspice.sym} 510 -160 0 0 {name=x2 ROUT=1000}
