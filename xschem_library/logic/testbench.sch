** sch_path: xschem_library/logic/testbench.sch
* xschem_library/logic/bf.sch:
* Copyright (C) 1998-2026 Stefan Frederik Schippers
* This program is free software; you can redistribute it and/or modify
* it under the terms of the GNU General Public License as published by
* the Free Software Foundation; either version 2 of the License, or
* (at your option) any later version.
* xschem_library/logic/bf.sym:
* Copyright (C) 1998-2023 Stefan Frederik Schippers
**.subckt testbench
x1 [ A B ] Y_NOR nor
x2 [ A B ] Y_NAND nand
x3 [ A ] Y_INV inv
x4 Y_XOR A B eo
x5 Y_BUF A bf
x6 #~#?1 A A Y_FF B Y_NOR ff
x7 A Y_LATCH B Y_NOR YN_LATCH latch
xcoderam ADD[4] ADD[3] ADD[2] ADD[1] ADD[0] M[7] M[6] M[5] M[4] M[3] M[2] M[1] M[0] DOUT[7] DOUT[6]
+ DOUT[5] DOUT[4] DOUT[3] DOUT[2] DOUT[1] DOUT[0] DIN[7] DIN[6] DIN[5] DIN[4] DIN[3] DIN[2] DIN[1] DIN[0] WEN
+ CEN OEN CK ram
x8 DATA_OUT[7] DATA_OUT[6] DATA_OUT[5] DATA_OUT[4] DATA_OUT[3] DATA_OUT[2] DATA_OUT[1] DATA_OUT[0]
+ CK BN DIN[7] DIN[6] DIN[5] DIN[4] DIN[3] DIN[2] DIN[1] DIN[0] A sync_reg
x9 [ B ] BN inv
v1 [ A_A ] [ A ] adc_buff
v2 [ B_A ] [ B ] adc_buff
v3 [ DIN_A[7] ] [ DIN[7] ] adc_buff
v4 [ M_A[7] ] [ M[7] ] adc_buff
v5 [ ADD_A[4] ] [ ADD[4] ] adc_buff
v6 [ CEN_A ] [ CEN ] adc_buff
v7 [ WEN_A ] [ WEN ] adc_buff
v8 [ OEN_A ] [ OEN ] adc_buff
v9 [ CK_A ] [ CK ] adc_buff
**.ends

* expanding   symbol:  eo.sym # of pins=3
** sym_path: xschem_library/logic/eo.sym
** sch_path: xschem_library/logic/eo.sch
.subckt eo Y A B  delay=220 ps del=220
*.ipin A
*.ipin B
*.opin Y
* noconn Y
* noconn B
* noconn A
.ends


* expanding   symbol:  bf.sym # of pins=2
** sym_path: xschem_library/logic/bf.sym
** sch_path: xschem_library/logic/bf.sch
.subckt bf Y A  delay=90 ps del=90
*.opin Y
*.ipin A
* noconn Y
* noconn A
.ends


* expanding   symbol:  ff.sym # of pins=4
** sym_path: xschem_library/logic/ff.sym
** sch_path: xschem_library/logic/ff.sch
.subckt ff D D Q CK RST  delay=400 ps del=400
*.ipin D
*.opin Q
*.ipin CK
*.ipin RST
* noconn Q
* noconn D
* noconn CK
* noconn RST
.ends


* expanding   symbol:  latch.sym # of pins=5
** sym_path: xschem_library/logic/latch.sym
** sch_path: xschem_library/logic/latch.sch
.subckt latch D Q G RST QN  delay=200 ps del=200
*.opin Q
*.ipin G
*.ipin RST
*.opin QN
*.ipin D
.ends


* expanding   symbol:  ram.sym # of pins=8
** sym_path: xschem_library/logic/ram.sym
** sch_path: xschem_library/logic/ram.sch
.subckt ram ADD[dim-1:0] M[width-1:0] DOUT[width-1:0] DIN[width-1:0] WEN CEN OEN CK  dim=5 width=8
+ hex=0
datafile=ram.list modulename=ram access_delay=3000 oe_delay=300
*.opin DOUT[width-1:0]
*.ipin DIN[width-1:0]
*.ipin CK
*.ipin OEN
*.ipin ADD[dim-1:0]
*.ipin WEN
*.ipin CEN
*.ipin M[width-1:0]
* noconn DOUT[width-1:0]
.ends


* expanding   symbol:  sync_reg.sym # of pins=5
** sym_path: xschem_library/logic/sync_reg.sym
** sch_path: xschem_library/logic/sync_reg.sch
.subckt sync_reg DATA_OUT[width-1:0] CK RESET DATA_IN[width-1:0] LOAD  width=8 del=400 delay=400 ps
*.opin DATA_OUT[width-1:0]
*.ipin CK
*.ipin RESET
*.ipin DATA_IN[width-1:0]
*.ipin LOAD
* noconn DATA_OUT[width-1:0]
.ends

.end
