** sch_path: xschem_library/rom8k/rom8k.sch
* Copyright (C) 1998-2023 Stefan Frederik Schippers
* This program is free software; you can redistribute it and/or modify
* it under the terms of the GNU General Public License as published by
* the Free Software Foundation; either version 2 of the License, or
* (at your option) any later version.
* This program is distributed in the hope that it will be useful,
* but WITHOUT ANY WARRANTY; without even the implied warranty of
* MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
* GNU General Public License for more details.
* You should have received a copy of the GNU General Public License
* along with this program; if not, write to the Free Software



**.subckt rom8k
*+ LDQ[15],LDQ[14],LDQ[13],LDQ[12],LDQ[11],LDQ[10],LDQ[9],LDQ[8],LDQ[7],LDQ[6],LDQ[5],LDQ[4],LDQ[3],LDQ[2],LDQ[1],LDQ[0] LDA[12],LDA[11],LDA[10],LDA[9],LDA[8],LDA[7],LDA[6],LDA[5],LDA[4],LDA[3],LDA[2],LDA[1],LDA[0] LDCP
*+ LDEN LDOE vss vcc
*.opin
*+ LDQ[15],LDQ[14],LDQ[13],LDQ[12],LDQ[11],LDQ[10],LDQ[9],LDQ[8],LDQ[7],LDQ[6],LDQ[5],LDQ[4],LDQ[3],LDQ[2],LDQ[1],LDQ[0]
*.ipin LDA[12],LDA[11],LDA[10],LDA[9],LDA[8],LDA[7],LDA[6],LDA[5],LDA[4],LDA[3],LDA[2],LDA[1],LDA[0]
*.ipin LDCP
*.ipin LDEN
*.ipin LDOE
*.ipin vss
*.ipin vcc
xcdec[15] LDYMS[15] LDY1[15] LDY1[14] LDY1[13] LDY1[12] LDY1[11] LDY1[10] LDY1[9] LDY1[8] LDY1[7]
+ LDY1[6] LDY1[5] LDY1[4] LDY1[3] LDY1[2] LDY1[1] LDY1[0] LDBL[255] LDBL[254] LDBL[253] LDBL[252] LDBL[251]
+ LDBL[250] LDBL[249] LDBL[248] LDBL[247] LDBL[246] LDBL[245] LDBL[244] LDBL[243] LDBL[242] LDBL[241] LDBL[240]
+ vss rom2_coldec
xcdec[14] LDYMS[14] LDY1[15] LDY1[14] LDY1[13] LDY1[12] LDY1[11] LDY1[10] LDY1[9] LDY1[8] LDY1[7]
+ LDY1[6] LDY1[5] LDY1[4] LDY1[3] LDY1[2] LDY1[1] LDY1[0] LDBL[239] LDBL[238] LDBL[237] LDBL[236] LDBL[235]
+ LDBL[234] LDBL[233] LDBL[232] LDBL[231] LDBL[230] LDBL[229] LDBL[228] LDBL[227] LDBL[226] LDBL[225] LDBL[224]
+ vss rom2_coldec
xcdec[13] LDYMS[13] LDY1[15] LDY1[14] LDY1[13] LDY1[12] LDY1[11] LDY1[10] LDY1[9] LDY1[8] LDY1[7]
+ LDY1[6] LDY1[5] LDY1[4] LDY1[3] LDY1[2] LDY1[1] LDY1[0] LDBL[223] LDBL[222] LDBL[221] LDBL[220] LDBL[219]
+ LDBL[218] LDBL[217] LDBL[216] LDBL[215] LDBL[214] LDBL[213] LDBL[212] LDBL[211] LDBL[210] LDBL[209] LDBL[208]
+ vss rom2_coldec
xcdec[12] LDYMS[12] LDY1[15] LDY1[14] LDY1[13] LDY1[12] LDY1[11] LDY1[10] LDY1[9] LDY1[8] LDY1[7]
+ LDY1[6] LDY1[5] LDY1[4] LDY1[3] LDY1[2] LDY1[1] LDY1[0] LDBL[207] LDBL[206] LDBL[205] LDBL[204] LDBL[203]
+ LDBL[202] LDBL[201] LDBL[200] LDBL[199] LDBL[198] LDBL[197] LDBL[196] LDBL[195] LDBL[194] LDBL[193] LDBL[192]
+ vss rom2_coldec
xcdec[11] LDYMS[11] LDY1[15] LDY1[14] LDY1[13] LDY1[12] LDY1[11] LDY1[10] LDY1[9] LDY1[8] LDY1[7]
+ LDY1[6] LDY1[5] LDY1[4] LDY1[3] LDY1[2] LDY1[1] LDY1[0] LDBL[191] LDBL[190] LDBL[189] LDBL[188] LDBL[187]
+ LDBL[186] LDBL[185] LDBL[184] LDBL[183] LDBL[182] LDBL[181] LDBL[180] LDBL[179] LDBL[178] LDBL[177] LDBL[176]
+ vss rom2_coldec
xcdec[10] LDYMS[10] LDY1[15] LDY1[14] LDY1[13] LDY1[12] LDY1[11] LDY1[10] LDY1[9] LDY1[8] LDY1[7]
+ LDY1[6] LDY1[5] LDY1[4] LDY1[3] LDY1[2] LDY1[1] LDY1[0] LDBL[175] LDBL[174] LDBL[173] LDBL[172] LDBL[171]
+ LDBL[170] LDBL[169] LDBL[168] LDBL[167] LDBL[166] LDBL[165] LDBL[164] LDBL[163] LDBL[162] LDBL[161] LDBL[160]
+ vss rom2_coldec
xcdec[9] LDYMS[9] LDY1[15] LDY1[14] LDY1[13] LDY1[12] LDY1[11] LDY1[10] LDY1[9] LDY1[8] LDY1[7]
+ LDY1[6] LDY1[5] LDY1[4] LDY1[3] LDY1[2] LDY1[1] LDY1[0] LDBL[159] LDBL[158] LDBL[157] LDBL[156] LDBL[155]
+ LDBL[154] LDBL[153] LDBL[152] LDBL[151] LDBL[150] LDBL[149] LDBL[148] LDBL[147] LDBL[146] LDBL[145] LDBL[144]
+ vss rom2_coldec
xcdec[8] LDYMS[8] LDY1[15] LDY1[14] LDY1[13] LDY1[12] LDY1[11] LDY1[10] LDY1[9] LDY1[8] LDY1[7]
+ LDY1[6] LDY1[5] LDY1[4] LDY1[3] LDY1[2] LDY1[1] LDY1[0] LDBL[143] LDBL[142] LDBL[141] LDBL[140] LDBL[139]
+ LDBL[138] LDBL[137] LDBL[136] LDBL[135] LDBL[134] LDBL[133] LDBL[132] LDBL[131] LDBL[130] LDBL[129] LDBL[128]
+ vss rom2_coldec
xcdec[7] LDYMS[7] LDY1[15] LDY1[14] LDY1[13] LDY1[12] LDY1[11] LDY1[10] LDY1[9] LDY1[8] LDY1[7]
+ LDY1[6] LDY1[5] LDY1[4] LDY1[3] LDY1[2] LDY1[1] LDY1[0] LDBL[127] LDBL[126] LDBL[125] LDBL[124] LDBL[123]
+ LDBL[122] LDBL[121] LDBL[120] LDBL[119] LDBL[118] LDBL[117] LDBL[116] LDBL[115] LDBL[114] LDBL[113] LDBL[112]
+ vss rom2_coldec
xcdec[6] LDYMS[6] LDY1[15] LDY1[14] LDY1[13] LDY1[12] LDY1[11] LDY1[10] LDY1[9] LDY1[8] LDY1[7]
+ LDY1[6] LDY1[5] LDY1[4] LDY1[3] LDY1[2] LDY1[1] LDY1[0] LDBL[111] LDBL[110] LDBL[109] LDBL[108] LDBL[107]
+ LDBL[106] LDBL[105] LDBL[104] LDBL[103] LDBL[102] LDBL[101] LDBL[100] LDBL[99] LDBL[98] LDBL[97] LDBL[96] vss
+ rom2_coldec
xcdec[5] LDYMS[5] LDY1[15] LDY1[14] LDY1[13] LDY1[12] LDY1[11] LDY1[10] LDY1[9] LDY1[8] LDY1[7]
+ LDY1[6] LDY1[5] LDY1[4] LDY1[3] LDY1[2] LDY1[1] LDY1[0] LDBL[95] LDBL[94] LDBL[93] LDBL[92] LDBL[91]
+ LDBL[90] LDBL[89] LDBL[88] LDBL[87] LDBL[86] LDBL[85] LDBL[84] LDBL[83] LDBL[82] LDBL[81] LDBL[80] vss
+ rom2_coldec
xcdec[4] LDYMS[4] LDY1[15] LDY1[14] LDY1[13] LDY1[12] LDY1[11] LDY1[10] LDY1[9] LDY1[8] LDY1[7]
+ LDY1[6] LDY1[5] LDY1[4] LDY1[3] LDY1[2] LDY1[1] LDY1[0] LDBL[79] LDBL[78] LDBL[77] LDBL[76] LDBL[75]
+ LDBL[74] LDBL[73] LDBL[72] LDBL[71] LDBL[70] LDBL[69] LDBL[68] LDBL[67] LDBL[66] LDBL[65] LDBL[64] vss
+ rom2_coldec
xcdec[3] LDYMS[3] LDY1[15] LDY1[14] LDY1[13] LDY1[12] LDY1[11] LDY1[10] LDY1[9] LDY1[8] LDY1[7]
+ LDY1[6] LDY1[5] LDY1[4] LDY1[3] LDY1[2] LDY1[1] LDY1[0] LDBL[63] LDBL[62] LDBL[61] LDBL[60] LDBL[59]
+ LDBL[58] LDBL[57] LDBL[56] LDBL[55] LDBL[54] LDBL[53] LDBL[52] LDBL[51] LDBL[50] LDBL[49] LDBL[48] vss
+ rom2_coldec
xcdec[2] LDYMS[2] LDY1[15] LDY1[14] LDY1[13] LDY1[12] LDY1[11] LDY1[10] LDY1[9] LDY1[8] LDY1[7]
+ LDY1[6] LDY1[5] LDY1[4] LDY1[3] LDY1[2] LDY1[1] LDY1[0] LDBL[47] LDBL[46] LDBL[45] LDBL[44] LDBL[43]
+ LDBL[42] LDBL[41] LDBL[40] LDBL[39] LDBL[38] LDBL[37] LDBL[36] LDBL[35] LDBL[34] LDBL[33] LDBL[32] vss
+ rom2_coldec
xcdec[1] LDYMS[1] LDY1[15] LDY1[14] LDY1[13] LDY1[12] LDY1[11] LDY1[10] LDY1[9] LDY1[8] LDY1[7]
+ LDY1[6] LDY1[5] LDY1[4] LDY1[3] LDY1[2] LDY1[1] LDY1[0] LDBL[31] LDBL[30] LDBL[29] LDBL[28] LDBL[27]
+ LDBL[26] LDBL[25] LDBL[24] LDBL[23] LDBL[22] LDBL[21] LDBL[20] LDBL[19] LDBL[18] LDBL[17] LDBL[16] vss
+ rom2_coldec
xcdec[0] LDYMS[0] LDY1[15] LDY1[14] LDY1[13] LDY1[12] LDY1[11] LDY1[10] LDY1[9] LDY1[8] LDY1[7]
+ LDY1[6] LDY1[5] LDY1[4] LDY1[3] LDY1[2] LDY1[1] LDY1[0] LDBL[15] LDBL[14] LDBL[13] LDBL[12] LDBL[11]
+ LDBL[10] LDBL[9] LDBL[8] LDBL[7] LDBL[6] LDBL[5] LDBL[4] LDBL[3] LDBL[2] LDBL[1] LDBL[0] vss rom2_coldec
xsa[15] LDQ[15] LDCP_SA LDYMS[15] LDOE LDPRECH LDSAL vccsa vss rom2_sa
xsa[14] LDQ[14] LDCP_SA LDYMS[14] LDOE LDPRECH LDSAL vccsa vss rom2_sa
xsa[13] LDQ[13] LDCP_SA LDYMS[13] LDOE LDPRECH LDSAL vccsa vss rom2_sa
xsa[12] LDQ[12] LDCP_SA LDYMS[12] LDOE LDPRECH LDSAL vccsa vss rom2_sa
xsa[11] LDQ[11] LDCP_SA LDYMS[11] LDOE LDPRECH LDSAL vccsa vss rom2_sa
xsa[10] LDQ[10] LDCP_SA LDYMS[10] LDOE LDPRECH LDSAL vccsa vss rom2_sa
xsa[9] LDQ[9] LDCP_SA LDYMS[9] LDOE LDPRECH LDSAL vccsa vss rom2_sa
xsa[8] LDQ[8] LDCP_SA LDYMS[8] LDOE LDPRECH LDSAL vccsa vss rom2_sa
xsa[7] LDQ[7] LDCP_SA LDYMS[7] LDOE LDPRECH LDSAL vccsa vss rom2_sa
xsa[6] LDQ[6] LDCP_SA LDYMS[6] LDOE LDPRECH LDSAL vccsa vss rom2_sa
xsa[5] LDQ[5] LDCP_SA LDYMS[5] LDOE LDPRECH LDSAL vccsa vss rom2_sa
xsa[4] LDQ[4] LDCP_SA LDYMS[4] LDOE LDPRECH LDSAL vccsa vss rom2_sa
xsa[3] LDQ[3] LDCP_SA LDYMS[3] LDOE LDPRECH LDSAL vccsa vss rom2_sa
xsa[2] LDQ[2] LDCP_SA LDYMS[2] LDOE LDPRECH LDSAL vccsa vss rom2_sa
xsa[1] LDQ[1] LDCP_SA LDYMS[1] LDOE LDPRECH LDSAL vccsa vss rom2_sa
xsa[0] LDQ[0] LDCP_SA LDYMS[0] LDOE LDPRECH LDSAL vccsa vss rom2_sa
vsa vcc vccsa 0
.save i(vsa)
vdec vcc vccdec 0
.save i(vdec)
vl vcc vccl 0
.save i(vl)
xlat LDEN_LAT LDAI[12] LDAI[11] LDAI[10] LDAI[9] LDAI[8] LDAI[7] LDAI[6] LDAI[5] LDAI[4] LDAI[3]
+ LDAI[2] LDAI[1] LDAI[0] LDEN LDCP_ADDLAT_B LDA[12] LDA[11] LDA[10] LDA[9] LDA[8] LDA[7] LDA[6] LDA[5]
+ LDA[4] LDA[3] LDA[2] LDA[1] LDA[0] vccl vss rom2_addlatch
xctrl LDPRECH LDSAL LDCP_ROWDEC LDCP_SA LDCP_ADDLAT_B LDCP_COL_B LDEN_LAT LDCP vccl vss LDYMSREF
+ rom2_ctrl
xcpre LDY1[15] LDY1[14] LDY1[13] LDY1[12] LDY1[11] LDY1[10] LDY1[9] LDY1[8] LDY1[7] LDY1[6] LDY1[5]
+ LDY1[4] LDY1[3] LDY1[2] LDY1[1] LDY1[0] LDAI[3] LDAI[2] LDAI[1] LDAI[0] vccdec vss rom2_predec3
c1[15] LDL1X[15] vss 210f m=1
c1[14] LDL1X[14] vss 210f m=1
c1[13] LDL1X[13] vss 210f m=1
c1[12] LDL1X[12] vss 210f m=1
c1[11] LDL1X[11] vss 210f m=1
c1[10] LDL1X[10] vss 210f m=1
c1[9] LDL1X[9] vss 210f m=1
c1[8] LDL1X[8] vss 210f m=1
c1[7] LDL1X[7] vss 210f m=1
c1[6] LDL1X[6] vss 210f m=1
c1[5] LDL1X[5] vss 210f m=1
c1[4] LDL1X[4] vss 210f m=1
c1[3] LDL1X[3] vss 210f m=1
c1[2] LDL1X[2] vss 210f m=1
c1[1] LDL1X[1] vss 210f m=1
c1[0] LDL1X[0] vss 210f m=1
c2[3] LDL2X[3] vss 120f m=1
c2[2] LDL2X[2] vss 120f m=1
c2[1] LDL2X[1] vss 120f m=1
c2[0] LDL2X[0] vss 120f m=1
c4[12] LDAI[12] vss 40f m=1
c4[11] LDAI[11] vss 40f m=1
c4[10] LDAI[10] vss 40f m=1
c4[9] LDAI[9] vss 40f m=1
c4[8] LDAI[8] vss 40f m=1
c4[7] LDAI[7] vss 40f m=1
c4[6] LDAI[6] vss 40f m=1
c4[5] LDAI[5] vss 40f m=1
c4[4] LDAI[4] vss 40f m=1
c4[3] LDAI[3] vss 40f m=1
c4[2] LDAI[2] vss 40f m=1
c4[1] LDAI[1] vss 40f m=1
c4[0] LDAI[0] vss 40f m=1
c5[15] LDY1[15] vss 45f m=1
c5[14] LDY1[14] vss 45f m=1
c5[13] LDY1[13] vss 45f m=1
c5[12] LDY1[12] vss 45f m=1
c5[11] LDY1[11] vss 45f m=1
c5[10] LDY1[10] vss 45f m=1
c5[9] LDY1[9] vss 45f m=1
c5[8] LDY1[8] vss 45f m=1
c5[7] LDY1[7] vss 45f m=1
c5[6] LDY1[6] vss 45f m=1
c5[5] LDY1[5] vss 45f m=1
c5[4] LDY1[4] vss 45f m=1
c5[3] LDY1[3] vss 45f m=1
c5[2] LDY1[2] vss 45f m=1
c5[1] LDY1[1] vss 45f m=1
c5[0] LDY1[0] vss 45f m=1
xrdec[31] LDWL[511] LDWL[510] LDWL[509] LDWL[508] LDWL[507] LDWL[506] LDWL[505] LDWL[504] LDWL[503]
+ LDWL[502] LDWL[501] LDWL[500] LDWL[499] LDWL[498] LDWL[497] LDWL[496] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[3] LDL3X[7] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[30] LDWL[495] LDWL[494] LDWL[493] LDWL[492] LDWL[491] LDWL[490] LDWL[489] LDWL[488] LDWL[487]
+ LDWL[486] LDWL[485] LDWL[484] LDWL[483] LDWL[482] LDWL[481] LDWL[480] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[2] LDL3X[7] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[29] LDWL[479] LDWL[478] LDWL[477] LDWL[476] LDWL[475] LDWL[474] LDWL[473] LDWL[472] LDWL[471]
+ LDWL[470] LDWL[469] LDWL[468] LDWL[467] LDWL[466] LDWL[465] LDWL[464] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[1] LDL3X[7] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[28] LDWL[463] LDWL[462] LDWL[461] LDWL[460] LDWL[459] LDWL[458] LDWL[457] LDWL[456] LDWL[455]
+ LDWL[454] LDWL[453] LDWL[452] LDWL[451] LDWL[450] LDWL[449] LDWL[448] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[0] LDL3X[7] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[27] LDWL[447] LDWL[446] LDWL[445] LDWL[444] LDWL[443] LDWL[442] LDWL[441] LDWL[440] LDWL[439]
+ LDWL[438] LDWL[437] LDWL[436] LDWL[435] LDWL[434] LDWL[433] LDWL[432] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[3] LDL3X[6] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[26] LDWL[431] LDWL[430] LDWL[429] LDWL[428] LDWL[427] LDWL[426] LDWL[425] LDWL[424] LDWL[423]
+ LDWL[422] LDWL[421] LDWL[420] LDWL[419] LDWL[418] LDWL[417] LDWL[416] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[2] LDL3X[6] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[25] LDWL[415] LDWL[414] LDWL[413] LDWL[412] LDWL[411] LDWL[410] LDWL[409] LDWL[408] LDWL[407]
+ LDWL[406] LDWL[405] LDWL[404] LDWL[403] LDWL[402] LDWL[401] LDWL[400] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[1] LDL3X[6] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[24] LDWL[399] LDWL[398] LDWL[397] LDWL[396] LDWL[395] LDWL[394] LDWL[393] LDWL[392] LDWL[391]
+ LDWL[390] LDWL[389] LDWL[388] LDWL[387] LDWL[386] LDWL[385] LDWL[384] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[0] LDL3X[6] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[23] LDWL[383] LDWL[382] LDWL[381] LDWL[380] LDWL[379] LDWL[378] LDWL[377] LDWL[376] LDWL[375]
+ LDWL[374] LDWL[373] LDWL[372] LDWL[371] LDWL[370] LDWL[369] LDWL[368] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[3] LDL3X[5] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[22] LDWL[367] LDWL[366] LDWL[365] LDWL[364] LDWL[363] LDWL[362] LDWL[361] LDWL[360] LDWL[359]
+ LDWL[358] LDWL[357] LDWL[356] LDWL[355] LDWL[354] LDWL[353] LDWL[352] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[2] LDL3X[5] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[21] LDWL[351] LDWL[350] LDWL[349] LDWL[348] LDWL[347] LDWL[346] LDWL[345] LDWL[344] LDWL[343]
+ LDWL[342] LDWL[341] LDWL[340] LDWL[339] LDWL[338] LDWL[337] LDWL[336] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[1] LDL3X[5] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[20] LDWL[335] LDWL[334] LDWL[333] LDWL[332] LDWL[331] LDWL[330] LDWL[329] LDWL[328] LDWL[327]
+ LDWL[326] LDWL[325] LDWL[324] LDWL[323] LDWL[322] LDWL[321] LDWL[320] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[0] LDL3X[5] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[19] LDWL[319] LDWL[318] LDWL[317] LDWL[316] LDWL[315] LDWL[314] LDWL[313] LDWL[312] LDWL[311]
+ LDWL[310] LDWL[309] LDWL[308] LDWL[307] LDWL[306] LDWL[305] LDWL[304] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[3] LDL3X[4] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[18] LDWL[303] LDWL[302] LDWL[301] LDWL[300] LDWL[299] LDWL[298] LDWL[297] LDWL[296] LDWL[295]
+ LDWL[294] LDWL[293] LDWL[292] LDWL[291] LDWL[290] LDWL[289] LDWL[288] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[2] LDL3X[4] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[17] LDWL[287] LDWL[286] LDWL[285] LDWL[284] LDWL[283] LDWL[282] LDWL[281] LDWL[280] LDWL[279]
+ LDWL[278] LDWL[277] LDWL[276] LDWL[275] LDWL[274] LDWL[273] LDWL[272] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[1] LDL3X[4] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[16] LDWL[271] LDWL[270] LDWL[269] LDWL[268] LDWL[267] LDWL[266] LDWL[265] LDWL[264] LDWL[263]
+ LDWL[262] LDWL[261] LDWL[260] LDWL[259] LDWL[258] LDWL[257] LDWL[256] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[0] LDL3X[4] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[15] LDWL[255] LDWL[254] LDWL[253] LDWL[252] LDWL[251] LDWL[250] LDWL[249] LDWL[248] LDWL[247]
+ LDWL[246] LDWL[245] LDWL[244] LDWL[243] LDWL[242] LDWL[241] LDWL[240] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[3] LDL3X[3] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[14] LDWL[239] LDWL[238] LDWL[237] LDWL[236] LDWL[235] LDWL[234] LDWL[233] LDWL[232] LDWL[231]
+ LDWL[230] LDWL[229] LDWL[228] LDWL[227] LDWL[226] LDWL[225] LDWL[224] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[2] LDL3X[3] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[13] LDWL[223] LDWL[222] LDWL[221] LDWL[220] LDWL[219] LDWL[218] LDWL[217] LDWL[216] LDWL[215]
+ LDWL[214] LDWL[213] LDWL[212] LDWL[211] LDWL[210] LDWL[209] LDWL[208] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[1] LDL3X[3] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[12] LDWL[207] LDWL[206] LDWL[205] LDWL[204] LDWL[203] LDWL[202] LDWL[201] LDWL[200] LDWL[199]
+ LDWL[198] LDWL[197] LDWL[196] LDWL[195] LDWL[194] LDWL[193] LDWL[192] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[0] LDL3X[3] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[11] LDWL[191] LDWL[190] LDWL[189] LDWL[188] LDWL[187] LDWL[186] LDWL[185] LDWL[184] LDWL[183]
+ LDWL[182] LDWL[181] LDWL[180] LDWL[179] LDWL[178] LDWL[177] LDWL[176] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[3] LDL3X[2] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[10] LDWL[175] LDWL[174] LDWL[173] LDWL[172] LDWL[171] LDWL[170] LDWL[169] LDWL[168] LDWL[167]
+ LDWL[166] LDWL[165] LDWL[164] LDWL[163] LDWL[162] LDWL[161] LDWL[160] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[2] LDL3X[2] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[9] LDWL[159] LDWL[158] LDWL[157] LDWL[156] LDWL[155] LDWL[154] LDWL[153] LDWL[152] LDWL[151]
+ LDWL[150] LDWL[149] LDWL[148] LDWL[147] LDWL[146] LDWL[145] LDWL[144] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[1] LDL3X[2] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[8] LDWL[143] LDWL[142] LDWL[141] LDWL[140] LDWL[139] LDWL[138] LDWL[137] LDWL[136] LDWL[135]
+ LDWL[134] LDWL[133] LDWL[132] LDWL[131] LDWL[130] LDWL[129] LDWL[128] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[0] LDL3X[2] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[7] LDWL[127] LDWL[126] LDWL[125] LDWL[124] LDWL[123] LDWL[122] LDWL[121] LDWL[120] LDWL[119]
+ LDWL[118] LDWL[117] LDWL[116] LDWL[115] LDWL[114] LDWL[113] LDWL[112] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[3] LDL3X[1] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[6] LDWL[111] LDWL[110] LDWL[109] LDWL[108] LDWL[107] LDWL[106] LDWL[105] LDWL[104] LDWL[103]
+ LDWL[102] LDWL[101] LDWL[100] LDWL[99] LDWL[98] LDWL[97] LDWL[96] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12]
+ LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0]
+ LDL2X[2] LDL3X[1] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[5] LDWL[95] LDWL[94] LDWL[93] LDWL[92] LDWL[91] LDWL[90] LDWL[89] LDWL[88] LDWL[87] LDWL[86]
+ LDWL[85] LDWL[84] LDWL[83] LDWL[82] LDWL[81] LDWL[80] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12] LDL1X[11]
+ LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0] LDL2X[1]
+ LDL3X[1] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[4] LDWL[79] LDWL[78] LDWL[77] LDWL[76] LDWL[75] LDWL[74] LDWL[73] LDWL[72] LDWL[71] LDWL[70]
+ LDWL[69] LDWL[68] LDWL[67] LDWL[66] LDWL[65] LDWL[64] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12] LDL1X[11]
+ LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0] LDL2X[0]
+ LDL3X[1] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[3] LDWL[63] LDWL[62] LDWL[61] LDWL[60] LDWL[59] LDWL[58] LDWL[57] LDWL[56] LDWL[55] LDWL[54]
+ LDWL[53] LDWL[52] LDWL[51] LDWL[50] LDWL[49] LDWL[48] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12] LDL1X[11]
+ LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0] LDL2X[3]
+ LDL3X[0] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[2] LDWL[47] LDWL[46] LDWL[45] LDWL[44] LDWL[43] LDWL[42] LDWL[41] LDWL[40] LDWL[39] LDWL[38]
+ LDWL[37] LDWL[36] LDWL[35] LDWL[34] LDWL[33] LDWL[32] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12] LDL1X[11]
+ LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0] LDL2X[2]
+ LDL3X[0] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[1] LDWL[31] LDWL[30] LDWL[29] LDWL[28] LDWL[27] LDWL[26] LDWL[25] LDWL[24] LDWL[23] LDWL[22]
+ LDWL[21] LDWL[20] LDWL[19] LDWL[18] LDWL[17] LDWL[16] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12] LDL1X[11]
+ LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0] LDL2X[1]
+ LDL3X[0] LDCP_ROWDEC vss vccdec rom3_rowdec
xrdec[0] LDWL[15] LDWL[14] LDWL[13] LDWL[12] LDWL[11] LDWL[10] LDWL[9] LDWL[8] LDWL[7] LDWL[6]
+ LDWL[5] LDWL[4] LDWL[3] LDWL[2] LDWL[1] LDWL[0] LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12] LDL1X[11] LDL1X[10]
+ LDL1X[9] LDL1X[8] LDL1X[7] LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0] LDL2X[0] LDL3X[0]
+ LDCP_ROWDEC vss vccdec rom3_rowdec
xrpre1 LDL1X[15] LDL1X[14] LDL1X[13] LDL1X[12] LDL1X[11] LDL1X[10] LDL1X[9] LDL1X[8] LDL1X[7]
+ LDL1X[6] LDL1X[5] LDL1X[4] LDL1X[3] LDL1X[2] LDL1X[1] LDL1X[0] LDAI[7] LDAI[6] LDAI[5] LDAI[4] vccdec vss
+ rom2_predec1
xrpre2 LDAI[12] LDAI[11] LDAI[10] LDAI[9] LDAI[8] vccdec vss LDL2X[3] LDL2X[2] LDL2X[1] LDL2X[0]
+ LDL3X[7] LDL3X[6] LDL3X[5] LDL3X[4] LDL3X[3] LDL3X[2] LDL3X[1] LDL3X[0] rom2_predec4
c3[7] LDL3X[7] vss 120f m=1
c3[6] LDL3X[6] vss 120f m=1
c3[5] LDL3X[5] vss 120f m=1
c3[4] LDL3X[4] vss 120f m=1
c3[3] LDL3X[3] vss 120f m=1
c3[2] LDL3X[2] vss 120f m=1
c3[1] LDL3X[1] vss 120f m=1
c3[0] LDL3X[0] vss 120f m=1
xcdecref LDYMSREF LDBLREF vccdec vss rom2_coldec_ref
xarr_ref LDWL[511] LDWL[510] LDWL[509] LDWL[508] LDWL[507] LDWL[506] LDWL[505] LDWL[504] LDWL[503]
+ LDWL[502] LDWL[501] LDWL[500] LDWL[499] LDWL[498] LDWL[497] LDWL[496] LDWL[495] LDWL[494] LDWL[493] LDWL[492]
+ LDWL[491] LDWL[490] LDWL[489] LDWL[488] LDWL[487] LDWL[486] LDWL[485] LDWL[484] LDWL[483] LDWL[482] LDWL[481]
+ LDWL[480] LDWL[479] LDWL[478] LDWL[477] LDWL[476] LDWL[475] LDWL[474] LDWL[473] LDWL[472] LDWL[471] LDWL[470]
+ LDWL[469] LDWL[468] LDWL[467] LDWL[466] LDWL[465] LDWL[464] LDWL[463] LDWL[462] LDWL[461] LDWL[460] LDWL[459]
+ LDWL[458] LDWL[457] LDWL[456] LDWL[455] LDWL[454] LDWL[453] LDWL[452] LDWL[451] LDWL[450] LDWL[449] LDWL[448]
+ LDWL[447] LDWL[446] LDWL[445] LDWL[444] LDWL[443] LDWL[442] LDWL[441] LDWL[440] LDWL[439] LDWL[438] LDWL[437]
+ LDWL[436] LDWL[435] LDWL[434] LDWL[433] LDWL[432] LDWL[431] LDWL[430] LDWL[429] LDWL[428] LDWL[427] LDWL[426]
+ LDWL[425] LDWL[424] LDWL[423] LDWL[422] LDWL[421] LDWL[420] LDWL[419] LDWL[418] LDWL[417] LDWL[416] LDWL[415]
+ LDWL[414] LDWL[413] LDWL[412] LDWL[411] LDWL[410] LDWL[409] LDWL[408] LDWL[407] LDWL[406] LDWL[405] LDWL[404]
+ LDWL[403] LDWL[402] LDWL[401] LDWL[400] LDWL[399] LDWL[398] LDWL[397] LDWL[396] LDWL[395] LDWL[394] LDWL[393]
+ LDWL[392] LDWL[391] LDWL[390] LDWL[389] LDWL[388] LDWL[387] LDWL[386] LDWL[385] LDWL[384] LDWL[383] LDWL[382]
+ LDWL[381] LDWL[380] LDWL[379] LDWL[378] LDWL[377] LDWL[376] LDWL[375] LDWL[374] LDWL[373] LDWL[372] LDWL[371]
+ LDWL[370] LDWL[369] LDWL[368] LDWL[367] LDWL[366] LDWL[365] LDWL[364] LDWL[363] LDWL[362] LDWL[361] LDWL[360]
+ LDWL[359] LDWL[358] LDWL[357] LDWL[356] LDWL[355] LDWL[354] LDWL[353] LDWL[352] LDWL[351] LDWL[350] LDWL[349]
+ LDWL[348] LDWL[347] LDWL[346] LDWL[345] LDWL[344] LDWL[343] LDWL[342] LDWL[341] LDWL[340] LDWL[339] LDWL[338]
+ LDWL[337] LDWL[336] LDWL[335] LDWL[334] LDWL[333] LDWL[332] LDWL[331] LDWL[330] LDWL[329] LDWL[328] LDWL[327]
+ LDWL[326] LDWL[325] LDWL[324] LDWL[323] LDWL[322] LDWL[321] LDWL[320] LDWL[319] LDWL[318] LDWL[317] LDWL[316]
+ LDWL[315] LDWL[314] LDWL[313] LDWL[312] LDWL[311] LDWL[310] LDWL[309] LDWL[308] LDWL[307] LDWL[306] LDWL[305]
+ LDWL[304] LDWL[303] LDWL[302] LDWL[301] LDWL[300] LDWL[299] LDWL[298] LDWL[297] LDWL[296] LDWL[295] LDWL[294]
+ LDWL[293] LDWL[292] LDWL[291] LDWL[290] LDWL[289] LDWL[288] LDWL[287] LDWL[286] LDWL[285] LDWL[284] LDWL[283]
+ LDWL[282] LDWL[281] LDWL[280] LDWL[279] LDWL[278] LDWL[277] LDWL[276] LDWL[275] LDWL[274] LDWL[273] LDWL[272]
+ LDWL[271] LDWL[270] LDWL[269] LDWL[268] LDWL[267] LDWL[266] LDWL[265] LDWL[264] LDWL[263] LDWL[262] LDWL[261]
+ LDWL[260] LDWL[259] LDWL[258] LDWL[257] LDWL[256] LDWL[255] LDWL[254] LDWL[253] LDWL[252] LDWL[251] LDWL[250]
+ LDWL[249] LDWL[248] LDWL[247] LDWL[246] LDWL[245] LDWL[244] LDWL[243] LDWL[242] LDWL[241] LDWL[240] LDWL[239]
+ LDWL[238] LDWL[237] LDWL[236] LDWL[235] LDWL[234] LDWL[233] LDWL[232] LDWL[231] LDWL[230] LDWL[229] LDWL[228]
+ LDWL[227] LDWL[226] LDWL[225] LDWL[224] LDWL[223] LDWL[222] LDWL[221] LDWL[220] LDWL[219] LDWL[218] LDWL[217]
+ LDWL[216] LDWL[215] LDWL[214] LDWL[213] LDWL[212] LDWL[211] LDWL[210] LDWL[209] LDWL[208] LDWL[207] LDWL[206]
+ LDWL[205] LDWL[204] LDWL[203] LDWL[202] LDWL[201] LDWL[200] LDWL[199] LDWL[198] LDWL[197] LDWL[196] LDWL[195]
+ LDWL[194] LDWL[193] LDWL[192] LDWL[191] LDWL[190] LDWL[189] LDWL[188] LDWL[187] LDWL[186] LDWL[185] LDWL[184]
+ LDWL[183] LDWL[182] LDWL[181] LDWL[180] LDWL[179] LDWL[178] LDWL[177] LDWL[176] LDWL[175] LDWL[174] LDWL[173]
+ LDWL[172] LDWL[171] LDWL[170] LDWL[169] LDWL[168] LDWL[167] LDWL[166] LDWL[165] LDWL[164] LDWL[163] LDWL[162]
+ LDWL[161] LDWL[160] LDWL[159] LDWL[158] LDWL[157] LDWL[156] LDWL[155] LDWL[154] LDWL[153] LDWL[152] LDWL[151]
+ LDWL[150] LDWL[149] LDWL[148] LDWL[147] LDWL[146] LDWL[145] LDWL[144] LDWL[143] LDWL[142] LDWL[141] LDWL[140]
+ LDWL[139] LDWL[138] LDWL[137] LDWL[136] LDWL[135] LDWL[134] LDWL[133] LDWL[132] LDWL[131] LDWL[130] LDWL[129]
+ LDWL[128] LDWL[127] LDWL[126] LDWL[125] LDWL[124] LDWL[123] LDWL[122] LDWL[121] LDWL[120] LDWL[119] LDWL[118]
+ LDWL[117] LDWL[116] LDWL[115] LDWL[114] LDWL[113] LDWL[112] LDWL[111] LDWL[110] LDWL[109] LDWL[108] LDWL[107]
+ LDWL[106] LDWL[105] LDWL[104] LDWL[103] LDWL[102] LDWL[101] LDWL[100] LDWL[99] LDWL[98] LDWL[97] LDWL[96]
+ LDWL[95] LDWL[94] LDWL[93] LDWL[92] LDWL[91] LDWL[90] LDWL[89] LDWL[88] LDWL[87] LDWL[86] LDWL[85] LDWL[84]
+ LDWL[83] LDWL[82] LDWL[81] LDWL[80] LDWL[79] LDWL[78] LDWL[77] LDWL[76] LDWL[75] LDWL[74] LDWL[73] LDWL[72]
+ LDWL[71] LDWL[70] LDWL[69] LDWL[68] LDWL[67] LDWL[66] LDWL[65] LDWL[64] LDWL[63] LDWL[62] LDWL[61] LDWL[60]
+ LDWL[59] LDWL[58] LDWL[57] LDWL[56] LDWL[55] LDWL[54] LDWL[53] LDWL[52] LDWL[51] LDWL[50] LDWL[49] LDWL[48]
+ LDWL[47] LDWL[46] LDWL[45] LDWL[44] LDWL[43] LDWL[42] LDWL[41] LDWL[40] LDWL[39] LDWL[38] LDWL[37] LDWL[36]
+ LDWL[35] LDWL[34] LDWL[33] LDWL[32] LDWL[31] LDWL[30] LDWL[29] LDWL[28] LDWL[27] LDWL[26] LDWL[25] LDWL[24]
+ LDWL[23] LDWL[22] LDWL[21] LDWL[20] LDWL[19] LDWL[18] LDWL[17] LDWL[16] LDWL[15] LDWL[14] LDWL[13] LDWL[12]
+ LDWL[11] LDWL[10] LDWL[9] LDWL[8] LDWL[7] LDWL[6] LDWL[5] LDWL[4] LDWL[3] LDWL[2] LDWL[1] LDWL[0] vss
+ LDBLREF rom3_array_ref
xcpr[256] LDCP_COL_B LDBL[255] vss rom2_col_prech
xcpr[255] LDCP_COL_B LDBL[254] vss rom2_col_prech
xcpr[254] LDCP_COL_B LDBL[253] vss rom2_col_prech
xcpr[253] LDCP_COL_B LDBL[252] vss rom2_col_prech
xcpr[252] LDCP_COL_B LDBL[251] vss rom2_col_prech
xcpr[251] LDCP_COL_B LDBL[250] vss rom2_col_prech
xcpr[250] LDCP_COL_B LDBL[249] vss rom2_col_prech
xcpr[249] LDCP_COL_B LDBL[248] vss rom2_col_prech
xcpr[248] LDCP_COL_B LDBL[247] vss rom2_col_prech
xcpr[247] LDCP_COL_B LDBL[246] vss rom2_col_prech
xcpr[246] LDCP_COL_B LDBL[245] vss rom2_col_prech
xcpr[245] LDCP_COL_B LDBL[244] vss rom2_col_prech
xcpr[244] LDCP_COL_B LDBL[243] vss rom2_col_prech
xcpr[243] LDCP_COL_B LDBL[242] vss rom2_col_prech
xcpr[242] LDCP_COL_B LDBL[241] vss rom2_col_prech
xcpr[241] LDCP_COL_B LDBL[240] vss rom2_col_prech
xcpr[240] LDCP_COL_B LDBL[239] vss rom2_col_prech
xcpr[239] LDCP_COL_B LDBL[238] vss rom2_col_prech
xcpr[238] LDCP_COL_B LDBL[237] vss rom2_col_prech
xcpr[237] LDCP_COL_B LDBL[236] vss rom2_col_prech
xcpr[236] LDCP_COL_B LDBL[235] vss rom2_col_prech
xcpr[235] LDCP_COL_B LDBL[234] vss rom2_col_prech
xcpr[234] LDCP_COL_B LDBL[233] vss rom2_col_prech
xcpr[233] LDCP_COL_B LDBL[232] vss rom2_col_prech
xcpr[232] LDCP_COL_B LDBL[231] vss rom2_col_prech
xcpr[231] LDCP_COL_B LDBL[230] vss rom2_col_prech
xcpr[230] LDCP_COL_B LDBL[229] vss rom2_col_prech
xcpr[229] LDCP_COL_B LDBL[228] vss rom2_col_prech
xcpr[228] LDCP_COL_B LDBL[227] vss rom2_col_prech
xcpr[227] LDCP_COL_B LDBL[226] vss rom2_col_prech
xcpr[226] LDCP_COL_B LDBL[225] vss rom2_col_prech
xcpr[225] LDCP_COL_B LDBL[224] vss rom2_col_prech
xcpr[224] LDCP_COL_B LDBL[223] vss rom2_col_prech
xcpr[223] LDCP_COL_B LDBL[222] vss rom2_col_prech
xcpr[222] LDCP_COL_B LDBL[221] vss rom2_col_prech
xcpr[221] LDCP_COL_B LDBL[220] vss rom2_col_prech
xcpr[220] LDCP_COL_B LDBL[219] vss rom2_col_prech
xcpr[219] LDCP_COL_B LDBL[218] vss rom2_col_prech
xcpr[218] LDCP_COL_B LDBL[217] vss rom2_col_prech
xcpr[217] LDCP_COL_B LDBL[216] vss rom2_col_prech
xcpr[216] LDCP_COL_B LDBL[215] vss rom2_col_prech
xcpr[215] LDCP_COL_B LDBL[214] vss rom2_col_prech
xcpr[214] LDCP_COL_B LDBL[213] vss rom2_col_prech
xcpr[213] LDCP_COL_B LDBL[212] vss rom2_col_prech
xcpr[212] LDCP_COL_B LDBL[211] vss rom2_col_prech
xcpr[211] LDCP_COL_B LDBL[210] vss rom2_col_prech
xcpr[210] LDCP_COL_B LDBL[209] vss rom2_col_prech
xcpr[209] LDCP_COL_B LDBL[208] vss rom2_col_prech
xcpr[208] LDCP_COL_B LDBL[207] vss rom2_col_prech
xcpr[207] LDCP_COL_B LDBL[206] vss rom2_col_prech
xcpr[206] LDCP_COL_B LDBL[205] vss rom2_col_prech
xcpr[205] LDCP_COL_B LDBL[204] vss rom2_col_prech
xcpr[204] LDCP_COL_B LDBL[203] vss rom2_col_prech
xcpr[203] LDCP_COL_B LDBL[202] vss rom2_col_prech
xcpr[202] LDCP_COL_B LDBL[201] vss rom2_col_prech
xcpr[201] LDCP_COL_B LDBL[200] vss rom2_col_prech
xcpr[200] LDCP_COL_B LDBL[199] vss rom2_col_prech
xcpr[199] LDCP_COL_B LDBL[198] vss rom2_col_prech
xcpr[198] LDCP_COL_B LDBL[197] vss rom2_col_prech
xcpr[197] LDCP_COL_B LDBL[196] vss rom2_col_prech
xcpr[196] LDCP_COL_B LDBL[195] vss rom2_col_prech
xcpr[195] LDCP_COL_B LDBL[194] vss rom2_col_prech
xcpr[194] LDCP_COL_B LDBL[193] vss rom2_col_prech
xcpr[193] LDCP_COL_B LDBL[192] vss rom2_col_prech
xcpr[192] LDCP_COL_B LDBL[191] vss rom2_col_prech
xcpr[191] LDCP_COL_B LDBL[190] vss rom2_col_prech
xcpr[190] LDCP_COL_B LDBL[189] vss rom2_col_prech
xcpr[189] LDCP_COL_B LDBL[188] vss rom2_col_prech
xcpr[188] LDCP_COL_B LDBL[187] vss rom2_col_prech
xcpr[187] LDCP_COL_B LDBL[186] vss rom2_col_prech
xcpr[186] LDCP_COL_B LDBL[185] vss rom2_col_prech
xcpr[185] LDCP_COL_B LDBL[184] vss rom2_col_prech
xcpr[184] LDCP_COL_B LDBL[183] vss rom2_col_prech
xcpr[183] LDCP_COL_B LDBL[182] vss rom2_col_prech
xcpr[182] LDCP_COL_B LDBL[181] vss rom2_col_prech
xcpr[181] LDCP_COL_B LDBL[180] vss rom2_col_prech
xcpr[180] LDCP_COL_B LDBL[179] vss rom2_col_prech
xcpr[179] LDCP_COL_B LDBL[178] vss rom2_col_prech
xcpr[178] LDCP_COL_B LDBL[177] vss rom2_col_prech
xcpr[177] LDCP_COL_B LDBL[176] vss rom2_col_prech
xcpr[176] LDCP_COL_B LDBL[175] vss rom2_col_prech
xcpr[175] LDCP_COL_B LDBL[174] vss rom2_col_prech
xcpr[174] LDCP_COL_B LDBL[173] vss rom2_col_prech
xcpr[173] LDCP_COL_B LDBL[172] vss rom2_col_prech
xcpr[172] LDCP_COL_B LDBL[171] vss rom2_col_prech
xcpr[171] LDCP_COL_B LDBL[170] vss rom2_col_prech
xcpr[170] LDCP_COL_B LDBL[169] vss rom2_col_prech
xcpr[169] LDCP_COL_B LDBL[168] vss rom2_col_prech
xcpr[168] LDCP_COL_B LDBL[167] vss rom2_col_prech
xcpr[167] LDCP_COL_B LDBL[166] vss rom2_col_prech
xcpr[166] LDCP_COL_B LDBL[165] vss rom2_col_prech
xcpr[165] LDCP_COL_B LDBL[164] vss rom2_col_prech
xcpr[164] LDCP_COL_B LDBL[163] vss rom2_col_prech
xcpr[163] LDCP_COL_B LDBL[162] vss rom2_col_prech
xcpr[162] LDCP_COL_B LDBL[161] vss rom2_col_prech
xcpr[161] LDCP_COL_B LDBL[160] vss rom2_col_prech
xcpr[160] LDCP_COL_B LDBL[159] vss rom2_col_prech
xcpr[159] LDCP_COL_B LDBL[158] vss rom2_col_prech
xcpr[158] LDCP_COL_B LDBL[157] vss rom2_col_prech
xcpr[157] LDCP_COL_B LDBL[156] vss rom2_col_prech
xcpr[156] LDCP_COL_B LDBL[155] vss rom2_col_prech
xcpr[155] LDCP_COL_B LDBL[154] vss rom2_col_prech
xcpr[154] LDCP_COL_B LDBL[153] vss rom2_col_prech
xcpr[153] LDCP_COL_B LDBL[152] vss rom2_col_prech
xcpr[152] LDCP_COL_B LDBL[151] vss rom2_col_prech
xcpr[151] LDCP_COL_B LDBL[150] vss rom2_col_prech
xcpr[150] LDCP_COL_B LDBL[149] vss rom2_col_prech
xcpr[149] LDCP_COL_B LDBL[148] vss rom2_col_prech
xcpr[148] LDCP_COL_B LDBL[147] vss rom2_col_prech
xcpr[147] LDCP_COL_B LDBL[146] vss rom2_col_prech
xcpr[146] LDCP_COL_B LDBL[145] vss rom2_col_prech
xcpr[145] LDCP_COL_B LDBL[144] vss rom2_col_prech
xcpr[144] LDCP_COL_B LDBL[143] vss rom2_col_prech
xcpr[143] LDCP_COL_B LDBL[142] vss rom2_col_prech
xcpr[142] LDCP_COL_B LDBL[141] vss rom2_col_prech
xcpr[141] LDCP_COL_B LDBL[140] vss rom2_col_prech
xcpr[140] LDCP_COL_B LDBL[139] vss rom2_col_prech
xcpr[139] LDCP_COL_B LDBL[138] vss rom2_col_prech
xcpr[138] LDCP_COL_B LDBL[137] vss rom2_col_prech
xcpr[137] LDCP_COL_B LDBL[136] vss rom2_col_prech
xcpr[136] LDCP_COL_B LDBL[135] vss rom2_col_prech
xcpr[135] LDCP_COL_B LDBL[134] vss rom2_col_prech
xcpr[134] LDCP_COL_B LDBL[133] vss rom2_col_prech
xcpr[133] LDCP_COL_B LDBL[132] vss rom2_col_prech
xcpr[132] LDCP_COL_B LDBL[131] vss rom2_col_prech
xcpr[131] LDCP_COL_B LDBL[130] vss rom2_col_prech
xcpr[130] LDCP_COL_B LDBL[129] vss rom2_col_prech
xcpr[129] LDCP_COL_B LDBL[128] vss rom2_col_prech
xcpr[128] LDCP_COL_B LDBL[127] vss rom2_col_prech
xcpr[127] LDCP_COL_B LDBL[126] vss rom2_col_prech
xcpr[126] LDCP_COL_B LDBL[125] vss rom2_col_prech
xcpr[125] LDCP_COL_B LDBL[124] vss rom2_col_prech
xcpr[124] LDCP_COL_B LDBL[123] vss rom2_col_prech
xcpr[123] LDCP_COL_B LDBL[122] vss rom2_col_prech
xcpr[122] LDCP_COL_B LDBL[121] vss rom2_col_prech
xcpr[121] LDCP_COL_B LDBL[120] vss rom2_col_prech
xcpr[120] LDCP_COL_B LDBL[119] vss rom2_col_prech
xcpr[119] LDCP_COL_B LDBL[118] vss rom2_col_prech
xcpr[118] LDCP_COL_B LDBL[117] vss rom2_col_prech
xcpr[117] LDCP_COL_B LDBL[116] vss rom2_col_prech
xcpr[116] LDCP_COL_B LDBL[115] vss rom2_col_prech
xcpr[115] LDCP_COL_B LDBL[114] vss rom2_col_prech
xcpr[114] LDCP_COL_B LDBL[113] vss rom2_col_prech
xcpr[113] LDCP_COL_B LDBL[112] vss rom2_col_prech
xcpr[112] LDCP_COL_B LDBL[111] vss rom2_col_prech
xcpr[111] LDCP_COL_B LDBL[110] vss rom2_col_prech
xcpr[110] LDCP_COL_B LDBL[109] vss rom2_col_prech
xcpr[109] LDCP_COL_B LDBL[108] vss rom2_col_prech
xcpr[108] LDCP_COL_B LDBL[107] vss rom2_col_prech
xcpr[107] LDCP_COL_B LDBL[106] vss rom2_col_prech
xcpr[106] LDCP_COL_B LDBL[105] vss rom2_col_prech
xcpr[105] LDCP_COL_B LDBL[104] vss rom2_col_prech
xcpr[104] LDCP_COL_B LDBL[103] vss rom2_col_prech
xcpr[103] LDCP_COL_B LDBL[102] vss rom2_col_prech
xcpr[102] LDCP_COL_B LDBL[101] vss rom2_col_prech
xcpr[101] LDCP_COL_B LDBL[100] vss rom2_col_prech
xcpr[100] LDCP_COL_B LDBL[99] vss rom2_col_prech
xcpr[99] LDCP_COL_B LDBL[98] vss rom2_col_prech
xcpr[98] LDCP_COL_B LDBL[97] vss rom2_col_prech
xcpr[97] LDCP_COL_B LDBL[96] vss rom2_col_prech
xcpr[96] LDCP_COL_B LDBL[95] vss rom2_col_prech
xcpr[95] LDCP_COL_B LDBL[94] vss rom2_col_prech
xcpr[94] LDCP_COL_B LDBL[93] vss rom2_col_prech
xcpr[93] LDCP_COL_B LDBL[92] vss rom2_col_prech
xcpr[92] LDCP_COL_B LDBL[91] vss rom2_col_prech
xcpr[91] LDCP_COL_B LDBL[90] vss rom2_col_prech
xcpr[90] LDCP_COL_B LDBL[89] vss rom2_col_prech
xcpr[89] LDCP_COL_B LDBL[88] vss rom2_col_prech
xcpr[88] LDCP_COL_B LDBL[87] vss rom2_col_prech
xcpr[87] LDCP_COL_B LDBL[86] vss rom2_col_prech
xcpr[86] LDCP_COL_B LDBL[85] vss rom2_col_prech
xcpr[85] LDCP_COL_B LDBL[84] vss rom2_col_prech
xcpr[84] LDCP_COL_B LDBL[83] vss rom2_col_prech
xcpr[83] LDCP_COL_B LDBL[82] vss rom2_col_prech
xcpr[82] LDCP_COL_B LDBL[81] vss rom2_col_prech
xcpr[81] LDCP_COL_B LDBL[80] vss rom2_col_prech
xcpr[80] LDCP_COL_B LDBL[79] vss rom2_col_prech
xcpr[79] LDCP_COL_B LDBL[78] vss rom2_col_prech
xcpr[78] LDCP_COL_B LDBL[77] vss rom2_col_prech
xcpr[77] LDCP_COL_B LDBL[76] vss rom2_col_prech
xcpr[76] LDCP_COL_B LDBL[75] vss rom2_col_prech
xcpr[75] LDCP_COL_B LDBL[74] vss rom2_col_prech
xcpr[74] LDCP_COL_B LDBL[73] vss rom2_col_prech
xcpr[73] LDCP_COL_B LDBL[72] vss rom2_col_prech
xcpr[72] LDCP_COL_B LDBL[71] vss rom2_col_prech
xcpr[71] LDCP_COL_B LDBL[70] vss rom2_col_prech
xcpr[70] LDCP_COL_B LDBL[69] vss rom2_col_prech
xcpr[69] LDCP_COL_B LDBL[68] vss rom2_col_prech
xcpr[68] LDCP_COL_B LDBL[67] vss rom2_col_prech
xcpr[67] LDCP_COL_B LDBL[66] vss rom2_col_prech
xcpr[66] LDCP_COL_B LDBL[65] vss rom2_col_prech
xcpr[65] LDCP_COL_B LDBL[64] vss rom2_col_prech
xcpr[64] LDCP_COL_B LDBL[63] vss rom2_col_prech
xcpr[63] LDCP_COL_B LDBL[62] vss rom2_col_prech
xcpr[62] LDCP_COL_B LDBL[61] vss rom2_col_prech
xcpr[61] LDCP_COL_B LDBL[60] vss rom2_col_prech
xcpr[60] LDCP_COL_B LDBL[59] vss rom2_col_prech
xcpr[59] LDCP_COL_B LDBL[58] vss rom2_col_prech
xcpr[58] LDCP_COL_B LDBL[57] vss rom2_col_prech
xcpr[57] LDCP_COL_B LDBL[56] vss rom2_col_prech
xcpr[56] LDCP_COL_B LDBL[55] vss rom2_col_prech
xcpr[55] LDCP_COL_B LDBL[54] vss rom2_col_prech
xcpr[54] LDCP_COL_B LDBL[53] vss rom2_col_prech
xcpr[53] LDCP_COL_B LDBL[52] vss rom2_col_prech
xcpr[52] LDCP_COL_B LDBL[51] vss rom2_col_prech
xcpr[51] LDCP_COL_B LDBL[50] vss rom2_col_prech
xcpr[50] LDCP_COL_B LDBL[49] vss rom2_col_prech
xcpr[49] LDCP_COL_B LDBL[48] vss rom2_col_prech
xcpr[48] LDCP_COL_B LDBL[47] vss rom2_col_prech
xcpr[47] LDCP_COL_B LDBL[46] vss rom2_col_prech
xcpr[46] LDCP_COL_B LDBL[45] vss rom2_col_prech
xcpr[45] LDCP_COL_B LDBL[44] vss rom2_col_prech
xcpr[44] LDCP_COL_B LDBL[43] vss rom2_col_prech
xcpr[43] LDCP_COL_B LDBL[42] vss rom2_col_prech
xcpr[42] LDCP_COL_B LDBL[41] vss rom2_col_prech
xcpr[41] LDCP_COL_B LDBL[40] vss rom2_col_prech
xcpr[40] LDCP_COL_B LDBL[39] vss rom2_col_prech
xcpr[39] LDCP_COL_B LDBL[38] vss rom2_col_prech
xcpr[38] LDCP_COL_B LDBL[37] vss rom2_col_prech
xcpr[37] LDCP_COL_B LDBL[36] vss rom2_col_prech
xcpr[36] LDCP_COL_B LDBL[35] vss rom2_col_prech
xcpr[35] LDCP_COL_B LDBL[34] vss rom2_col_prech
xcpr[34] LDCP_COL_B LDBL[33] vss rom2_col_prech
xcpr[33] LDCP_COL_B LDBL[32] vss rom2_col_prech
xcpr[32] LDCP_COL_B LDBL[31] vss rom2_col_prech
xcpr[31] LDCP_COL_B LDBL[30] vss rom2_col_prech
xcpr[30] LDCP_COL_B LDBL[29] vss rom2_col_prech
xcpr[29] LDCP_COL_B LDBL[28] vss rom2_col_prech
xcpr[28] LDCP_COL_B LDBL[27] vss rom2_col_prech
xcpr[27] LDCP_COL_B LDBL[26] vss rom2_col_prech
xcpr[26] LDCP_COL_B LDBL[25] vss rom2_col_prech
xcpr[25] LDCP_COL_B LDBL[24] vss rom2_col_prech
xcpr[24] LDCP_COL_B LDBL[23] vss rom2_col_prech
xcpr[23] LDCP_COL_B LDBL[22] vss rom2_col_prech
xcpr[22] LDCP_COL_B LDBL[21] vss rom2_col_prech
xcpr[21] LDCP_COL_B LDBL[20] vss rom2_col_prech
xcpr[20] LDCP_COL_B LDBL[19] vss rom2_col_prech
xcpr[19] LDCP_COL_B LDBL[18] vss rom2_col_prech
xcpr[18] LDCP_COL_B LDBL[17] vss rom2_col_prech
xcpr[17] LDCP_COL_B LDBL[16] vss rom2_col_prech
xcpr[16] LDCP_COL_B LDBL[15] vss rom2_col_prech
xcpr[15] LDCP_COL_B LDBL[14] vss rom2_col_prech
xcpr[14] LDCP_COL_B LDBL[13] vss rom2_col_prech
xcpr[13] LDCP_COL_B LDBL[12] vss rom2_col_prech
xcpr[12] LDCP_COL_B LDBL[11] vss rom2_col_prech
xcpr[11] LDCP_COL_B LDBL[10] vss rom2_col_prech
xcpr[10] LDCP_COL_B LDBL[9] vss rom2_col_prech
xcpr[9] LDCP_COL_B LDBL[8] vss rom2_col_prech
xcpr[8] LDCP_COL_B LDBL[7] vss rom2_col_prech
xcpr[7] LDCP_COL_B LDBL[6] vss rom2_col_prech
xcpr[6] LDCP_COL_B LDBL[5] vss rom2_col_prech
xcpr[5] LDCP_COL_B LDBL[4] vss rom2_col_prech
xcpr[4] LDCP_COL_B LDBL[3] vss rom2_col_prech
xcpr[3] LDCP_COL_B LDBL[2] vss rom2_col_prech
xcpr[2] LDCP_COL_B LDBL[1] vss rom2_col_prech
xcpr[1] LDCP_COL_B LDBL[0] vss rom2_col_prech
xcpr[0] LDCP_COL_B LDBLREF vss rom2_col_prech
c0 LDPRECH vss 66f m=1
c6 LDSAL vss 34f m=1
c7 LDCP_ROWDEC vss 280f m=1
c8 LDCP_SA vss 44f m=1
c9 LDCP_COL_B vss 63f m=1
c10 LDCP_ADDLAT_B vss 12f m=1
.save v(ldq[15])
.save v(ldq[14])
.save v(ldq[13])
.save v(ldq[12])
.save v(ldq[11])
.save v(ldq[10])
.save v(ldq[9])
.save v(ldq[8])
.save v(ldq[7])
.save v(ldq[6])
.save v(ldq[5])
.save v(ldq[4])
.save v(ldq[3])
.save v(ldq[2])
.save v(ldq[1])
.save v(ldq[0])
.save v(ldl1x[15])
.save v(ldl1x[14])
.save v(ldl1x[13])
.save v(ldl1x[12])
.save v(ldl1x[11])
.save v(ldl1x[10])
.save v(ldl1x[9])
.save v(ldl1x[8])
.save v(ldl1x[7])
.save v(ldl1x[6])
.save v(ldl1x[5])
.save v(ldl1x[4])
.save v(ldl1x[3])
.save v(ldl1x[2])
.save v(ldl1x[1])
.save v(ldl1x[0])
.save v(ldy1[15])
.save v(ldy1[14])
.save v(ldy1[13])
.save v(ldy1[12])
.save v(ldy1[11])
.save v(ldy1[10])
.save v(ldy1[9])
.save v(ldy1[8])
.save v(ldy1[7])
.save v(ldy1[6])
.save v(ldy1[5])
.save v(ldy1[4])
.save v(ldy1[3])
.save v(ldy1[2])
.save v(ldy1[1])
.save v(ldy1[0])
.save v(ldl3x[7])
.save v(ldl3x[6])
.save v(ldl3x[5])
.save v(ldl3x[4])
.save v(ldl3x[3])
.save v(ldl3x[2])
.save v(ldl3x[1])
.save v(ldl3x[0])
.save v(ldl2x[3])
.save v(ldl2x[2])
.save v(ldl2x[1])
.save v(ldl2x[0])
.save v(ldai[12])
.save v(ldai[11])
.save v(ldai[10])
.save v(ldai[9])
.save v(ldai[8])
.save v(ldai[7])
.save v(ldai[6])
.save v(ldai[5])
.save v(ldai[4])
.save v(ldai[3])
.save v(ldai[2])
.save v(ldai[1])
.save v(ldai[0])
.save v(ldcp_sa)
.save v(ldcp_rowdec)
.save v(ldcp_addlat_b)
.save v(ldcp_col_b)
.save v(ldprech)
.save v(ldsal)
.save v(ldymsref)
.save v(lden_lat)
.save v(ldblref)
.save v(ldyms[15])
.save v(ldyms[14])
.save v(ldyms[13])
.save v(ldyms[12])
.save v(ldyms[11])
.save v(ldyms[10])
.save v(ldyms[9])
.save v(ldyms[8])
.save v(ldyms[7])
.save v(ldyms[6])
.save v(ldyms[5])
.save v(ldyms[4])
.save v(ldyms[3])
.save v(ldyms[2])
.save v(ldyms[1])
.save v(ldyms[0])
.save v(ldoe)
.save v(ldcp)
.save v(lden)
.save v(lda[12])
.save v(lda[11])
.save v(lda[10])
.save v(lda[9])
.save v(lda[8])
.save v(lda[7])
.save v(lda[6])
.save v(lda[5])
.save v(lda[4])
.save v(lda[3])
.save v(lda[2])
.save v(lda[1])
.save v(lda[0])
xarr LDWL[511] LDWL[510] LDWL[509] LDWL[508] LDWL[507] LDWL[506] LDWL[505] LDWL[504] LDWL[503]
+ LDWL[502] LDWL[501] LDWL[500] LDWL[499] LDWL[498] LDWL[497] LDWL[496] LDWL[495] LDWL[494] LDWL[493] LDWL[492]
+ LDWL[491] LDWL[490] LDWL[489] LDWL[488] LDWL[487] LDWL[486] LDWL[485] LDWL[484] LDWL[483] LDWL[482] LDWL[481]
+ LDWL[480] LDWL[479] LDWL[478] LDWL[477] LDWL[476] LDWL[475] LDWL[474] LDWL[473] LDWL[472] LDWL[471] LDWL[470]
+ LDWL[469] LDWL[468] LDWL[467] LDWL[466] LDWL[465] LDWL[464] LDWL[463] LDWL[462] LDWL[461] LDWL[460] LDWL[459]
+ LDWL[458] LDWL[457] LDWL[456] LDWL[455] LDWL[454] LDWL[453] LDWL[452] LDWL[451] LDWL[450] LDWL[449] LDWL[448]
+ LDWL[447] LDWL[446] LDWL[445] LDWL[444] LDWL[443] LDWL[442] LDWL[441] LDWL[440] LDWL[439] LDWL[438] LDWL[437]
+ LDWL[436] LDWL[435] LDWL[434] LDWL[433] LDWL[432] LDWL[431] LDWL[430] LDWL[429] LDWL[428] LDWL[427] LDWL[426]
+ LDWL[425] LDWL[424] LDWL[423] LDWL[422] LDWL[421] LDWL[420] LDWL[419] LDWL[418] LDWL[417] LDWL[416] LDWL[415]
+ LDWL[414] LDWL[413] LDWL[412] LDWL[411] LDWL[410] LDWL[409] LDWL[408] LDWL[407] LDWL[406] LDWL[405] LDWL[404]
+ LDWL[403] LDWL[402] LDWL[401] LDWL[400] LDWL[399] LDWL[398] LDWL[397] LDWL[396] LDWL[395] LDWL[394] LDWL[393]
+ LDWL[392] LDWL[391] LDWL[390] LDWL[389] LDWL[388] LDWL[387] LDWL[386] LDWL[385] LDWL[384] LDWL[383] LDWL[382]
+ LDWL[381] LDWL[380] LDWL[379] LDWL[378] LDWL[377] LDWL[376] LDWL[375] LDWL[374] LDWL[373] LDWL[372] LDWL[371]
+ LDWL[370] LDWL[369] LDWL[368] LDWL[367] LDWL[366] LDWL[365] LDWL[364] LDWL[363] LDWL[362] LDWL[361] LDWL[360]
+ LDWL[359] LDWL[358] LDWL[357] LDWL[356] LDWL[355] LDWL[354] LDWL[353] LDWL[352] LDWL[351] LDWL[350] LDWL[349]
+ LDWL[348] LDWL[347] LDWL[346] LDWL[345] LDWL[344] LDWL[343] LDWL[342] LDWL[341] LDWL[340] LDWL[339] LDWL[338]
+ LDWL[337] LDWL[336] LDWL[335] LDWL[334] LDWL[333] LDWL[332] LDWL[331] LDWL[330] LDWL[329] LDWL[328] LDWL[327]
+ LDWL[326] LDWL[325] LDWL[324] LDWL[323] LDWL[322] LDWL[321] LDWL[320] LDWL[319] LDWL[318] LDWL[317] LDWL[316]
+ LDWL[315] LDWL[314] LDWL[313] LDWL[312] LDWL[311] LDWL[310] LDWL[309] LDWL[308] LDWL[307] LDWL[306] LDWL[305]
+ LDWL[304] LDWL[303] LDWL[302] LDWL[301] LDWL[300] LDWL[299] LDWL[298] LDWL[297] LDWL[296] LDWL[295] LDWL[294]
+ LDWL[293] LDWL[292] LDWL[291] LDWL[290] LDWL[289] LDWL[288] LDWL[287] LDWL[286] LDWL[285] LDWL[284] LDWL[283]
+ LDWL[282] LDWL[281] LDWL[280] LDWL[279] LDWL[278] LDWL[277] LDWL[276] LDWL[275] LDWL[274] LDWL[273] LDWL[272]
+ LDWL[271] LDWL[270] LDWL[269] LDWL[268] LDWL[267] LDWL[266] LDWL[265] LDWL[264] LDWL[263] LDWL[262] LDWL[261]
+ LDWL[260] LDWL[259] LDWL[258] LDWL[257] LDWL[256] LDWL[255] LDWL[254] LDWL[253] LDWL[252] LDWL[251] LDWL[250]
+ LDWL[249] LDWL[248] LDWL[247] LDWL[246] LDWL[245] LDWL[244] LDWL[243] LDWL[242] LDWL[241] LDWL[240] LDWL[239]
+ LDWL[238] LDWL[237] LDWL[236] LDWL[235] LDWL[234] LDWL[233] LDWL[232] LDWL[231] LDWL[230] LDWL[229] LDWL[228]
+ LDWL[227] LDWL[226] LDWL[225] LDWL[224] LDWL[223] LDWL[222] LDWL[221] LDWL[220] LDWL[219] LDWL[218] LDWL[217]
+ LDWL[216] LDWL[215] LDWL[214] LDWL[213] LDWL[212] LDWL[211] LDWL[210] LDWL[209] LDWL[208] LDWL[207] LDWL[206]
+ LDWL[205] LDWL[204] LDWL[203] LDWL[202] LDWL[201] LDWL[200] LDWL[199] LDWL[198] LDWL[197] LDWL[196] LDWL[195]
+ LDWL[194] LDWL[193] LDWL[192] LDWL[191] LDWL[190] LDWL[189] LDWL[188] LDWL[187] LDWL[186] LDWL[185] LDWL[184]
+ LDWL[183] LDWL[182] LDWL[181] LDWL[180] LDWL[179] LDWL[178] LDWL[177] LDWL[176] LDWL[175] LDWL[174] LDWL[173]
+ LDWL[172] LDWL[171] LDWL[170] LDWL[169] LDWL[168] LDWL[167] LDWL[166] LDWL[165] LDWL[164] LDWL[163] LDWL[162]
+ LDWL[161] LDWL[160] LDWL[159] LDWL[158] LDWL[157] LDWL[156] LDWL[155] LDWL[154] LDWL[153] LDWL[152] LDWL[151]
+ LDWL[150] LDWL[149] LDWL[148] LDWL[147] LDWL[146] LDWL[145] LDWL[144] LDWL[143] LDWL[142] LDWL[141] LDWL[140]
+ LDWL[139] LDWL[138] LDWL[137] LDWL[136] LDWL[135] LDWL[134] LDWL[133] LDWL[132] LDWL[131] LDWL[130] LDWL[129]
+ LDWL[128] LDWL[127] LDWL[126] LDWL[125] LDWL[124] LDWL[123] LDWL[122] LDWL[121] LDWL[120] LDWL[119] LDWL[118]
+ LDWL[117] LDWL[116] LDWL[115] LDWL[114] LDWL[113] LDWL[112] LDWL[111] LDWL[110] LDWL[109] LDWL[108] LDWL[107]
+ LDWL[106] LDWL[105] LDWL[104] LDWL[103] LDWL[102] LDWL[101] LDWL[100] LDWL[99] LDWL[98] LDWL[97] LDWL[96]
+ LDWL[95] LDWL[94] LDWL[93] LDWL[92] LDWL[91] LDWL[90] LDWL[89] LDWL[88] LDWL[87] LDWL[86] LDWL[85] LDWL[84]
+ LDWL[83] LDWL[82] LDWL[81] LDWL[80] LDWL[79] LDWL[78] LDWL[77] LDWL[76] LDWL[75] LDWL[74] LDWL[73] LDWL[72]
+ LDWL[71] LDWL[70] LDWL[69] LDWL[68] LDWL[67] LDWL[66] LDWL[65] LDWL[64] LDWL[63] LDWL[62] LDWL[61] LDWL[60]
+ LDWL[59] LDWL[58] LDWL[57] LDWL[56] LDWL[55] LDWL[54] LDWL[53] LDWL[52] LDWL[51] LDWL[50] LDWL[49] LDWL[48]
+ LDWL[47] LDWL[46] LDWL[45] LDWL[44] LDWL[43] LDWL[42] LDWL[41] LDWL[40] LDWL[39] LDWL[38] LDWL[37] LDWL[36]
+ LDWL[35] LDWL[34] LDWL[33] LDWL[32] LDWL[31] LDWL[30] LDWL[29] LDWL[28] LDWL[27] LDWL[26] LDWL[25] LDWL[24]
+ LDWL[23] LDWL[22] LDWL[21] LDWL[20] LDWL[19] LDWL[18] LDWL[17] LDWL[16] LDWL[15] LDWL[14] LDWL[13] LDWL[12]
+ LDWL[11] LDWL[10] LDWL[9] LDWL[8] LDWL[7] LDWL[6] LDWL[5] LDWL[4] LDWL[3] LDWL[2] LDWL[1] LDWL[0] LDBL[255]
+ LDBL[254] LDBL[253] LDBL[252] LDBL[251] LDBL[250] LDBL[249] LDBL[248] LDBL[247] LDBL[246] LDBL[245] LDBL[244]
+ LDBL[243] LDBL[242] LDBL[241] LDBL[240] LDBL[239] LDBL[238] LDBL[237] LDBL[236] LDBL[235] LDBL[234] LDBL[233]
+ LDBL[232] LDBL[231] LDBL[230] LDBL[229] LDBL[228] LDBL[227] LDBL[226] LDBL[225] LDBL[224] LDBL[223] LDBL[222]
+ LDBL[221] LDBL[220] LDBL[219] LDBL[218] LDBL[217] LDBL[216] LDBL[215] LDBL[214] LDBL[213] LDBL[212] LDBL[211]
+ LDBL[210] LDBL[209] LDBL[208] LDBL[207] LDBL[206] LDBL[205] LDBL[204] LDBL[203] LDBL[202] LDBL[201] LDBL[200]
+ LDBL[199] LDBL[198] LDBL[197] LDBL[196] LDBL[195] LDBL[194] LDBL[193] LDBL[192] LDBL[191] LDBL[190] LDBL[189]
+ LDBL[188] LDBL[187] LDBL[186] LDBL[185] LDBL[184] LDBL[183] LDBL[182] LDBL[181] LDBL[180] LDBL[179] LDBL[178]
+ LDBL[177] LDBL[176] LDBL[175] LDBL[174] LDBL[173] LDBL[172] LDBL[171] LDBL[170] LDBL[169] LDBL[168] LDBL[167]
+ LDBL[166] LDBL[165] LDBL[164] LDBL[163] LDBL[162] LDBL[161] LDBL[160] LDBL[159] LDBL[158] LDBL[157] LDBL[156]
+ LDBL[155] LDBL[154] LDBL[153] LDBL[152] LDBL[151] LDBL[150] LDBL[149] LDBL[148] LDBL[147] LDBL[146] LDBL[145]
+ LDBL[144] LDBL[143] LDBL[142] LDBL[141] LDBL[140] LDBL[139] LDBL[138] LDBL[137] LDBL[136] LDBL[135] LDBL[134]
+ LDBL[133] LDBL[132] LDBL[131] LDBL[130] LDBL[129] LDBL[128] LDBL[127] LDBL[126] LDBL[125] LDBL[124] LDBL[123]
+ LDBL[122] LDBL[121] LDBL[120] LDBL[119] LDBL[118] LDBL[117] LDBL[116] LDBL[115] LDBL[114] LDBL[113] LDBL[112]
+ LDBL[111] LDBL[110] LDBL[109] LDBL[108] LDBL[107] LDBL[106] LDBL[105] LDBL[104] LDBL[103] LDBL[102] LDBL[101]
+ LDBL[100] LDBL[99] LDBL[98] LDBL[97] LDBL[96] LDBL[95] LDBL[94] LDBL[93] LDBL[92] LDBL[91] LDBL[90] LDBL[89]
+ LDBL[88] LDBL[87] LDBL[86] LDBL[85] LDBL[84] LDBL[83] LDBL[82] LDBL[81] LDBL[80] LDBL[79] LDBL[78] LDBL[77]
+ LDBL[76] LDBL[75] LDBL[74] LDBL[73] LDBL[72] LDBL[71] LDBL[70] LDBL[69] LDBL[68] LDBL[67] LDBL[66] LDBL[65]
+ LDBL[64] LDBL[63] LDBL[62] LDBL[61] LDBL[60] LDBL[59] LDBL[58] LDBL[57] LDBL[56] LDBL[55] LDBL[54] LDBL[53]
+ LDBL[52] LDBL[51] LDBL[50] LDBL[49] LDBL[48] LDBL[47] LDBL[46] LDBL[45] LDBL[44] LDBL[43] LDBL[42] LDBL[41]
+ LDBL[40] LDBL[39] LDBL[38] LDBL[37] LDBL[36] LDBL[35] LDBL[34] LDBL[33] LDBL[32] LDBL[31] LDBL[30] LDBL[29]
+ LDBL[28] LDBL[27] LDBL[26] LDBL[25] LDBL[24] LDBL[23] LDBL[22] LDBL[21] LDBL[20] LDBL[19] LDBL[18] LDBL[17]
+ LDBL[16] LDBL[15] LDBL[14] LDBL[13] LDBL[12] LDBL[11] LDBL[10] LDBL[9] LDBL[8] LDBL[7] LDBL[6] LDBL[5]
+ LDBL[4] LDBL[3] LDBL[2] LDBL[1] LDBL[0] vss rom3_array
.save v(ldymsref)
.save v(vcc)
.save v(ldwl[511])
.save v(ldwl[510])
.save v(ldwl[509])
.save v(ldwl[508])
.save v(ldwl[507])
.save v(ldwl[506])
.save v(ldwl[505])
.save v(ldwl[504])
.save v(ldwl[503])
.save v(ldwl[502])
.save v(ldwl[501])
.save v(ldwl[500])
.save v(ldwl[499])
.save v(ldwl[498])
.save v(ldwl[497])
.save v(ldwl[496])
.save v(ldwl[495])
.save v(ldwl[494])
.save v(ldwl[493])
.save v(ldwl[492])
.save v(ldwl[491])
.save v(ldwl[490])
.save v(ldwl[489])
.save v(ldwl[488])
.save v(ldwl[487])
.save v(ldwl[486])
.save v(ldwl[485])
.save v(ldwl[484])
.save v(ldwl[483])
.save v(ldwl[482])
.save v(ldwl[481])
.save v(ldwl[480])
.save v(ldwl[479])
.save v(ldwl[478])
.save v(ldwl[477])
.save v(ldwl[476])
.save v(ldwl[475])
.save v(ldwl[474])
.save v(ldwl[473])
.save v(ldwl[472])
.save v(ldwl[471])
.save v(ldwl[470])
.save v(ldwl[469])
.save v(ldwl[468])
.save v(ldwl[467])
.save v(ldwl[466])
.save v(ldwl[465])
.save v(ldwl[464])
.save v(ldwl[463])
.save v(ldwl[462])
.save v(ldwl[461])
.save v(ldwl[460])
.save v(ldwl[459])
.save v(ldwl[458])
.save v(ldwl[457])
.save v(ldwl[456])
.save v(ldwl[455])
.save v(ldwl[454])
.save v(ldwl[453])
.save v(ldwl[452])
.save v(ldwl[451])
.save v(ldwl[450])
.save v(ldwl[449])
.save v(ldwl[448])
.save v(ldwl[447])
.save v(ldwl[446])
.save v(ldwl[445])
.save v(ldwl[444])
.save v(ldwl[443])
.save v(ldwl[442])
.save v(ldwl[441])
.save v(ldwl[440])
.save v(ldwl[439])
.save v(ldwl[438])
.save v(ldwl[437])
.save v(ldwl[436])
.save v(ldwl[435])
.save v(ldwl[434])
.save v(ldwl[433])
.save v(ldwl[432])
.save v(ldwl[431])
.save v(ldwl[430])
.save v(ldwl[429])
.save v(ldwl[428])
.save v(ldwl[427])
.save v(ldwl[426])
.save v(ldwl[425])
.save v(ldwl[424])
.save v(ldwl[423])
.save v(ldwl[422])
.save v(ldwl[421])
.save v(ldwl[420])
.save v(ldwl[419])
.save v(ldwl[418])
.save v(ldwl[417])
.save v(ldwl[416])
.save v(ldwl[415])
.save v(ldwl[414])
.save v(ldwl[413])
.save v(ldwl[412])
.save v(ldwl[411])
.save v(ldwl[410])
.save v(ldwl[409])
.save v(ldwl[408])
.save v(ldwl[407])
.save v(ldwl[406])
.save v(ldwl[405])
.save v(ldwl[404])
.save v(ldwl[403])
.save v(ldwl[402])
.save v(ldwl[401])
.save v(ldwl[400])
.save v(ldwl[399])
.save v(ldwl[398])
.save v(ldwl[397])
.save v(ldwl[396])
.save v(ldwl[395])
.save v(ldwl[394])
.save v(ldwl[393])
.save v(ldwl[392])
.save v(ldwl[391])
.save v(ldwl[390])
.save v(ldwl[389])
.save v(ldwl[388])
.save v(ldwl[387])
.save v(ldwl[386])
.save v(ldwl[385])
.save v(ldwl[384])
.save v(ldwl[383])
.save v(ldwl[382])
.save v(ldwl[381])
.save v(ldwl[380])
.save v(ldwl[379])
.save v(ldwl[378])
.save v(ldwl[377])
.save v(ldwl[376])
.save v(ldwl[375])
.save v(ldwl[374])
.save v(ldwl[373])
.save v(ldwl[372])
.save v(ldwl[371])
.save v(ldwl[370])
.save v(ldwl[369])
.save v(ldwl[368])
.save v(ldwl[367])
.save v(ldwl[366])
.save v(ldwl[365])
.save v(ldwl[364])
.save v(ldwl[363])
.save v(ldwl[362])
.save v(ldwl[361])
.save v(ldwl[360])
.save v(ldwl[359])
.save v(ldwl[358])
.save v(ldwl[357])
.save v(ldwl[356])
.save v(ldwl[355])
.save v(ldwl[354])
.save v(ldwl[353])
.save v(ldwl[352])
.save v(ldwl[351])
.save v(ldwl[350])
.save v(ldwl[349])
.save v(ldwl[348])
.save v(ldwl[347])
.save v(ldwl[346])
.save v(ldwl[345])
.save v(ldwl[344])
.save v(ldwl[343])
.save v(ldwl[342])
.save v(ldwl[341])
.save v(ldwl[340])
.save v(ldwl[339])
.save v(ldwl[338])
.save v(ldwl[337])
.save v(ldwl[336])
.save v(ldwl[335])
.save v(ldwl[334])
.save v(ldwl[333])
.save v(ldwl[332])
.save v(ldwl[331])
.save v(ldwl[330])
.save v(ldwl[329])
.save v(ldwl[328])
.save v(ldwl[327])
.save v(ldwl[326])
.save v(ldwl[325])
.save v(ldwl[324])
.save v(ldwl[323])
.save v(ldwl[322])
.save v(ldwl[321])
.save v(ldwl[320])
.save v(ldwl[319])
.save v(ldwl[318])
.save v(ldwl[317])
.save v(ldwl[316])
.save v(ldwl[315])
.save v(ldwl[314])
.save v(ldwl[313])
.save v(ldwl[312])
.save v(ldwl[311])
.save v(ldwl[310])
.save v(ldwl[309])
.save v(ldwl[308])
.save v(ldwl[307])
.save v(ldwl[306])
.save v(ldwl[305])
.save v(ldwl[304])
.save v(ldwl[303])
.save v(ldwl[302])
.save v(ldwl[301])
.save v(ldwl[300])
.save v(ldwl[299])
.save v(ldwl[298])
.save v(ldwl[297])
.save v(ldwl[296])
.save v(ldwl[295])
.save v(ldwl[294])
.save v(ldwl[293])
.save v(ldwl[292])
.save v(ldwl[291])
.save v(ldwl[290])
.save v(ldwl[289])
.save v(ldwl[288])
.save v(ldwl[287])
.save v(ldwl[286])
.save v(ldwl[285])
.save v(ldwl[284])
.save v(ldwl[283])
.save v(ldwl[282])
.save v(ldwl[281])
.save v(ldwl[280])
.save v(ldwl[279])
.save v(ldwl[278])
.save v(ldwl[277])
.save v(ldwl[276])
.save v(ldwl[275])
.save v(ldwl[274])
.save v(ldwl[273])
.save v(ldwl[272])
.save v(ldwl[271])
.save v(ldwl[270])
.save v(ldwl[269])
.save v(ldwl[268])
.save v(ldwl[267])
.save v(ldwl[266])
.save v(ldwl[265])
.save v(ldwl[264])
.save v(ldwl[263])
.save v(ldwl[262])
.save v(ldwl[261])
.save v(ldwl[260])
.save v(ldwl[259])
.save v(ldwl[258])
.save v(ldwl[257])
.save v(ldwl[256])
.save v(ldwl[255])
.save v(ldwl[254])
.save v(ldwl[253])
.save v(ldwl[252])
.save v(ldwl[251])
.save v(ldwl[250])
.save v(ldwl[249])
.save v(ldwl[248])
.save v(ldwl[247])
.save v(ldwl[246])
.save v(ldwl[245])
.save v(ldwl[244])
.save v(ldwl[243])
.save v(ldwl[242])
.save v(ldwl[241])
.save v(ldwl[240])
.save v(ldwl[239])
.save v(ldwl[238])
.save v(ldwl[237])
.save v(ldwl[236])
.save v(ldwl[235])
.save v(ldwl[234])
.save v(ldwl[233])
.save v(ldwl[232])
.save v(ldwl[231])
.save v(ldwl[230])
.save v(ldwl[229])
.save v(ldwl[228])
.save v(ldwl[227])
.save v(ldwl[226])
.save v(ldwl[225])
.save v(ldwl[224])
.save v(ldwl[223])
.save v(ldwl[222])
.save v(ldwl[221])
.save v(ldwl[220])
.save v(ldwl[219])
.save v(ldwl[218])
.save v(ldwl[217])
.save v(ldwl[216])
.save v(ldwl[215])
.save v(ldwl[214])
.save v(ldwl[213])
.save v(ldwl[212])
.save v(ldwl[211])
.save v(ldwl[210])
.save v(ldwl[209])
.save v(ldwl[208])
.save v(ldwl[207])
.save v(ldwl[206])
.save v(ldwl[205])
.save v(ldwl[204])
.save v(ldwl[203])
.save v(ldwl[202])
.save v(ldwl[201])
.save v(ldwl[200])
.save v(ldwl[199])
.save v(ldwl[198])
.save v(ldwl[197])
.save v(ldwl[196])
.save v(ldwl[195])
.save v(ldwl[194])
.save v(ldwl[193])
.save v(ldwl[192])
.save v(ldwl[191])
.save v(ldwl[190])
.save v(ldwl[189])
.save v(ldwl[188])
.save v(ldwl[187])
.save v(ldwl[186])
.save v(ldwl[185])
.save v(ldwl[184])
.save v(ldwl[183])
.save v(ldwl[182])
.save v(ldwl[181])
.save v(ldwl[180])
.save v(ldwl[179])
.save v(ldwl[178])
.save v(ldwl[177])
.save v(ldwl[176])
.save v(ldwl[175])
.save v(ldwl[174])
.save v(ldwl[173])
.save v(ldwl[172])
.save v(ldwl[171])
.save v(ldwl[170])
.save v(ldwl[169])
.save v(ldwl[168])
.save v(ldwl[167])
.save v(ldwl[166])
.save v(ldwl[165])
.save v(ldwl[164])
.save v(ldwl[163])
.save v(ldwl[162])
.save v(ldwl[161])
.save v(ldwl[160])
.save v(ldwl[159])
.save v(ldwl[158])
.save v(ldwl[157])
.save v(ldwl[156])
.save v(ldwl[155])
.save v(ldwl[154])
.save v(ldwl[153])
.save v(ldwl[152])
.save v(ldwl[151])
.save v(ldwl[150])
.save v(ldwl[149])
.save v(ldwl[148])
.save v(ldwl[147])
.save v(ldwl[146])
.save v(ldwl[145])
.save v(ldwl[144])
.save v(ldwl[143])
.save v(ldwl[142])
.save v(ldwl[141])
.save v(ldwl[140])
.save v(ldwl[139])
.save v(ldwl[138])
.save v(ldwl[137])
.save v(ldwl[136])
.save v(ldwl[135])
.save v(ldwl[134])
.save v(ldwl[133])
.save v(ldwl[132])
.save v(ldwl[131])
.save v(ldwl[130])
.save v(ldwl[129])
.save v(ldwl[128])
.save v(ldwl[127])
.save v(ldwl[126])
.save v(ldwl[125])
.save v(ldwl[124])
.save v(ldwl[123])
.save v(ldwl[122])
.save v(ldwl[121])
.save v(ldwl[120])
.save v(ldwl[119])
.save v(ldwl[118])
.save v(ldwl[117])
.save v(ldwl[116])
.save v(ldwl[115])
.save v(ldwl[114])
.save v(ldwl[113])
.save v(ldwl[112])
.save v(ldwl[111])
.save v(ldwl[110])
.save v(ldwl[109])
.save v(ldwl[108])
.save v(ldwl[107])
.save v(ldwl[106])
.save v(ldwl[105])
.save v(ldwl[104])
.save v(ldwl[103])
.save v(ldwl[102])
.save v(ldwl[101])
.save v(ldwl[100])
.save v(ldwl[99])
.save v(ldwl[98])
.save v(ldwl[97])
.save v(ldwl[96])
.save v(ldwl[95])
.save v(ldwl[94])
.save v(ldwl[93])
.save v(ldwl[92])
.save v(ldwl[91])
.save v(ldwl[90])
.save v(ldwl[89])
.save v(ldwl[88])
.save v(ldwl[87])
.save v(ldwl[86])
.save v(ldwl[85])
.save v(ldwl[84])
.save v(ldwl[83])
.save v(ldwl[82])
.save v(ldwl[81])
.save v(ldwl[80])
.save v(ldwl[79])
.save v(ldwl[78])
.save v(ldwl[77])
.save v(ldwl[76])
.save v(ldwl[75])
.save v(ldwl[74])
.save v(ldwl[73])
.save v(ldwl[72])
.save v(ldwl[71])
.save v(ldwl[70])
.save v(ldwl[69])
.save v(ldwl[68])
.save v(ldwl[67])
.save v(ldwl[66])
.save v(ldwl[65])
.save v(ldwl[64])
.save v(ldwl[63])
.save v(ldwl[62])
.save v(ldwl[61])
.save v(ldwl[60])
.save v(ldwl[59])
.save v(ldwl[58])
.save v(ldwl[57])
.save v(ldwl[56])
.save v(ldwl[55])
.save v(ldwl[54])
.save v(ldwl[53])
.save v(ldwl[52])
.save v(ldwl[51])
.save v(ldwl[50])
.save v(ldwl[49])
.save v(ldwl[48])
.save v(ldwl[47])
.save v(ldwl[46])
.save v(ldwl[45])
.save v(ldwl[44])
.save v(ldwl[43])
.save v(ldwl[42])
.save v(ldwl[41])
.save v(ldwl[40])
.save v(ldwl[39])
.save v(ldwl[38])
.save v(ldwl[37])
.save v(ldwl[36])
.save v(ldwl[35])
.save v(ldwl[34])
.save v(ldwl[33])
.save v(ldwl[32])
.save v(ldwl[31])
.save v(ldwl[30])
.save v(ldwl[29])
.save v(ldwl[28])
.save v(ldwl[27])
.save v(ldwl[26])
.save v(ldwl[25])
.save v(ldwl[24])
.save v(ldwl[23])
.save v(ldwl[22])
.save v(ldwl[21])
.save v(ldwl[20])
.save v(ldwl[19])
.save v(ldwl[18])
.save v(ldwl[17])
.save v(ldwl[16])
.save v(ldwl[15])
.save v(ldwl[14])
.save v(ldwl[13])
.save v(ldwl[12])
.save v(ldwl[11])
.save v(ldwl[10])
.save v(ldwl[9])
.save v(ldwl[8])
.save v(ldwl[7])
.save v(ldwl[6])
.save v(ldwl[5])
.save v(ldwl[4])
.save v(ldwl[3])
.save v(ldwl[2])
.save v(ldwl[1])
.save v(ldwl[0])
.save v(ldbl[0])
.save v(ldbl[16])
.save v(ldbl[32])
.save v(ldbl[1])
.save v(ldbl[17])
.save v(ldbl[33])
.save v(ldbl[2])
.save v(ldbl[18])
.save v(ldbl[34])
**** begin user architecture code



.options SCALE=0.10
.param VCC=1.5
.temp 25
.param WPRECH=30u

vvss vss 0 0

** to generate following file:
** copy .../share/doc/xschem/rom8k/stimuli.rom8k to simulation directory
** then do 'Simulation->Utile Stimuli Editor (GUI)' and press 'Translate'
.include stimuli_rom8k.cir

* .op ALL  4n
*.dc vvcc 0 2 0.1
.control
  save tran i(vvcc) i(vsa) i(vl) i(vdec)
  tran 0.2n 480n uic
  write rom8k_ngspice.raw
  acct
.endc

** download models from here:
** http://www.amarketplaceofideas.com/wp-content/uploads/2014/11/180nm-V1.7z
** and save to 'models_rom8k.txt' in simulation directory
.include models_rom8k.txt







.options SCALE=0.10
.param VCC=1.5
.temp 25
.param WPRECH=30u

vvss vss 0 0

** to generate following file:
** copy .../share/doc/xschem/rom8k/stimuli.rom8k to simulation directory
** then do 'Simulation->Utile Stimuli Editor (GUI)' and press 'Translate'
.include stimuli_rom8k.cir

* .op ALL  4n
*.dc vvcc 0 2 0.1
.save tran i(vvcc) i(vsa) i(vl) i(vdec)
.tran 0.2n 480n uic

** download models from here:
** http://www.amarketplaceofideas.com/wp-content/uploads/2014/11/180nm-V1.7z
** and save to 'models_rom8k.txt' in simulation directory
.include models_rom8k.txt




**** end user architecture code
**.ends
.end
