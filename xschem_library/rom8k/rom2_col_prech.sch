v {xschem version=2.9.5_RC6 file_version=1.1}
G {}
V {}
S {}
E {}
N 370 -360 370 -300 {lab=LDBL}
N 370 -440 370 -420 {lab=vss}
C {iopin.sym} 600 -180 0 0 {name=p1 lab=LDBL}
C {lab_pin.sym} 330 -390 0 0 {name=p711 lab=LDPRECH}
C {title.sym} 160 0 0 0 {name=l3 author="Stefan Schippers"}
C {lab_pin.sym} 370 -300 0 0 {name=p5 lab=LDBL}
C {lab_pin.sym} 370 -440 0 0 {name=p2 lab=vss}
C {nlv.sym} 350 -390 0 0 {name=m0 model=cmosn w=6u l=2.4u m=1
}
C {ipin.sym} 430 -200 0 0 {name=p6 lab=LDPRECH}
C {ipin.sym} 430 -160 0 0 {name=p7 lab=vss}
