v {xschem version=2.9.5_RC6 file_version=1.1}
G {}
V {}
S {}
E {}
C {10K10LC84-1.sym} 2000 0 0 0 {}
C {12SA7-1.sym} 4000 0 0 0 {}
C {12SK7-1.sym} 6000 0 0 0 {}
C {12SQ7-1.sym} 8000 0 0 0 {}
C {12V-minus-1.sym} 10000 0 0 0 {}
C {12V-plus-1.sym} 12000 0 0 0 {}
C {22V10-DIP-1.sym} 14000 0 0 0 {}
C {22V10-PLCC.sym} 16000 0 0 0 {}
C {24Cxx-1.sym} 18000 0 0 0 {}
C {25Cxx-1.sym} 20000 0 0 0 {}
C {27256-1.sym} 22000 0 0 0 {}
C {2732-1.sym} 24000 0 0 0 {}
C {27512-1.sym} 26000 0 0 0 {}
C {27C2001-1.sym} 28000 0 0 0 {}
C {27C256-1.sym} 30000 0 0 0 {}
C {2N2222-1.sym} 32000 0 0 0 {}
C {2N3055-1.sym} 34000 0 0 0 {}
C {2N3904-1.sym} 36000 0 0 0 {}
C {2N3904-2.sym} 38000 0 0 0 {}
C {2N3906-1.sym} 40000 0 0 0 {}
C {2N5245-1.sym} 42000 0 0 0 {}
C {2N5911-1.sym} 44000 0 0 0 {}
C {2phase-stepper-1.sym} 46000 0 0 0 {}
C {2S2K3-1.sym} 48000 0 0 0 {}
C {2tri-1.sym} 50000 0 0 0 {}
C {31-71043-1.sym} 52000 0 0 0 {}
C {3.3V-plus-1.sym} 54000 0 0 0 {}
C {35Z5GT-1.sym} 56000 0 0 0 {}
C {3967-1.sym} 58000 0 0 0 {}
C {3967-2.sym} 0 2000 0 0 {}
C {3tri-1.sym} 2000 2000 0 0 {}
C {4000-1.sym} 4000 2000 0 0 {}
C {4000-2.sym} 6000 2000 0 0 {}
C {4001-1.sym} 8000 2000 0 0 {}
C {4002-1.sym} 10000 2000 0 0 {}
C {4002-2.sym} 12000 2000 0 0 {}
C {4006-1.sym} 14000 2000 0 0 {}
C {4006-2.sym} 16000 2000 0 0 {}
C {4007-1.sym} 18000 2000 0 0 {}
C {4008-1.sym} 20000 2000 0 0 {}
C {4008-2.sym} 22000 2000 0 0 {}
C {4009-1.sym} 24000 2000 0 0 {}
C {40100-1.sym} 26000 2000 0 0 {}
C {40101-1.sym} 28000 2000 0 0 {}
C {4010-1.sym} 30000 2000 0 0 {}
C {40102-1.sym} 32000 2000 0 0 {}
C {40103-1.sym} 34000 2000 0 0 {}
C {40104-1.sym} 36000 2000 0 0 {}
C {40105-1.sym} 38000 2000 0 0 {}
C {40106-1.sym} 40000 2000 0 0 {}
C {40107-1.sym} 42000 2000 0 0 {}
C {40108-1.sym} 44000 2000 0 0 {}
C {40109-1.sym} 46000 2000 0 0 {}
C {40110-1.sym} 48000 2000 0 0 {}
C {4011-1.sym} 50000 2000 0 0 {}
C {4011-2.sym} 52000 2000 0 0 {}
C {40117-1.sym} 54000 2000 0 0 {}
C {4012-1.sym} 56000 2000 0 0 {}
C {4013-1.sym} 58000 2000 0 0 {}
C {4014-1.sym} 0 4000 0 0 {}
C {4014-2.sym} 2000 4000 0 0 {}
C {40147-1.sym} 4000 4000 0 0 {}
C {4015-1.sym} 6000 4000 0 0 {}
C {40160-1.sym} 8000 4000 0 0 {}
C {40161-1.sym} 10000 4000 0 0 {}
C {4016-1.sym} 12000 4000 0 0 {}
C {40162-1.sym} 14000 4000 0 0 {}
C {4016-2.sym} 16000 4000 0 0 {}
C {40163-1.sym} 18000 4000 0 0 {}
C {4017-1.sym} 20000 4000 0 0 {}
C {4017-2.sym} 22000 4000 0 0 {}
C {40174-1.sym} 24000 4000 0 0 {}
C {40175-1.sym} 26000 4000 0 0 {}
C {40181-1.sym} 28000 4000 0 0 {}
C {4018-1.sym} 30000 4000 0 0 {}
C {40182-1.sym} 32000 4000 0 0 {}
C {4018-2.sym} 34000 4000 0 0 {}
C {4019-1.sym} 36000 4000 0 0 {}
C {40192-1.sym} 38000 4000 0 0 {}
C {4019-2.sym} 40000 4000 0 0 {}
C {40193-1.sym} 42000 4000 0 0 {}
C {40194-1.sym} 44000 4000 0 0 {}
C {40195-1.sym} 46000 4000 0 0 {}
C {4020-1.sym} 48000 4000 0 0 {}
C {40208-1.sym} 50000 4000 0 0 {}
C {4021-1.sym} 52000 4000 0 0 {}
C {4021-2.sym} 54000 4000 0 0 {}
C {4021-3.sym} 56000 4000 0 0 {}
C {4022-1.sym} 58000 4000 0 0 {}
C {4022-2.sym} 0 6000 0 0 {}
C {4023-1.sym} 2000 6000 0 0 {}
C {40240-1.sym} 4000 6000 0 0 {}
C {4024-1.sym} 6000 6000 0 0 {}
C {40244-1.sym} 8000 6000 0 0 {}
C {40245-1.sym} 10000 6000 0 0 {}
C {4025-1.sym} 12000 6000 0 0 {}
C {40257-1.sym} 14000 6000 0 0 {}
C {4026-1.sym} 16000 6000 0 0 {}
C {4027-1.sym} 18000 6000 0 0 {}
C {4028-1.sym} 20000 6000 0 0 {}
C {4028-2.sym} 22000 6000 0 0 {}
C {4029-1.sym} 24000 6000 0 0 {}
C {4030-1.sym} 26000 6000 0 0 {}
C {4031-1.sym} 28000 6000 0 0 {}
C {4032-1.sym} 30000 6000 0 0 {}
C {4032-2.sym} 32000 6000 0 0 {}
C {4033-1.sym} 34000 6000 0 0 {}
C {4033-2.sym} 36000 6000 0 0 {}
C {4034-1.sym} 38000 6000 0 0 {}
C {4035-1.sym} 40000 6000 0 0 {}
C {4035-2.sym} 42000 6000 0 0 {}
C {40373-1.sym} 44000 6000 0 0 {}
C {40374-1.sym} 46000 6000 0 0 {}
C {4038-1.sym} 48000 6000 0 0 {}
C {4038-2.sym} 50000 6000 0 0 {}
C {4040-1.sym} 52000 6000 0 0 {}
C {4041-1.sym} 54000 6000 0 0 {}
C {4042-1.sym} 56000 6000 0 0 {}
C {4042-2.sym} 58000 6000 0 0 {}
C {4043-1.sym} 0 8000 0 0 {}
C {4043-2.sym} 2000 8000 0 0 {}
C {4044-1.sym} 4000 8000 0 0 {}
C {4044-2.sym} 6000 8000 0 0 {}
C {4045-1.sym} 8000 8000 0 0 {}
C {4046-1.sym} 10000 8000 0 0 {}
C {4047-1.sym} 12000 8000 0 0 {}
C {4048-1.sym} 14000 8000 0 0 {}
C {4049-1.sym} 16000 8000 0 0 {}
C {4050-1.sym} 18000 8000 0 0 {}
C {4051-1.sym} 20000 8000 0 0 {}
C {4052-1.sym} 22000 8000 0 0 {}
C {4053-1.sym} 24000 8000 0 0 {}
C {4053-2.sym} 26000 8000 0 0 {}
C {4054-1.sym} 28000 8000 0 0 {}
C {4055-1.sym} 30000 8000 0 0 {}
C {4056-1.sym} 32000 8000 0 0 {}
C {4059-1.sym} 34000 8000 0 0 {}
C {4060-1.sym} 36000 8000 0 0 {}
C {4060-2.sym} 38000 8000 0 0 {}
C {4061-1.sym} 40000 8000 0 0 {}
C {4062-1.sym} 42000 8000 0 0 {}
C {4063-1.sym} 44000 8000 0 0 {}
C {4066-1.sym} 46000 8000 0 0 {}
C {4066-2.sym} 48000 8000 0 0 {}
C {4067-1.sym} 50000 8000 0 0 {}
C {4067-2.sym} 52000 8000 0 0 {}
C {4068-1.sym} 54000 8000 0 0 {}
C {4068-2.sym} 56000 8000 0 0 {}
C {4069-1.sym} 58000 8000 0 0 {}
C {4069-2.sym} 0 10000 0 0 {}
C {4069-3.sym} 2000 10000 0 0 {}
C {4070-1.sym} 4000 10000 0 0 {}
C {4071-1.sym} 6000 10000 0 0 {}
C {4072-1.sym} 8000 10000 0 0 {}
C {4072-2.sym} 10000 10000 0 0 {}
C {4073-1.sym} 12000 10000 0 0 {}
C {4073-2.sym} 14000 10000 0 0 {}
C {4075-1.sym} 16000 10000 0 0 {}
C {4075-2.sym} 18000 10000 0 0 {}
C {4076-1.sym} 20000 10000 0 0 {}
C {4077-1.sym} 22000 10000 0 0 {}
C {4078-1.sym} 24000 10000 0 0 {}
C {4078-2.sym} 26000 10000 0 0 {}
C {4081-1.sym} 28000 10000 0 0 {}
C {4082-1.sym} 30000 10000 0 0 {}
C {4082-2.sym} 32000 10000 0 0 {}
C {4085-1.sym} 34000 10000 0 0 {}
C {4086-1.sym} 36000 10000 0 0 {}
C {4089-1.sym} 38000 10000 0 0 {}
C {4093-1.sym} 40000 10000 0 0 {}
C {4094-1.sym} 42000 10000 0 0 {}
C {4094-2.sym} 44000 10000 0 0 {}
C {4095-1.sym} 46000 10000 0 0 {}
C {4096-1.sym} 48000 10000 0 0 {}
C {4097-1.sym} 50000 10000 0 0 {}
C {4098-1.sym} 52000 10000 0 0 {}
C {4099-1.sym} 54000 10000 0 0 {}
C {4164-1.sym} 56000 10000 0 0 {}
C {4316-1.sym} 58000 10000 0 0 {}
C {4352-1.sym} 0 12000 0 0 {}
C {4353-1.sym} 2000 12000 0 0 {}
C {4501-1.sym} 4000 12000 0 0 {}
C {4502-1.sym} 6000 12000 0 0 {}
C {4503-1.sym} 8000 12000 0 0 {}
C {4504-1.sym} 10000 12000 0 0 {}
C {4508-1.sym} 12000 12000 0 0 {}
C {4510-1.sym} 14000 12000 0 0 {}
C {4511-1.sym} 16000 12000 0 0 {}
C {4512-1.sym} 18000 12000 0 0 {}
C {4513-1.sym} 20000 12000 0 0 {}
C {4514-1.sym} 22000 12000 0 0 {}
C {4515-1.sym} 24000 12000 0 0 {}
C {4516-1.sym} 26000 12000 0 0 {}
C {4517-1.sym} 28000 12000 0 0 {}
C {4518-1.sym} 30000 12000 0 0 {}
C {4520-1.sym} 32000 12000 0 0 {}
C {4521-1.sym} 34000 12000 0 0 {}
C {4522-1.sym} 36000 12000 0 0 {}
C {4527-1.sym} 38000 12000 0 0 {}
C {4528-1.sym} 40000 12000 0 0 {}
C {4531-1.sym} 42000 12000 0 0 {}
C {4532-1.sym} 44000 12000 0 0 {}
C {4534-1.sym} 46000 12000 0 0 {}
C {4536-1.sym} 48000 12000 0 0 {}
C {4538-1.sym} 50000 12000 0 0 {}
C {4541-1.sym} 52000 12000 0 0 {}
C {4543-1.sym} 54000 12000 0 0 {}
C {4555-1.sym} 56000 12000 0 0 {}
C {4556-1.sym} 58000 12000 0 0 {}
C {4572-1.sym} 0 14000 0 0 {}
C {4580-1.sym} 2000 14000 0 0 {}
C {4582-1.sym} 4000 14000 0 0 {}
C {4585-1.sym} 6000 14000 0 0 {}
C {4723-1.sym} 8000 14000 0 0 {}
C {4724-1.sym} 10000 14000 0 0 {}
C {4737-1.sym} 12000 14000 0 0 {}
C {4N25-1.sym} 14000 14000 0 0 {}
C {4N29-1.sym} 16000 14000 0 0 {}
C {4phase-stepper6-1.sym} 18000 14000 0 0 {}
C {4phase-stepper8-1.sym} 20000 14000 0 0 {}
C {50L6GT-1.sym} 22000 14000 0 0 {}
C {581000-1.sym} 24000 14000 0 0 {}
C {5V-minus-1.sym} 26000 14000 0 0 {}
C {5V-plus-1.sym} 28000 14000 0 0 {}
C {62256-1.sym} 30000 14000 0 0 {}
C {62256-2.sym} 32000 14000 0 0 {}
C {628512-1.sym} 34000 14000 0 0 {}
C {6821-1.sym} 36000 14000 0 0 {}
C {6821-2.sym} 38000 14000 0 0 {}
C {6A259-1.sym} 40000 14000 0 0 {}
C {6N135-1.sym} 42000 14000 0 0 {}
C {6N136-1.sym} 44000 14000 0 0 {}
C {6n137-1.sym} 46000 14000 0 0 {}
C {7400-1.sym} 48000 14000 0 0 {}
C {7400-2.sym} 50000 14000 0 0 {}
C {7401-1.sym} 52000 14000 0 0 {}
C {7401-2.sym} 54000 14000 0 0 {}
C {7402-1.sym} 56000 14000 0 0 {}
C {7402-2.sym} 58000 14000 0 0 {}
C {7403-1.sym} 0 16000 0 0 {}
C {7403-2.sym} 2000 16000 0 0 {}
C {7404-1.sym} 4000 16000 0 0 {}
C {7404-2.sym} 6000 16000 0 0 {}
C {7404-3.sym} 8000 16000 0 0 {}
C {7404-4.sym} 10000 16000 0 0 {}
C {7405-1.sym} 12000 16000 0 0 {}
C {7405-2.sym} 14000 16000 0 0 {}
C {7407-1.sym} 16000 16000 0 0 {}
C {7408-1.sym} 18000 16000 0 0 {}
C {7408-2.sym} 20000 16000 0 0 {}
C {7409-1.sym} 22000 16000 0 0 {}
C {7409-2.sym} 24000 16000 0 0 {}
C {7410-1.sym} 26000 16000 0 0 {}
C {7410-2.sym} 28000 16000 0 0 {}
C {74107-1.sym} 30000 16000 0 0 {}
C {74107-2.sym} 32000 16000 0 0 {}
C {74109-1.sym} 34000 16000 0 0 {}
C {74109-2.sym} 36000 16000 0 0 {}
C {7411-1.sym} 38000 16000 0 0 {}
C {74112-1.sym} 40000 16000 0 0 {}
C {7411-2.sym} 42000 16000 0 0 {}
C {74113-1.sym} 44000 16000 0 0 {}
C {74114-1.sym} 46000 16000 0 0 {}
C {74121-1.sym} 48000 16000 0 0 {}
C {7412-1.sym} 50000 16000 0 0 {}
C {74122-1.sym} 52000 16000 0 0 {}
C {7412-2.sym} 54000 16000 0 0 {}
C {74123-1.sym} 56000 16000 0 0 {}
C {74123-2.sym} 58000 16000 0 0 {}
C {74123-3.sym} 0 18000 0 0 {}
C {74124-1.sym} 2000 18000 0 0 {}
C {74124-2.sym} 4000 18000 0 0 {}
C {74125-1.sym} 6000 18000 0 0 {}
C {74126-1.sym} 8000 18000 0 0 {}
C {74131-1.sym} 10000 18000 0 0 {}
C {74132-1.sym} 12000 18000 0 0 {}
C {74133-1.sym} 14000 18000 0 0 {}
C {74133-2.sym} 16000 18000 0 0 {}
C {74137-1.sym} 18000 18000 0 0 {}
C {74138-1.sym} 20000 18000 0 0 {}
C {74138-2.sym} 22000 18000 0 0 {}
C {74139-1.sym} 24000 18000 0 0 {}
C {74139-2.sym} 26000 18000 0 0 {}
C {74139-3.sym} 28000 18000 0 0 {}
C {74141-1.sym} 30000 18000 0 0 {}
C {7414-1.sym} 32000 18000 0 0 {}
C {7414-2.sym} 34000 18000 0 0 {}
C {74145-1.sym} 36000 18000 0 0 {}
C {74147-1.sym} 38000 18000 0 0 {}
C {74148-1.sym} 40000 18000 0 0 {}
C {74150-1.sym} 42000 18000 0 0 {}
C {74151-1.sym} 44000 18000 0 0 {}
C {74151-2.sym} 46000 18000 0 0 {}
C {7415-1.sym} 48000 18000 0 0 {}
C {74152-1.sym} 50000 18000 0 0 {}
C {7415-2.sym} 52000 18000 0 0 {}
C {74153-1.sym} 54000 18000 0 0 {}
C {74153-2.sym} 56000 18000 0 0 {}
C {74154-1.sym} 58000 18000 0 0 {}
C {74154-2.sym} 0 20000 0 0 {}
C {74157-1.sym} 2000 20000 0 0 {}
C {74158-1.sym} 4000 20000 0 0 {}
C {74159-1.sym} 6000 20000 0 0 {}
C {74160-1.sym} 8000 20000 0 0 {}
C {74161-1.sym} 10000 20000 0 0 {}
C {74161-2.sym} 12000 20000 0 0 {}
C {74162-1.sym} 14000 20000 0 0 {}
C {74163-1.sym} 16000 20000 0 0 {}
C {74164-1.sym} 18000 20000 0 0 {}
C {74164-2.sym} 20000 20000 0 0 {}
C {74165-1.sym} 22000 20000 0 0 {}
C {74166-1.sym} 24000 20000 0 0 {}
C {74168-1.sym} 26000 20000 0 0 {}
C {74169-1.sym} 28000 20000 0 0 {}
C {74170-1.sym} 30000 20000 0 0 {}
C {74173-1.sym} 32000 20000 0 0 {}
C {74175-1.sym} 34000 20000 0 0 {}
C {74181-1.sym} 36000 20000 0 0 {}
C {74182-1.sym} 38000 20000 0 0 {}
C {74189-1.sym} 40000 20000 0 0 {}
C {74189-2.sym} 42000 20000 0 0 {}
C {74190-1.sym} 44000 20000 0 0 {}
C {74191-1.sym} 46000 20000 0 0 {}
C {74191-2.sym} 48000 20000 0 0 {}
C {74192-1.sym} 50000 20000 0 0 {}
C {74193-1.sym} 52000 20000 0 0 {}
C {74194-1.sym} 54000 20000 0 0 {}
C {74195-1.sym} 56000 20000 0 0 {}
C {74196-1.sym} 58000 20000 0 0 {}
C {74197-1.sym} 0 22000 0 0 {}
C {7420-1.sym} 2000 22000 0 0 {}
C {7420-2.sym} 4000 22000 0 0 {}
C {7421-1.sym} 6000 22000 0 0 {}
C {7421-2.sym} 8000 22000 0 0 {}
C {7422-1.sym} 10000 22000 0 0 {}
C {7422-2.sym} 12000 22000 0 0 {}
C {74238-1.sym} 14000 22000 0 0 {}
C {74240-1.sym} 16000 22000 0 0 {}
C {74243-1.sym} 18000 22000 0 0 {}
C {74244-1.sym} 20000 22000 0 0 {}
C {74244-2.sym} 22000 22000 0 0 {}
C {74245-1.sym} 24000 22000 0 0 {}
C {74257-1.sym} 26000 22000 0 0 {}
C {74259-1.sym} 28000 22000 0 0 {}
C {74265-1.sym} 30000 22000 0 0 {}
C {74265-2.sym} 32000 22000 0 0 {}
C {74266-1.sym} 34000 22000 0 0 {}
C {7427-1.sym} 36000 22000 0 0 {}
C {74273-1.sym} 38000 22000 0 0 {}
C {74280-1.sym} 40000 22000 0 0 {}
C {74283-1.sym} 42000 22000 0 0 {}
C {74299-1.sym} 44000 22000 0 0 {}
C {7430-1.sym} 46000 22000 0 0 {}
C {7430-2.sym} 48000 22000 0 0 {}
C {7431-1.sym} 50000 22000 0 0 {}
C {7432-1.sym} 52000 22000 0 0 {}
C {7432-2.sym} 54000 22000 0 0 {}
C {7432-3.sym} 56000 22000 0 0 {}
C {74367-1.sym} 58000 22000 0 0 {}
C {74373-1.sym} 0 24000 0 0 {}
C {74374-1.sym} 2000 24000 0 0 {}
C {74377-1.sym} 4000 24000 0 0 {}
C {74379-1.sym} 6000 24000 0 0 {}
C {74393-1.sym} 8000 24000 0 0 {}
C {7442-1.sym} 10000 24000 0 0 {}
C {7445-1.sym} 12000 24000 0 0 {}
C {7446-1.sym} 14000 24000 0 0 {}
C {7447-1.sym} 16000 24000 0 0 {}
C {7448-1.sym} 18000 24000 0 0 {}
C {7451-1.sym} 20000 24000 0 0 {}
C {74520-1.sym} 22000 24000 0 0 {}
C {74520-2.sym} 24000 24000 0 0 {}
C {74520-3.sym} 26000 24000 0 0 {}
C {74541-1.sym} 28000 24000 0 0 {}
C {7454-1.sym} 30000 24000 0 0 {}
C {7455-1.sym} 32000 24000 0 0 {}
C {7456-1.sym} 34000 24000 0 0 {}
C {7457-1.sym} 36000 24000 0 0 {}
C {74573-1.sym} 38000 24000 0 0 {}
C {74574-1.sym} 40000 24000 0 0 {}
C {74595-1.sym} 42000 24000 0 0 {}
C {74673A-1.sym} 44000 24000 0 0 {}
C {74673A-2.sym} 46000 24000 0 0 {}
C {74684-1.sym} 48000 24000 0 0 {}
C {74688-1.sym} 50000 24000 0 0 {}
C {74688-2.sym} 52000 24000 0 0 {}
C {7472-1.sym} 54000 24000 0 0 {}
C {7473-1.sym} 56000 24000 0 0 {}
C {7474-1.sym} 58000 24000 0 0 {}
C {7474-2.sym} 0 26000 0 0 {}
C {7474-3.sym} 2000 26000 0 0 {}
C {7475-1.sym} 4000 26000 0 0 {}
C {7476-1.sym} 6000 26000 0 0 {}
C {7478-1.sym} 8000 26000 0 0 {}
C {7483-1.sym} 10000 26000 0 0 {}
C {7485-1.sym} 12000 26000 0 0 {}
C {7486-1.sym} 14000 26000 0 0 {}
C {7490-1.sym} 16000 26000 0 0 {}
C {7491-1.sym} 18000 26000 0 0 {}
C {7492-1.sym} 20000 26000 0 0 {}
C {7493-1.sym} 22000 26000 0 0 {}
C {7495-1.sym} 24000 26000 0 0 {}
C {7495-2.sym} 26000 26000 0 0 {}
C {7496-1.sym} 28000 26000 0 0 {}
C {7497-1.sym} 30000 26000 0 0 {}
C {7497-2.sym} 32000 26000 0 0 {}
C {74HC244-1.sym} 34000 26000 0 0 {}
C {74HC244-2.sym} 36000 26000 0 0 {}
C {74HC373-1.sym} 38000 26000 0 0 {}
C {74HC374-1.sym} 40000 26000 0 0 {}
C {74HCT01-1.sym} 42000 26000 0 0 {}
C {74HCT03-1.sym} 44000 26000 0 0 {}
C {74HCT05-1.sym} 46000 26000 0 0 {}
C {74HCT08-1.sym} 48000 26000 0 0 {}
C {74HCT245-1.sym} 50000 26000 0 0 {}
C {74HCT4094-1.sym} 52000 26000 0 0 {}
C {74HCT541-1.sym} 54000 26000 0 0 {}
C {74power-1.sym} 56000 26000 0 0 {}
C {75176-1.sym} 58000 26000 0 0 {}
C {8031.sym} 0 28000 0 0 {}
C {8052basic-1.sym} 2000 28000 0 0 {}
C {8086-1.sym} 4000 28000 0 0 {}
C {8088-1.sym} 6000 28000 0 0 {}
C {810-1.sym} 8000 28000 0 0 {}
C {8254-1.sym} 10000 28000 0 0 {}
C {8255A-1.sym} 12000 28000 0 0 {}
C {8259A-1.sym} 14000 28000 0 0 {}
C {93Cx6-1.sym} 16000 28000 0 0 {}
C {9602-1.sym} 18000 28000 0 0 {}
C {9602-2.sym} 20000 28000 0 0 {}
C {9V-minus-1.sym} 22000 28000 0 0 {}
C {9V-plus-1.sym} 24000 28000 0 0 {}
C {ac-ac.sym} 26000 28000 0 0 {}
C {ac-dc.sym} 28000 28000 0 0 {}
C {ACE1202-1.sym} 30000 28000 0 0 {}
C {ad633JN-1.sym} 32000 28000 0 0 {}
C {ad633JN-2.sym} 34000 28000 0 0 {}
C {ad633JR-1.sym} 36000 28000 0 0 {}
C {ADC0804-1.sym} 38000 28000 0 0 {}
C {adc0820-1.sym} 40000 28000 0 0 {}
C {ADC0831-1.sym} 42000 28000 0 0 {}
C {adc.sym} 44000 28000 0 0 {}
C {ADG601-1.sym} 46000 28000 0 0 {}
C {ADG602-1.sym} 48000 28000 0 0 {}
C {ADG619-1.sym} 50000 28000 0 0 {}
C {ADG620-1.sym} 52000 28000 0 0 {}
C {adm202-1.sym} 54000 28000 0 0 {}
C {adm202-2.sym} 56000 28000 0 0 {}
C {adm707.sym} 58000 28000 0 0 {}
C {ADT1-1WT-1.sym} 0 30000 0 0 {}
C {ADT1-1WT-2.sym} 2000 30000 0 0 {}
C {aerial.sym} 4000 30000 0 0 {}
C {af_output_transformer-1.sym} 6000 30000 0 0 {}
C {am27S13D-1.sym} 8000 30000 0 0 {}
C {am9128-1.sym} 10000 30000 0 0 {}
C {amp-bidir.sym} 12000 30000 0 0 {}
C {amp-diff.sym} 14000 30000 0 0 {}
C {amp-step.sym} 16000 30000 0 0 {}
C {amp.sym} 18000 30000 0 0 {}
C {amp-trim.sym} 20000 30000 0 0 {}
C {amp-var.sym} 22000 30000 0 0 {}
C {AN82527.sym} 24000 30000 0 0 {}
C {aop-spice-1.sym} 26000 30000 0 0 {}
C {aop-std-1.sym} 28000 30000 0 0 {}
C {arfx1229-1.sym} 30000 30000 0 0 {}
C {aromat-tq4.sym} 32000 30000 0 0 {}
C {arrow.sym} 34000 30000 0 0 {}
C {asic-cap-1.sym} 36000 30000 0 0 {}
C {asic-cap-2.sym} 38000 30000 0 0 {}
C {asic-cap-3.sym} 40000 30000 0 0 {}
C {asic-diode-1.sym} 42000 30000 0 0 {}
C {asic-nhhv-1.sym} 44000 30000 0 0 {}
C {asic-nhv-1.sym} 46000 30000 0 0 {}
C {asic-nmmv-1.sym} 48000 30000 0 0 {}
C {asic-nmos-1.sym} 50000 30000 0 0 {}
C {asic-nmv-1.sym} 52000 30000 0 0 {}
C {asic-phhv-1.sym} 54000 30000 0 0 {}
C {asic-phv-1.sym} 56000 30000 0 0 {}
C {asic-pmmv-1.sym} 58000 30000 0 0 {}
C {asic-pmos-1.sym} 0 32000 0 0 {}
C {asic-pmv-1.sym} 2000 32000 0 0 {}
C {asic-res-1.sym} 4000 32000 0 0 {}
C {asic-res-2.sym} 6000 32000 0 0 {}
C {asic-res-3.sym} 8000 32000 0 0 {}
C {asic-res-4.sym} 10000 32000 0 0 {}
C {at-1xx.sym} 12000 32000 0 0 {}
C {AT43USB320A.sym} 14000 32000 0 0 {}
C {AT45db021bso8w-1.sym} 16000 32000 0 0 {}
C {AT89C2051-1.sym} 18000 32000 0 0 {}
C {AT89C5131_PLCC-1.sym} 20000 32000 0 0 {}
C {AT89C5132_TQFP-1.sym} 22000 32000 0 0 {}
C {AT89C51_DIP.sym} 24000 32000 0 0 {}
C {AT89C51_PLCC.sym} 26000 32000 0 0 {}
C {AT89C51_TQFP.sym} 28000 32000 0 0 {}
C {AT89S53-24PI-1.sym} 30000 32000 0 0 {}
C {AT89S8252-24PC-1.sym} 32000 32000 0 0 {}
C {AT90S1200.sym} 34000 32000 0 0 {}
C {AT90S2313.sym} 36000 32000 0 0 {}
C {AT90S2323.sym} 38000 32000 0 0 {}
C {AT90S2343.sym} 40000 32000 0 0 {}
C {AT90S4433_DIP.sym} 42000 32000 0 0 {}
C {AT90S4433_TQFP.sym} 44000 32000 0 0 {}
C {AT90S8515_DIP.sym} 46000 32000 0 0 {}
C {AT90S8515_PLCC.sym} 48000 32000 0 0 {}
C {AT90S8515_TQFP.sym} 50000 32000 0 0 {}
C {AT90S8535_DIP.sym} 52000 32000 0 0 {}
C {AT90S8535J-1.sym} 54000 32000 0 0 {}
C {AT90S8535P-1.sym} 56000 32000 0 0 {}
C {AT90S8535_PLCC.sym} 58000 32000 0 0 {}
C {AT90S8535.sym} 0 34000 0 0 {}
C {AT90S8535_TQFP.sym} 2000 34000 0 0 {}
C {ATmega103.sym} 4000 34000 0 0 {}
C {ATmega128-1.sym} 6000 34000 0 0 {}
C {ATmega128-2.sym} 8000 34000 0 0 {}
C {ATmega128-3.sym} 10000 34000 0 0 {}
C {ATmega161_DIP.sym} 12000 34000 0 0 {}
C {ATmega161_TQFP.sym} 14000 34000 0 0 {}
C {ATmega163_DIP.sym} 16000 34000 0 0 {}
C {ATmega163_TQFP.sym} 18000 34000 0 0 {}
C {ATmega16_DIP-1.sym} 20000 34000 0 0 {}
C {ATmega16L-1.sym} 22000 34000 0 0 {}
C {ATmega323-1.sym} 24000 34000 0 0 {}
C {ATmega32MLF-1.sym} 26000 34000 0 0 {}
C {ATmega64-1.sym} 28000 34000 0 0 {}
C {ATmega8-1.sym} 30000 34000 0 0 {}
C {atten-step.sym} 32000 34000 0 0 {}
C {atten.sym} 34000 34000 0 0 {}
C {atten-trim.sym} 36000 34000 0 0 {}
C {attenuator-1.sym} 38000 34000 0 0 {}
C {atten-var.sym} 40000 34000 0 0 {}
C {ATtiny11.sym} 42000 34000 0 0 {}
C {ATtiny12.sym} 44000 34000 0 0 {}
C {ATtiny15L-1.sym} 46000 34000 0 0 {}
C {ATtiny28_DIP.sym} 48000 34000 0 0 {}
C {ATtiny28_TQFP.sym} 50000 34000 0 0 {}
C {aui-1.sym} 52000 34000 0 0 {}
C {bandpass-step.sym} 54000 34000 0 0 {}
C {bandpass.sym} 56000 34000 0 0 {}
C {bandpass-trim.sym} 58000 34000 0 0 {}
C {bandpass-var.sym} 0 36000 0 0 {}
C {bandstop-step.sym} 2000 36000 0 0 {}
C {bandstop.sym} 4000 36000 0 0 {}
C {bandstop-trim.sym} 6000 36000 0 0 {}
C {bandstop-var.sym} 8000 36000 0 0 {}
C {basicstamp-1.sym} 10000 36000 0 0 {}
C {battery-1.sym} 12000 36000 0 0 {}
C {battery-2.sym} 14000 36000 0 0 {}
C {battery-3.sym} 16000 36000 0 0 {}
C {bav70lt1-1.sym} 18000 36000 0 0 {}
C {BC182-1.sym} 20000 36000 0 0 {}
C {BC307-1.sym} 22000 36000 0 0 {}
C {BC547-1.sym} 24000 36000 0 0 {}
C {BC547-2.sym} 26000 36000 0 0 {}
C {BC547-3.sym} 28000 36000 0 0 {}
C {BC557-1.sym} 30000 36000 0 0 {}
C {BC557-2.sym} 32000 36000 0 0 {}
C {beeper-1.sym} 34000 36000 0 0 {}
C {block-convert.sym} 36000 36000 0 0 {}
C {block.sym} 38000 36000 0 0 {}
C {BNC-1.sym} 40000 36000 0 0 {}
C {bridge-1.sym} 42000 36000 0 0 {}
C {bridge-2.sym} 44000 36000 0 0 {}
C {busripper-1.sym} 46000 36000 0 0 {}
C {busripper-2.sym} 48000 36000 0 0 {}
C {capacitor-1.sym} 50000 36000 0 0 {}
C {capacitor-2.sym} 52000 36000 0 0 {}
C {capacitor-3.sym} 54000 36000 0 0 {}
C {capacitor-4.sym} 56000 36000 0 0 {}
C {capacitor-variable-1.sym} 58000 36000 0 0 {}
C {capacitor-variable-2.sym} 0 38000 0 0 {}
C {cascade-amp-1.sym} 2000 38000 0 0 {}
C {cascade-defaults-1.sym} 4000 38000 0 0 {}
C {cascade-defaults-2.sym} 6000 38000 0 0 {}
C {cascade-filter-1.sym} 8000 38000 0 0 {}
C {cascade-mixer-1.sym} 10000 38000 0 0 {}
C {cascade-source-1.sym} 12000 38000 0 0 {}
C {cascade-source-2.sym} 14000 38000 0 0 {}
C {cascade-transformer-1.sym} 16000 38000 0 0 {}
C {cccs-1.sym} 18000 38000 0 0 {}
C {ccvs-1.sym} 20000 38000 0 0 {}
C {chassis.sym} 22000 38000 0 0 {}
C {circulator.sym} 24000 38000 0 0 {}
C {CNY17-1.sym} 26000 38000 0 0 {}
C {coil-1.sym} 28000 38000 0 0 {}
C {coil-2.sym} 30000 38000 0 0 {}
C {combine-2.sym} 32000 38000 0 0 {}
C {combine-3.sym} 34000 38000 0 0 {}
C {combine-4.sym} 36000 38000 0 0 {}
C {common.sym} 38000 38000 0 0 {}
C {con2.sym} 40000 38000 0 0 {}
C {con-coaxial.sym} 42000 38000 0 0 {}
C {connector10-1.sym} 44000 38000 0 0 {}
C {connector10-2.sym} 46000 38000 0 0 {}
C {connector11-2.sym} 48000 38000 0 0 {}
C {connector12-1.sym} 50000 38000 0 0 {}
C {connector12-2.sym} 52000 38000 0 0 {}
C {connector1-2.sym} 54000 38000 0 0 {}
C {connector13-2.sym} 56000 38000 0 0 {}
C {connector14-2.sym} 58000 38000 0 0 {}
C {connector15-1.sym} 0 40000 0 0 {}
C {connector15-2.sym} 2000 40000 0 0 {}
C {connector16-1.sym} 4000 40000 0 0 {}
C {connector16-2.sym} 6000 40000 0 0 {}
C {connector17-2.sym} 8000 40000 0 0 {}
C {connector18-2.sym} 10000 40000 0 0 {}
C {connector19-1.sym} 12000 40000 0 0 {}
C {connector19-2.sym} 14000 40000 0 0 {}
C {connector20-1.sym} 16000 40000 0 0 {}
C {connector20-2.sym} 18000 40000 0 0 {}
C {connector21-2.sym} 20000 40000 0 0 {}
C {connector2-1.sym} 22000 40000 0 0 {}
C {connector22-2.sym} 24000 40000 0 0 {}
C {connector2-2.sym} 26000 40000 0 0 {}
C {connector23-2.sym} 28000 40000 0 0 {}
C {connector24-2.sym} 30000 40000 0 0 {}
C {connector25-2.sym} 32000 40000 0 0 {}
C {connector26-1.sym} 34000 40000 0 0 {}
C {connector26-2.sym} 36000 40000 0 0 {}
C {connector27-2.sym} 38000 40000 0 0 {}
C {connector28-2.sym} 40000 40000 0 0 {}
C {connector29-2.sym} 42000 40000 0 0 {}
C {connector30-2.sym} 44000 40000 0 0 {}
C {connector31-2.sym} 46000 40000 0 0 {}
C {connector3-1.sym} 48000 40000 0 0 {}
C {connector32-2.sym} 50000 40000 0 0 {}
C {connector3-2.sym} 52000 40000 0 0 {}
C {connector33-2.sym} 54000 40000 0 0 {}
C {connector34-2.sym} 56000 40000 0 0 {}
C {connector35-2.sym} 58000 40000 0 0 {}
C {connector36-2.sym} 0 42000 0 0 {}
C {connector37-2.sym} 2000 42000 0 0 {}
C {connector38-2.sym} 4000 42000 0 0 {}
C {connector39-2.sym} 6000 42000 0 0 {}
C {connector40-2.sym} 8000 42000 0 0 {}
C {connector41-1.sym} 10000 42000 0 0 {}
C {connector4-1.sym} 12000 42000 0 0 {}
C {connector4-2.sym} 14000 42000 0 0 {}
C {connector5-1.sym} 16000 42000 0 0 {}
C {connector5-2.sym} 18000 42000 0 0 {}
C {connector6-1.sym} 20000 42000 0 0 {}
C {connector6-2.sym} 22000 42000 0 0 {}
C {connector7-2.sym} 24000 42000 0 0 {}
C {connector8-1.sym} 26000 42000 0 0 {}
C {connector8-2.sym} 28000 42000 0 0 {}
C {connector9-1.sym} 30000 42000 0 0 {}
C {connector9-2.sym} 32000 42000 0 0 {}
C {corrector.sym} 34000 42000 0 0 {}
C {coupler-1.sym} 36000 42000 0 0 {}
C {coupler-dual.sym} 38000 42000 0 0 {}
C {coupler.sym} 40000 42000 0 0 {}
C {crystal-1.sym} 42000 42000 0 0 {}
C {CS5396-1.sym} 44000 42000 0 0 {}
C {current-1.sym} 46000 42000 0 0 {}
C {DAC0808-1.sym} 48000 42000 0 0 {}
C {dac08sm-1.sym} 50000 42000 0 0 {}
C {dac.sym} 52000 42000 0 0 {}
C {darlington_NPN-1.sym} 54000 42000 0 0 {}
C {darlington_NPN_PNP-1.sym} 56000 42000 0 0 {}
C {DB15-1.sym} 58000 42000 0 0 {}
C {DB25-1.sym} 0 44000 0 0 {}
C {DB25-2.sym} 2000 44000 0 0 {}
C {DB25-3.sym} 4000 44000 0 0 {}
C {DB31-1.sym} 6000 44000 0 0 {}
C {DB37-1.sym} 8000 44000 0 0 {}
C {DB9-1.sym} 10000 44000 0 0 {}
C {DB9-2.sym} 12000 44000 0 0 {}
C {DC003C-1.sym} 14000 44000 0 0 {}
C {DC004C-1.sym} 16000 44000 0 0 {}
C {DC310ES-1.sym} 18000 44000 0 0 {}
C {DC319-1.sym} 20000 44000 0 0 {}
C {DC331-1.sym} 22000 44000 0 0 {}
C {DC8640-1.sym} 24000 44000 0 0 {}
C {dc-ac.sym} 26000 44000 0 0 {}
C {dc-dc.sym} 28000 44000 0 0 {}
C {dc_motor-1.sym} 30000 44000 0 0 {}
C {decon-1.sym} 32000 44000 0 0 {}
C {decrypt.sym} 34000 44000 0 0 {}
C {delay-step.sym} 36000 44000 0 0 {}
C {delay.sym} 38000 44000 0 0 {}
C {delay-trim.sym} 40000 44000 0 0 {}
C {delay-var.sym} 42000 44000 0 0 {}
C {demodulator.sym} 44000 44000 0 0 {}
C {detector.sym} 46000 44000 0 0 {}
C {dgnmos-1.sym} 48000 44000 0 0 {}
C {DIN41612C48-1.sym} 50000 44000 0 0 {}
C {DIN41612C48-2.sym} 52000 44000 0 0 {}
C {DIN41612C56-1.sym} 54000 44000 0 0 {}
C {DIN41612C56-2.sym} 56000 44000 0 0 {}
C {DIN41612C96-1.sym} 58000 44000 0 0 {}
C {DIN41612C96-2.sym} 0 46000 0 0 {}
C {DIN41617C13-1.sym} 2000 46000 0 0 {}
C {DIN41617C15-1.sym} 4000 46000 0 0 {}
C {DIN41617C31-1.sym} 6000 46000 0 0 {}
C {diode-1.sym} 8000 46000 0 0 {}
C {diode-2.sym} 10000 46000 0 0 {}
C {diode-3.sym} 12000 46000 0 0 {}
C {diode-bridge-1.sym} 14000 46000 0 0 {}
C {dip24-1.sym} 16000 46000 0 0 {}
C {diplexer.sym} 18000 46000 0 0 {}
C {divide-by-N.sym} 20000 46000 0 0 {}
C {DM9368.sym} 22000 46000 0 0 {}
C {down-converter.sym} 24000 46000 0 0 {}
C {dpst-noblock.sym} 26000 46000 0 0 {}
C {DS1307-1.sym} 28000 46000 0 0 {}
C {DS1602-1.sym} 30000 46000 0 0 {}
C {DS1620-1.sym} 32000 46000 0 0 {}
C {DS2405-1.sym} 34000 46000 0 0 {}
C {DS2450-1.sym} 36000 46000 0 0 {}
C {DS2480B-1.sym} 38000 46000 0 0 {}
C {DS26C31-1.sym} 40000 46000 0 0 {}
C {DS26C32-1.sym} 42000 46000 0 0 {}
C {DS26C32-2.sym} 44000 46000 0 0 {}
C {DS26C61-1.sym} 46000 46000 0 0 {}
C {DS26LS31-1.sym} 48000 46000 0 0 {}
C {DS2890_TO92-1.sym} 50000 46000 0 0 {}
C {DS75176-1.sym} 52000 46000 0 0 {}
C {DS80C310-1.sym} 54000 46000 0 0 {}
C {DS80C310.sym} 56000 46000 0 0 {}
C {DS80C320-1.sym} 58000 46000 0 0 {}
C {DS80C320.sym} 0 48000 0 0 {}
C {DS8641_1.sym} 2000 48000 0 0 {}
C {DS89C450-1.sym} 4000 48000 0 0 {}
C {dual-opamp-1.sym} 6000 48000 0 0 {}
C {encrypt.sym} 8000 48000 0 0 {}
C {EPC1LC20-1.sym} 10000 48000 0 0 {}
C {EPF10K-1.sym} 12000 48000 0 0 {}
C {filter-1.sym} 14000 48000 0 0 {}
C {FND5148-1.sym} 16000 48000 0 0 {}
C {FT245BM-1.sym} 18000 48000 0 0 {}
C {fuse-1.sym} 20000 48000 0 0 {}
C {fuse-2.sym} 22000 48000 0 0 {}
C {generic-power.sym} 24000 48000 0 0 {}
C {glow-lamp-1.sym} 26000 48000 0 0 {}
C {gnd-1.sym} 28000 48000 0 0 {}
C {gnd-2.sym} 30000 48000 0 0 {}
C {gnucap-directive-1.sym} 32000 48000 0 0 {}
C {gnucap-include-1.sym} 34000 48000 0 0 {}
C {gnucap-model-1.sym} 36000 48000 0 0 {}
C {gnucap-npn-1.sym} 38000 48000 0 0 {}
C {gnucap-options-1.sym} 40000 48000 0 0 {}
C {gpib-1.sym} 42000 48000 0 0 {}
C {grid-1.sym} 44000 48000 0 0 {}
C {ground.sym} 46000 48000 0 0 {}
C {HA5221-1.sym} 48000 48000 0 0 {}
C {hcnr201-1.sym} 50000 48000 0 0 {}
C {hcpl-2430-1.sym} 52000 48000 0 0 {}
C {hcpl-2630-1.sym} 54000 48000 0 0 {}
C {hcpl-2631-1.sym} 56000 48000 0 0 {}
C {HCPL4502-1.sym} 58000 48000 0 0 {}
C {hcpl-4534-1.sym} 0 50000 0 0 {}
C {HCPL4701-1.sym} 2000 50000 0 0 {}
C {HCTL-2000-1.sym} 4000 50000 0 0 {}
C {HCTL-2016-1.sym} 6000 50000 0 0 {}
C {header10-1.sym} 8000 50000 0 0 {}
C {header10-2.sym} 10000 50000 0 0 {}
C {header16-1.sym} 12000 50000 0 0 {}
C {header18-2.sym} 14000 50000 0 0 {}
C {header20-1.sym} 16000 50000 0 0 {}
C {header20-2.sym} 18000 50000 0 0 {}
C {header20-3.sym} 20000 50000 0 0 {}
C {header22-1.sym} 22000 50000 0 0 {}
C {header26-1.sym} 24000 50000 0 0 {}
C {header26-2.sym} 26000 50000 0 0 {}
C {header3-1.sym} 28000 50000 0 0 {}
C {header32-2.sym} 30000 50000 0 0 {}
C {header34-1.sym} 32000 50000 0 0 {}
C {header40-2.sym} 34000 50000 0 0 {}
C {header50-1.sym} 36000 50000 0 0 {}
C {header50-2.sym} 38000 50000 0 0 {}
C {header50-3.sym} 40000 50000 0 0 {}
C {header50r-1.sym} 42000 50000 0 0 {}
C {header8-1.sym} 44000 50000 0 0 {}
C {header8-2.sym} 46000 50000 0 0 {}
C {HFA1100-1.sym} 48000 50000 0 0 {}
C {highpass-step.sym} 50000 50000 0 0 {}
C {highpass.sym} 52000 50000 0 0 {}
C {highpass-trim.sym} 54000 50000 0 0 {}
C {highpass-var.sym} 56000 50000 0 0 {}
C {HIP4080A-1.sym} 58000 50000 0 0 {}
C {HIP4081A-1.sym} 0 52000 0 0 {}
C {HM6264P15-1.sym} 2000 52000 0 0 {}
C {HM628511HC-SOJ36-1.sym} 4000 52000 0 0 {}
C {hole-1.sym} 6000 52000 0 0 {}
C {hsdl3612-1.sym} 8000 52000 0 0 {}
C {HSDL7000-1.sym} 10000 52000 0 0 {}
C {hybrid.sym} 12000 52000 0 0 {}
C {icl7660-1.sym} 14000 52000 0 0 {}
C {idc-1.sym} 16000 52000 0 0 {}
C {idt7204-1.sym} 18000 52000 0 0 {}
C {if_trans_aircore-1.sym} 20000 52000 0 0 {}
C {in-1.sym} 22000 52000 0 0 {}
C {inamp-1.sym} 24000 52000 0 0 {}
C {include-1.sym} 26000 52000 0 0 {}
C {inductor-1.sym} 28000 52000 0 0 {}
C {inductor-dot-1.sym} 30000 52000 0 0 {}
C {input-1.sym} 32000 52000 0 0 {}
C {input-2.sym} 34000 52000 0 0 {}
C {input-orcad-1.sym} 36000 52000 0 0 {}
C {input-output.sym} 38000 52000 0 0 {}
C {input.sym} 40000 52000 0 0 {}
C {interpage_bidir-1.sym} 42000 52000 0 0 {}
C {interpage_from-1.sym} 44000 52000 0 0 {}
C {interpage_to-1.sym} 46000 52000 0 0 {}
C {io-1.sym} 48000 52000 0 0 {}
C {io.sym} 50000 52000 0 0 {}
C {ips021-1.sym} 52000 52000 0 0 {}
C {ips3310-1.sym} 54000 52000 0 0 {}
C {ips521-1.sym} 56000 52000 0 0 {}
C {ir2110-1.sym} 58000 52000 0 0 {}
C {IRF1010N-1.sym} 0 54000 0 0 {}
C {IRLZ24N-1.sym} 2000 54000 0 0 {}
C {ISA-98W-SOCKET-1.sym} 4000 54000 0 0 {}
C {isolator.sym} 6000 54000 0 0 {}
C {isp2032-1.sym} 8000 54000 0 0 {}
C {jj-1.sym} 10000 54000 0 0 {}
C {jumper-1.sym} 12000 54000 0 0 {}
C {K3020P-1.sym} 14000 54000 0 0 {}
C {kmutual-1.sym} 16000 54000 0 0 {}
C {l200-1.sym} 18000 54000 0 0 {}
C {L293.sym} 20000 54000 0 0 {}
C {LCD-1.sym} 22000 54000 0 0 {}
C {led-1.sym} 24000 54000 0 0 {}
C {led-2.sym} 26000 54000 0 0 {}
C {led-3.sym} 28000 54000 0 0 {}
C {leddual-1.sym} 30000 54000 0 0 {}
C {leddual-2.sym} 32000 54000 0 0 {}
C {limiter.sym} 34000 54000 0 0 {}
C {lm135-1.sym} 36000 54000 0 0 {}
C {lm1877-1.sym} 38000 54000 0 0 {}
C {lm2576T-1.sym} 40000 54000 0 0 {}
C {lm2822-1.sym} 42000 54000 0 0 {}
C {lm2822m-1.sym} 44000 54000 0 0 {}
C {lm2902-1.sym} 46000 54000 0 0 {}
C {lm2941-1.sym} 48000 54000 0 0 {}
C {lm311-1.sym} 50000 54000 0 0 {}
C {lm317-1.sym} 52000 54000 0 0 {}
C {lm319-1.sym} 54000 54000 0 0 {}
C {lm324-1.sym} 56000 54000 0 0 {}
C {lm337-1.sym} 58000 54000 0 0 {}
C {lm339-1.sym} 0 56000 0 0 {}
C {lm339-2.sym} 2000 56000 0 0 {}
C {lm358-1.sym} 4000 56000 0 0 {}
C {lm386-1.sym} 6000 56000 0 0 {}
C {lm3909-1.sym} 8000 56000 0 0 {}
C {lm393-1.sym} 10000 56000 0 0 {}
C {lm4871m-1.sym} 12000 56000 0 0 {}
C {lm555-1.sym} 14000 56000 0 0 {}
C {lm628n-6.sym} 16000 56000 0 0 {}
C {lm723-1.sym} 18000 56000 0 0 {}
C {lm741-1.sym} 20000 56000 0 0 {}
C {lm75-1.sym} 22000 56000 0 0 {}
C {lm7805-1.sym} 24000 56000 0 0 {}
C {lm7806-1.sym} 26000 56000 0 0 {}
C {lm7810-1.sym} 28000 56000 0 0 {}
C {lm7812-1.sym} 30000 56000 0 0 {}
C {lm7815-1.sym} 32000 56000 0 0 {}
C {lm7818-1.sym} 34000 56000 0 0 {}
C {lm7824-1.sym} 36000 56000 0 0 {}
C {lm7885-1.sym} 38000 56000 0 0 {}
C {lm7912-1.sym} 40000 56000 0 0 {}
C {logic.sym} 42000 56000 0 0 {}
C {loop_antenna-1.sym} 44000 56000 0 0 {}
C {loop_antenna-2.sym} 46000 56000 0 0 {}
C {lowpass-step.sym} 48000 56000 0 0 {}
C {lowpass.sym} 50000 56000 0 0 {}
C {lowpass-trim.sym} 52000 56000 0 0 {}
C {lowpass-var.sym} 54000 56000 0 0 {}
C {lp2954IT-1.sym} 56000 56000 0 0 {}
C {LRPS-2-11.sym} 58000 56000 0 0 {}
C {LSI11BUS-1.sym} 0 58000 0 0 {}
C {lt1108-1.sym} 2000 58000 0 0 {}
C {lt1160-1.sym} 4000 58000 0 0 {}
C {lt1162-1.sym} 6000 58000 0 0 {}
C {lt1181-1.sym} 8000 58000 0 0 {}
C {lt1308-1.sym} 10000 58000 0 0 {}
C {lt1374cs8.sym} 12000 58000 0 0 {}
C {lt1376-5.sym} 14000 58000 0 0 {}
C {lt1761sd-1.sym} 16000 58000 0 0 {}
C {lt1782-1.sym} 18000 58000 0 0 {}
C {ltc1799-1.sym} 20000 58000 0 0 {}
C {ltc2400-1.sym} 22000 58000 0 0 {}
C {ltp-757g-1.sym} 24000 58000 0 0 {}
C {M41T00-SO8-1.sym} 26000 58000 0 0 {}
C {MAC160-1.sym} 28000 58000 0 0 {}
C {mains-entry-1.sym} 30000 58000 0 0 {}
C {mains-plug-1.sym} 32000 58000 0 0 {}
C {mains-plug-2.sym} 34000 58000 0 0 {}
C {max038-1.sym} 36000 58000 0 0 {}
C {max038-2.sym} 38000 58000 0 0 {}
C {max100-1.sym} 40000 58000 0 0 {}
C {max1005-1.sym} 42000 58000 0 0 {}
C {max1005-2.sym} 44000 58000 0 0 {}
C {max1011-1.sym} 46000 58000 0 0 {}
C {max1011-2.sym} 48000 58000 0 0 {}
C {max101A-1.sym} 50000 58000 0 0 {}
C {max1055-1.sym} 52000 58000 0 0 {}
C {max1080-1.sym} 54000 58000 0 0 {}
C {max1081-1.sym} 56000 58000 0 0 {}
C {max1114-1.sym} 58000 58000 0 0 {}
C {max1114-2.sym} 0 60000 0 0 {}
C {max1206-1.sym} 2000 60000 0 0 {}
C {max1207-1.sym} 4000 60000 0 0 {}
C {max1208-1.sym} 6000 60000 0 0 {}
C {max1209-1.sym} 8000 60000 0 0 {}
C {max1211-1.sym} 10000 60000 0 0 {}
C {max122-1.sym} 12000 60000 0 0 {}
C {max12527-1.sym} 14000 60000 0 0 {}
C {max12528-1.sym} 16000 60000 0 0 {}
C {max12529-1.sym} 18000 60000 0 0 {}
C {max12553-1.sym} 20000 60000 0 0 {}
C {max12554-1.sym} 22000 60000 0 0 {}
C {max12555-1.sym} 24000 60000 0 0 {}
C {max12557-1.sym} 26000 60000 0 0 {}
C {max12558-1.sym} 28000 60000 0 0 {}
C {max12559-1.sym} 30000 60000 0 0 {}
C {max135-1.sym} 32000 60000 0 0 {}
C {max1407-1.sym} 34000 60000 0 0 {}
C {max147-1.sym} 36000 60000 0 0 {}
C {max1480A-1.sym} 38000 60000 0 0 {}
C {max1482-1.sym} 40000 60000 0 0 {}
C {max1588-1.sym} 42000 60000 0 0 {}
C {max1608-1.sym} 44000 60000 0 0 {}
C {max1609-1.sym} 46000 60000 0 0 {}
C {max1614-1.sym} 48000 60000 0 0 {}
C {max1620-1.sym} 50000 60000 0 0 {}
C {max1637-1.sym} 52000 60000 0 0 {}
C {max1674-1.sym} 54000 60000 0 0 {}
C {max186-1.sym} 56000 60000 0 0 {}
C {max186-2.sym} 58000 60000 0 0 {}
C {max189-1.sym} 0 62000 0 0 {}
C {max19538-1.sym} 2000 62000 0 0 {}
C {max202-1.sym} 4000 62000 0 0 {}
C {max214-1.sym} 6000 62000 0 0 {}
C {max218-1.sym} 8000 62000 0 0 {}
C {max232-1.sym} 10000 62000 0 0 {}
C {max232-2.sym} 12000 62000 0 0 {}
C {max233-1.sym} 14000 62000 0 0 {}
C {max233-2.sym} 16000 62000 0 0 {}
C {max237-1.sym} 18000 62000 0 0 {}
C {max238-1.sym} 20000 62000 0 0 {}
C {max3120-1.sym} 22000 62000 0 0 {}
C {max3223e-1.sym} 24000 62000 0 0 {}
C {max3226-1.sym} 26000 62000 0 0 {}
C {max3491-1.sym} 28000 62000 0 0 {}
C {max3674-1.sym} 30000 62000 0 0 {}
C {max378-1.sym} 32000 62000 0 0 {}
C {max400-1.sym} 34000 62000 0 0 {}
C {max4005-1.sym} 36000 62000 0 0 {}
C {max4106-1.sym} 38000 62000 0 0 {}
C {max4107-1.sym} 40000 62000 0 0 {}
C {max436-1.sym} 42000 62000 0 0 {}
C {max4420-1.sym} 44000 62000 0 0 {}
C {max4429-1.sym} 46000 62000 0 0 {}
C {max4636-1.sym} 48000 62000 0 0 {}
C {max4662-2.sym} 50000 62000 0 0 {}
C {max478-1.sym} 52000 62000 0 0 {}
C {max488-1.sym} 54000 62000 0 0 {}
C {max489-1.sym} 56000 62000 0 0 {}
C {max492-1.sym} 58000 62000 0 0 {}
C {max507-1.sym} 0 64000 0 0 {}
C {max531-1.sym} 2000 64000 0 0 {}
C {max535-1.sym} 4000 64000 0 0 {}
C {max6018-1.sym} 6000 64000 0 0 {}
C {max6314-1.sym} 8000 64000 0 0 {}
C {max662A-1.sym} 10000 64000 0 0 {}
C {max663-1.sym} 12000 64000 0 0 {}
C {max664-1.sym} 14000 64000 0 0 {}
C {max6674-1.sym} 16000 64000 0 0 {}
C {max713-1.sym} 18000 64000 0 0 {}
C {max7652-1.sym} 20000 64000 0 0 {}
C {max807-1.sym} 22000 64000 0 0 {}
C {max865EUA-1.sym} 24000 64000 0 0 {}
C {max872-1.sym} 26000 64000 0 0 {}
C {max874-1.sym} 28000 64000 0 0 {}
C {max982-1.sym} 30000 64000 0 0 {}
C {mbr1545ct-1.sym} 32000 64000 0 0 {}
C {MC100ELT21-1.sym} 34000 64000 0 0 {}
C {MC100ELT23-1.sym} 36000 64000 0 0 {}
C {MC100ELT23-2.sym} 38000 64000 0 0 {}
C {MC100ELT24-1.sym} 40000 64000 0 0 {}
C {MC10E104-1.sym} 42000 64000 0 0 {}
C {MC10E104-2.sym} 44000 64000 0 0 {}
C {MC10E136-1.sym} 46000 64000 0 0 {}
C {MC10E137-1.sym} 48000 64000 0 0 {}
C {MC10E137-2.sym} 50000 64000 0 0 {}
C {MC12429-1.sym} 52000 64000 0 0 {}
C {mc13175-1.sym} 54000 64000 0 0 {}
C {mc1496-1.sym} 56000 64000 0 0 {}
C {MC34063-1.sym} 58000 64000 0 0 {}
C {mc3479-1.sym} 0 66000 0 0 {}
C {mc3487-1.sym} 2000 66000 0 0 {}
C {mc68hc05j1a-1.sym} 4000 66000 0 0 {}
C {mc68hc705kj1-1.sym} 6000 66000 0 0 {}
C {mc68hc811e2fn-1.sym} 8000 66000 0 0 {}
C {mc68hc812a4-1.sym} 10000 66000 0 0 {}
C {mc68hc908gp32cp-1.sym} 12000 66000 0 0 {}
C {mc68hc912b32-1.sym} 14000 66000 0 0 {}
C {mct9001-1.sym} 16000 66000 0 0 {}
C {MCX-1.sym} 18000 66000 0 0 {}
C {microphone-1.sym} 20000 66000 0 0 {}
C {mixer-ansi.sym} 22000 66000 0 0 {}
C {mixer-din.sym} 24000 66000 0 0 {}
C {mixer.sym} 26000 66000 0 0 {}
C {modem.sym} 28000 66000 0 0 {}
C {modulator.sym} 30000 66000 0 0 {}
C {mosfet-with-diode-1.sym} 32000 66000 0 0 {}
C {MSP430x11x1.sym} 34000 66000 0 0 {}
C {MSP430x11x2.sym} 36000 66000 0 0 {}
C {MSP430x12x2.sym} 38000 66000 0 0 {}
C {MSP430x12x.sym} 40000 66000 0 0 {}
C {MSP430x13-4x.sym} 42000 66000 0 0 {}
C {MSP430x15-6x.sym} 44000 66000 0 0 {}
C {MSP430x41x.sym} 46000 66000 0 0 {}
C {MSP430x43x.sym} 48000 66000 0 0 {}
C {MSP430x44x.sym} 50000 66000 0 0 {}
C {mt8870-1.sym} 52000 66000 0 0 {}
C {mxt429-1.sym} 54000 66000 0 0 {}
C {N82S100N-1.sym} 56000 66000 0 0 {}
C {N82S23N-1.sym} 58000 66000 0 0 {}
C {nc-bottom-1.sym} 0 68000 0 0 {}
C {nc-left-1.sym} 2000 68000 0 0 {}
C {nc-right-1.sym} 4000 68000 0 0 {}
C {nc-top-1.sym} 6000 68000 0 0 {}
C {NE-592-1.sym} 8000 68000 0 0 {}
C {nmos-1.sym} 10000 68000 0 0 {}
C {nmos-2.sym} 12000 68000 0 0 {}
C {nmos-3.sym} 14000 68000 0 0 {}
C {npn-1.sym} 16000 68000 0 0 {}
C {npn-2.sym} 18000 68000 0 0 {}
C {npn-3.sym} 20000 68000 0 0 {}
C {npn-IGBT-1.sym} 22000 68000 0 0 {}
C {ntc-1.sym} 24000 68000 0 0 {}
C {nullor-1.sym} 26000 68000 0 0 {}
C {omron_g2r_24_dc5.sym} 28000 68000 0 0 {}
C {omron-G5V-1-DCx-1.sym} 30000 68000 0 0 {}
C {opamp-1.sym} 32000 68000 0 0 {}
C {opamp-2.sym} 34000 68000 0 0 {}
C {osc-1.sym} 36000 68000 0 0 {}
C {osc-2.sym} 38000 68000 0 0 {}
C {osc-3.sym} 40000 68000 0 0 {}
C {osc_coil_aircore-1.sym} 42000 68000 0 0 {}
C {osc-step.sym} 44000 68000 0 0 {}
C {osc.sym} 46000 68000 0 0 {}
C {osc-trim.sym} 48000 68000 0 0 {}
C {osc-var.sym} 50000 68000 0 0 {}
C {out-1.sym} 52000 68000 0 0 {}
C {output-1.sym} 54000 68000 0 0 {}
C {output-2.sym} 56000 68000 0 0 {}
C {output.sym} 58000 68000 0 0 {}
C {pa140-1.sym} 0 70000 0 0 {}
C {pa91-1.sym} 2000 70000 0 0 {}
C {pad_analog.sym} 4000 70000 0 0 {}
C {pad_gnd.sym} 6000 70000 0 0 {}
C {pad_in.sym} 8000 70000 0 0 {}
C {pad_io.sym} 10000 70000 0 0 {}
C {pad_no_esd.sym} 12000 70000 0 0 {}
C {pad_out.sym} 14000 70000 0 0 {}
C {pad_pull_down.sym} 16000 70000 0 0 {}
C {pad_pull_up.sym} 18000 70000 0 0 {}
C {pad.sym} 20000 70000 0 0 {}
C {pad_vdd.sym} 22000 70000 0 0 {}
C {PAL12H6-1.sym} 24000 70000 0 0 {}
C {PAL16L8-1.sym} 26000 70000 0 0 {}
C {PAL20X10-1.sym} 28000 70000 0 0 {}
C {PAL20X4-1.sym} 30000 70000 0 0 {}
C {PAL20X8-1.sym} 32000 70000 0 0 {}
C {passive-1.sym} 34000 70000 0 0 {}
C {pc104A-1.sym} 36000 70000 0 0 {}
C {pc104B-1.sym} 38000 70000 0 0 {}
C {pc16500d-1.sym} 40000 70000 0 0 {}
C {PCA82C250-1.sym} 42000 70000 0 0 {}
C {PCF8563-1.sym} 44000 70000 0 0 {}
C {PCF8591.sym} 46000 70000 0 0 {}
C {PCM2702E-1.sym} 48000 70000 0 0 {}
C {phase-detector.sym} 50000 70000 0 0 {}
C {photodiode-1.sym} 52000 70000 0 0 {}
C {photo-resistor-1.sym} 54000 70000 0 0 {}
C {photo-transistor-1.sym} 56000 70000 0 0 {}
C {pic12c5xx-1.sym} 58000 70000 0 0 {}
C {pic12F675-1.sym} 0 72000 0 0 {}
C {pic12F675-2.sym} 2000 72000 0 0 {}
C {pic16c505-1.sym} 4000 72000 0 0 {}
C {pic16c5x-1.sym} 6000 72000 0 0 {}
C {pic16C74A-1.sym} 8000 72000 0 0 {}
C {pic16C84.sym} 10000 72000 0 0 {}
C {pic16F628-1.sym} 12000 72000 0 0 {}
C {pic16F628-2.sym} 14000 72000 0 0 {}
C {pic16F876-1.sym} 16000 72000 0 0 {}
C {pic16F877-1.sym} 18000 72000 0 0 {}
C {pic16F877A-1.sym} 20000 72000 0 0 {}
C {pic18F242-1.sym} 22000 72000 0 0 {}
C {pic18F4431-1.sym} 24000 72000 0 0 {}
C {pmos-1.sym} 26000 72000 0 0 {}
C {pmos-2.sym} 28000 72000 0 0 {}
C {pmos-3.sym} 30000 72000 0 0 {}
C {pnp-1.sym} 32000 72000 0 0 {}
C {pnp-2.sym} 34000 72000 0 0 {}
C {pnp-3.sym} 36000 72000 0 0 {}
C {port1-1.sym} 38000 72000 0 0 {}
C {port2-1.sym} 40000 72000 0 0 {}
C {pot-1.sym} 42000 72000 0 0 {}
C {pot-2.sym} 44000 72000 0 0 {}
C {pot-bourns.sym} 46000 72000 0 0 {}
C {process.sym} 48000 72000 0 0 {}
C {ps2501-1.sym} 50000 72000 0 0 {}
C {pulse-step.sym} 52000 72000 0 0 {}
C {pulse.sym} 54000 72000 0 0 {}
C {pulse-trim.sym} 56000 72000 0 0 {}
C {pulse-var.sym} 58000 72000 0 0 {}
C {pushbutton.sym} 0 74000 0 0 {}
C {pwrjack-1.sym} 2000 74000 0 0 {}
C {pwrxfmr-1.sym} 4000 74000 0 0 {}
C {QT60040-1.sym} 6000 74000 0 0 {}
C {quad_opamp-1.sym} 8000 74000 0 0 {}
C {relay-1.sym} 10000 74000 0 0 {}
C {resistor-1.sym} 12000 74000 0 0 {}
C {resistor-2.sym} 14000 74000 0 0 {}
C {resistorpack10-1.sym} 16000 74000 0 0 {}
C {resistorpack11-1.sym} 18000 74000 0 0 {}
C {resistorpack12-1.sym} 20000 74000 0 0 {}
C {resistorpack3-1.sym} 22000 74000 0 0 {}
C {resistorpack4-1.sym} 24000 74000 0 0 {}
C {resistorpack5-1.sym} 26000 74000 0 0 {}
C {resistorpack6-1.sym} 28000 74000 0 0 {}
C {resistorpack7-1.sym} 30000 74000 0 0 {}
C {resistorpack7-2.sym} 32000 74000 0 0 {}
C {resistorpack8-1.sym} 34000 74000 0 0 {}
C {resistorpack8-2.sym} 36000 74000 0 0 {}
C {resistorpack9-1.sym} 38000 74000 0 0 {}
C {resistor-variable-1.sym} 40000 74000 0 0 {}
C {resistor-variable-2.sym} 42000 74000 0 0 {}
C {rf2155-1.sym} 44000 74000 0 0 {}
C {rj45-1.sym} 46000 74000 0 0 {}
C {rpack-1.sym} 48000 74000 0 0 {}
C {rs232-idc10.sym} 50000 74000 0 0 {}
C {sa52-11-1.sym} 52000 74000 0 0 {}
C {SAB80C537-1.sym} 54000 74000 0 0 {}
C {sampler.sym} 56000 74000 0 0 {}
C {sc52-11-1.sym} 58000 74000 0 0 {}
C {schottky-1.sym} 0 76000 0 0 {}
C {si9200-1.sym} 2000 76000 0 0 {}
C {Si9986.sym} 4000 76000 0 0 {}
C {SLA7024M.sym} 6000 76000 0 0 {}
C {smart-media-1.sym} 8000 76000 0 0 {}
C {smda05-1.sym} 10000 76000 0 0 {}
C {smith-1.sym} 12000 76000 0 0 {}
C {sp3t-noblock.sym} 14000 76000 0 0 {}
C {sp3t.sym} 16000 76000 0 0 {}
C {sp4t-noblock.sym} 18000 76000 0 0 {}
C {sp4t.sym} 20000 76000 0 0 {}
C {s-param-1.sym} 22000 76000 0 0 {}
C {spdt-noblock.sym} 24000 76000 0 0 {}
C {spdt.sym} 26000 76000 0 0 {}
C {speaker-1.sym} 28000 76000 0 0 {}
C {speaker-2.sym} 30000 76000 0 0 {}
C {spice-directive-1.sym} 32000 76000 0 0 {}
C {spice-include-1.sym} 34000 76000 0 0 {}
C {spice-model-1.sym} 36000 76000 0 0 {}
C {spice-npn-1.sym} 38000 76000 0 0 {}
C {spice-options-1.sym} 40000 76000 0 0 {}
C {spice-pnp-1.sym} 42000 76000 0 0 {}
C {spice-subcircuit-IO-1.sym} 44000 76000 0 0 {}
C {spice-subcircuit-LL-1.sym} 46000 76000 0 0 {}
C {spice-vc-switch-1.sym} 48000 76000 0 0 {}
C {split-2.sym} 50000 76000 0 0 {}
C {split-3.sym} 52000 76000 0 0 {}
C {split-4.sym} 54000 76000 0 0 {}
C {splitter-1.sym} 56000 76000 0 0 {}
C {spst-noblock.sym} 58000 76000 0 0 {}
C {spst.sym} 0 78000 0 0 {}
C {square-up.sym} 2000 78000 0 0 {}
C {ssrelay-spdt-lcc110-1.sym} 4000 78000 0 0 {}
C {ssrelay-spst-lcb110-1.sym} 6000 78000 0 0 {}
C {ST39SF020A-1.sym} 8000 78000 0 0 {}
C {ST7538-1.sym} 10000 78000 0 0 {}
C {staver24m32-1.sym} 12000 78000 0 0 {}
C {switcap-analysis-1.sym} 14000 78000 0 0 {}
C {switcap-capacitor-1.sym} 16000 78000 0 0 {}
C {switcap-clock-1.sym} 18000 78000 0 0 {}
C {switcap-options-1.sym} 20000 78000 0 0 {}
C {switcap-switch-1.sym} 22000 78000 0 0 {}
C {switcap-timing-1.sym} 24000 78000 0 0 {}
C {switcap-vcvs-1.sym} 26000 78000 0 0 {}
C {switcap-vcvs-2.sym} 28000 78000 0 0 {}
C {switcap-vcvs-3.sym} 30000 78000 0 0 {}
C {switcap-vsrc-1.sym} 32000 78000 0 0 {}
C {switch-5port.sym} 34000 78000 0 0 {}
C {switch-dip12.sym} 36000 78000 0 0 {}
C {switch-dip4-1.sym} 38000 78000 0 0 {}
C {switch-dip4-2.sym} 40000 78000 0 0 {}
C {switch-dip5-1.sym} 42000 78000 0 0 {}
C {switch-dip5-2.sym} 44000 78000 0 0 {}
C {switch-dip6-1.sym} 46000 78000 0 0 {}
C {switch-dip6-2.sym} 48000 78000 0 0 {}
C {switch-dip8-1.sym} 50000 78000 0 0 {}
C {switch-dip8-2.sym} 52000 78000 0 0 {}
C {switch-LORLIN-12pos-1com-1.sym} 54000 78000 0 0 {}
C {switch-pushbutton-nc-1.sym} 56000 78000 0 0 {}
C {switch-pushbutton-nc-2.sym} 58000 78000 0 0 {}
C {switch-pushbutton-no-1.sym} 0 80000 0 0 {}
C {switch-pushbutton-spdt-1.sym} 2000 80000 0 0 {}
C {switch-spdt-1.sym} 4000 80000 0 0 {}
C {switch-spdt-2.sym} 6000 80000 0 0 {}
C {switch-spst-1.sym} 8000 80000 0 0 {}
C {sx28ac-1.sym} 10000 80000 0 0 {}
C {T1-1T-W38-1.sym} 12000 80000 0 0 {}
C {T1-1T-X65-1.sym} 14000 80000 0 0 {}
C {T2-1T-KK81-1.sym} 16000 80000 0 0 {}
C {TC5516AP-1.sym} 18000 80000 0 0 {}
C {TDA2822M-1.sym} 20000 80000 0 0 {}
C {TEC4x3-1.sym} 22000 80000 0 0 {}
C {terminal-1.sym} 24000 80000 0 0 {}
C {termination.sym} 26000 80000 0 0 {}
C {testpt-1.sym} 28000 80000 0 0 {}
C {tfds4500-1.sym} 30000 80000 0 0 {}
C {TINIm390-RevD.sym} 32000 80000 0 0 {}
C {tiny-tiger-1.sym} 34000 80000 0 0 {}
C {tl062-1.sym} 36000 80000 0 0 {}
C {tl072-1.sym} 38000 80000 0 0 {}
C {tl082-1.sym} 40000 80000 0 0 {}
C {tl16c554afn-1.sym} 42000 80000 0 0 {}
C {tline.sym} 44000 80000 0 0 {}
C {TOKO4DFA-1.sym} 46000 80000 0 0 {}
C {transformer-1.sym} 48000 80000 0 0 {}
C {transformer-2.sym} 50000 80000 0 0 {}
C {transformer-3.sym} 52000 80000 0 0 {}
C {transformer-4.sym} 54000 80000 0 0 {}
C {transformer-5.sym} 56000 80000 0 0 {}
C {transformer.sym} 58000 80000 0 0 {}
C {triac-1.sym} 0 82000 0 0 {}
C {txline-1.sym} 2000 82000 0 0 {}
C {txline4-1.sym} 4000 82000 0 0 {}
C {txo-1.sym} 6000 82000 0 0 {}
C {UAA170-1.sym} 8000 82000 0 0 {}
C {ULN2003-1.sym} 10000 82000 0 0 {}
C {ULN2801A-1.sym} 12000 82000 0 0 {}
C {up-converter.sym} 14000 82000 0 0 {}
C {vac-1.sym} 16000 82000 0 0 {}
C {varistor-1.sym} 18000 82000 0 0 {}
C {vcc-1.sym} 20000 82000 0 0 {}
C {vcc-2.sym} 22000 82000 0 0 {}
C {vcc-minus-1.sym} 24000 82000 0 0 {}
C {vcc-orcad-circle-1.sym} 26000 82000 0 0 {}
C {vccs-1.sym} 28000 82000 0 0 {}
C {vcvs-1.sym} 30000 82000 0 0 {}
C {vdc-1.sym} 32000 82000 0 0 {}
C {vdd-1.sym} 34000 82000 0 0 {}
C {vee-1.sym} 36000 82000 0 0 {}
C {vexp-1.sym} 38000 82000 0 0 {}
C {vicor_gen1.sym} 40000 82000 0 0 {}
C {vipec-analysis-1.sym} 42000 82000 0 0 {}
C {voltage-1.sym} 44000 82000 0 0 {}
C {voltage-2.sym} 46000 82000 0 0 {}
C {voltage-3.sym} 48000 82000 0 0 {}
C {voltmeter-1.sym} 50000 82000 0 0 {}
C {volt_reg_adj-1.sym} 52000 82000 0 0 {}
C {vpulse-1.sym} 54000 82000 0 0 {}
C {vpwl-1.sym} 56000 82000 0 0 {}
C {vsin-1.sym} 58000 82000 0 0 {}
C {vss-1.sym} 0 84000 0 0 {}
C {wline-1x.sym} 2000 84000 0 0 {}
C {XC2S100-5PQ208C.sym} 4000 84000 0 0 {}
C {XC2S100-5PQ208I.sym} 6000 84000 0 0 {}
C {XC2S100-6PQ208C.sym} 8000 84000 0 0 {}
C {XC2S150-5PQ208C.sym} 10000 84000 0 0 {}
C {XC2S150-5PQ208I.sym} 12000 84000 0 0 {}
C {XC2S150-6PQ208C.sym} 14000 84000 0 0 {}
C {XC2S200-5PQ208C.sym} 16000 84000 0 0 {}
C {XC2S200-5PQ208I.sym} 18000 84000 0 0 {}
C {XC2S200-6PQ208C.sym} 20000 84000 0 0 {}
C {XC2S30-5PQ208C.sym} 22000 84000 0 0 {}
C {XC2S30-5PQ208I.sym} 24000 84000 0 0 {}
C {XC2S30-6PQ208C.sym} 26000 84000 0 0 {}
C {XC2S50-5PQ208C.sym} 28000 84000 0 0 {}
C {XC2S50-5PQ208I.sym} 30000 84000 0 0 {}
C {XC2S50-6PQ208C.sym} 32000 84000 0 0 {}
C {XC95108-PC84.sym} 34000 84000 0 0 {}
C {xinger-coupler-1.sym} 36000 84000 0 0 {}
C {xinger-hybrid-1.sym} 38000 84000 0 0 {}
C {xinger-split3-1.sym} 40000 84000 0 0 {}
C {xinger-split4-1.sym} 42000 84000 0 0 {}
C {xinger-splitter-1.sym} 44000 84000 0 0 {}
C {z80pio-1.sym} 46000 84000 0 0 {}
C {zener-1.sym} 48000 84000 0 0 {}
C {zener-2.sym} 50000 84000 0 0 {}
C {zener-3.sym} 52000 84000 0 0 {}
C {zener-4.sym} 54000 84000 0 0 {}
