v {xschem version=3.4.6RC file_version=1.2
*
* This file is part of XSCHEM,
* a schematic capture and Spice/Vhdl/Verilog netlisting tool for circuit
* simulation.
* Copyright (C) 1998-2024 Stefan Frederik Schippers
*
* This program is free software; you can redistribute it and/or modify
* it under the terms of the GNU General Public License as published by
* the Free Software Foundation; either version 2 of the License, or
* (at your option) any later version.
*
* This program is distributed in the hope that it will be useful,
* but WITHOUT ANY WARRANTY; without even the implied warranty of
* MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
* GNU General Public License for more details.
*
* You should have received a copy of the GNU General Public License
* along with this program; if not, write to the Free Software
* Foundation, Inc., 51 Franklin Street, Fifth Floor, Boston, MA 02110-1301 USA
}
G {}
K {}
V {}
S {vout out 0 2}
E {}
C {ipin.sym} 120 -550 0 0 {name=p161 lab=PLUS}
C {ipin.sym} 120 -500 0 0 {name=p1 lab=MINUS}
C {opin.sym} 200 -530 0 0 {name=p20 lab=OUT}
C {noconn.sym} 200 -530 0 0 {name=l1}
C {noconn.sym} 120 -550 0 1 {name=l2}
C {noconn.sym} 120 -500 0 1 {name=l3}
C {architecture.sym} 60 -600 0 0 {code=ARCHITECTURE 
"Use global schematic properties for code"}
