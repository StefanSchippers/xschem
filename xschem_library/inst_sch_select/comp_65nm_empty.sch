v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {vout out 0 2}
E {}
C {architecture.sym} 70 -610 0 0 { nothing here, use global schematic properties }
