v {xschem version=3.4.7 file_version=1.2
}
G {font file}
K {}
V {}
S {}
E {}
L 3 1330 -35 1330 -5 {}
L 3 1367.5 -35 1367.5 -25 {}
L 3 1372.5 -35 1372.5 -25 {}
L 3 1405 -30 1405 0 {}
L 3 1415 -30 1415 0 {}
L 3 1400 -20 1420 -20 {}
L 3 1400 -10 1420 -10 {}
L 3 1455 -30 1460 -25 {}
L 3 1445 -30 1455 -30 {}
L 3 1440 -25 1445 -30 {}
L 3 1440 -25 1440 -20 {}
L 3 1440 -20 1445 -15 {}
L 3 1445 -15 1455 -15 {}
L 3 1455 -15 1460 -10 {}
L 3 1460 -10 1460 -5 {}
L 3 1455 0 1460 -5 {}
L 3 1445 0 1455 0 {}
L 3 1440 -5 1445 0 {}
L 3 1450 -35 1450 5 {}
L 3 1480 0 1500 -30 {}
L 3 1480 -30 1485 -30 {}
L 3 1485 -30 1485 -25 {}
L 3 1480 -25 1485 -25 {}
L 3 1480 -30 1480 -25 {}
L 3 1500 -5 1500 0 {}
L 3 1495 0 1500 0 {}
L 3 1495 -5 1495 0 {}
L 3 1495 -5 1500 -5 {}
L 3 1525 5 1530 5 {}
L 3 1520 -5 1520 0 {}
L 3 1520 -5 1535 -27.5 {}
L 3 1525 -25 1540 5 {}
L 3 1528.75 -35 1532.5 -35 {}
L 3 1570 -35 1570 -25 {}
L 3 1605 -25 1610 -35 {}
L 3 1605 -25 1605 -5 {}
L 3 1605 -5 1610 5 {}
L 3 1650 -35 1655 -25 {}
L 3 1655 -25 1655 -5 {}
L 3 1650 5 1655 -5 {}
L 3 1680 -15 1700 -15 {}
L 3 1690 -25 1690 -5 {}
L 3 1682.5 -7.5 1697.5 -22.5 {}
L 3 1682.5 -22.5 1697.5 -7.5 {}
L 3 1720 -15 1740 -15 {}
L 3 1730 -25 1730 -5 {}
L 3 1800 -15 1820 -15 {}
L 3 2480 -25 2500 -15 {}
L 3 2480 -5 2500 -15 {}
L 3 2527.5 2.5 2527.5 5 {}
L 3 2527.5 2.5 2532.5 2.5 {}
L 3 2532.5 2.5 2532.5 5 {}
L 3 2527.5 5 2532.5 5 {}
L 3 2520 -30 2525 -35 {}
L 3 2525 -35 2535 -35 {}
L 3 2535 -35 2540 -30 {}
L 3 2540 -30 2540 -25 {}
L 3 2530 -15 2540 -25 {}
L 3 2530 -15 2530 -5 {}
L 3 2565 -20 2570 -20 {}
L 3 2565 -20 2565 -10 {}
L 3 2565 -10 2570 -10 {}
L 3 2570 -20 2570 -10 {}
L 3 2570 -10 2575 -10 {}
L 3 2575 -10 2580 -15 {}
L 3 2580 -25 2580 -15 {}
L 3 2575 -30 2580 -25 {}
L 3 2565 -30 2575 -30 {}
L 3 2560 -25 2565 -30 {}
L 3 2560 -25 2560 0 {}
L 3 2560 0 2565 5 {}
L 3 2565 5 2575 5 {}
L 3 2575 5 2580 0 {}
L 3 2640 -35 2640 5 {}
L 3 2640 -35 2655 -35 {}
L 3 2640 -15 2653.75 -15 {}
L 3 2640 5 2655 5 {}
L 3 2680 -30 2680 0 {}
L 3 2685 -35 2695 -35 {}
L 3 2685 5 2695 5 {}
L 3 2720 -35 2720 5 {}
L 3 2720 5 2728.75 5 {}
L 3 2760 -35 2760 5 {}
L 3 2760 -35 2780 -35 {}
L 3 2760 5 2780 5 {}
L 3 2800 -35 2800 5 {}
L 3 2800 -35 2820 -35 {}
L 3 2800 -15 2815 -15 {}
L 3 2840 -30 2840 0 {}
L 3 2845 5 2855 5 {}
L 3 2860 -10 2860 0 {}
L 3 2850 -10 2860 -10 {}
L 3 2845 -35 2855 -35 {}
L 3 2880 -35 2880 5 {}
L 3 2880 -15 2900 -15 {}
L 3 2900 -35 2900 5 {}
L 3 2930 -35 2930 5 {}
L 3 2965 -35 2975 -35 {}
L 3 2970 -35 2970 0 {}
L 3 3000 -35 3000 5 {}
L 3 3000 -15 3020 -35 {}
L 3 3000 -15 3020 5 {}
L 3 3040 -35 3040 5 {}
L 3 3040 5 3060 5 {}
L 3 3080 -35 3080 5 {}
L 3 3080 -35 3090 -20 {}
L 3 3090 -20 3100 -35 {}
L 3 3100 -35 3100 5 {}
L 3 3120 -35 3120 5 {}
L 3 3120 -35 3140 5 {}
L 3 3140 -35 3140 5 {}
L 3 3160 -30 3160 0 {}
L 3 3165 -35 3175 -35 {}
L 3 3180 -30 3180 0 {}
L 3 3165 5 3175 5 {}
L 3 3200 -35 3200 5 {}
L 3 3200 -35 3215 -35 {}
L 3 3220 -30 3220 -20 {}
L 3 3200 -15 3215 -15 {}
L 3 3240 -30 3240 0 {}
L 3 3245 -35 3255 -35 {}
L 3 3280 -35 3280 5 {}
L 3 3280 -35 3295 -35 {}
L 3 3300 -30 3300 -20 {}
L 3 3280 -15 3295 -15 {}
L 3 3290 -15 3300 5 {}
L 3 3370 -35 3370 5 {}
L 3 3360 -35 3380 -35 {}
L 3 3400 -35 3400 0 {}
L 3 3405 5 3415 5 {}
L 3 3420 -35 3420 0 {}
L 3 3440 -35 3450 5 {}
L 3 3450 5 3460 -35 {}
L 3 3520 5 3540 -35 {}
L 3 3520 -35 3540 5 {}
L 3 3560 -35 3570 -15 {}
L 3 3570 -15 3580 -35 {}
L 3 3570 -15 3570 5 {}
L 3 3600 -35 3620 -35 {}
L 3 3600 5 3620 -35 {}
L 3 3600 5 3620 5 {}
L 3 3645 -35 3645 5 {}
L 3 3645 5 3655 5 {}
L 3 3645 -35 3655 -35 {}
L 3 3680 -35 3700 5 {}
L 3 3725 -35 3735 -35 {}
L 3 3735 -35 3735 5 {}
L 3 3725 5 3735 5 {}
L 3 3760 -25 3770 -35 {}
L 3 3770 -35 3780 -25 {}
L 3 3800 5 3820 5 {}
L 3 3845 -35 3855 -25 {}
L 3 3900 -15 3900 5 {}
L 3 3885 5 3895 5 {}
L 3 3880 -5 3880 0 {}
L 3 3885 -10 3895 -10 {}
L 3 3885 -20 3895 -20 {}
L 3 3920 -35 3920 5 {}
L 3 3940 -15 3940 0 {}
L 3 3960 -15 3960 0 {}
L 3 4020 -35 4020 5 {}
L 3 4006.25 -20 4013.75 -20 {}
L 3 4000 -15 4000 0 {}
L 3 4006.25 5 4013.75 5 {}
L 3 4040 -10 4060 -10 {}
L 3 4045 -20 4055 -20 {}
L 3 4045 5 4055 5 {}
L 3 4085 -27.5 4085 5 {}
L 3 4090 -35 4095 -35 {}
L 3 4160 -35 4160 5 {}
L 3 4180 -12.5 4180 5 {}
L 3 4210 -20 4210 5 {}
L 3 4208.75 -30 4208.75 -27.5 {}
L 3 4208.75 -27.5 4211.25 -27.5 {}
L 3 4211.25 -30 4211.25 -27.5 {}
L 3 4208.75 -30 4211.25 -30 {}
L 3 4248.75 -30 4248.75 -27.5 {}
L 3 4248.75 -27.5 4251.25 -27.5 {}
L 3 4251.25 -30 4251.25 -27.5 {}
L 3 4248.75 -30 4251.25 -30 {}
L 3 4250 -20 4250 15 {}
L 3 4240 20 4245 20 {}
L 3 4280 -35 4280 5 {}
L 3 4280 -5 4300 -20 {}
L 3 4280 -5 4300 5 {}
L 3 4330 -35 4330 5 {}
L 3 4325 -35 4330 -35 {}
L 3 4360 -20 4360 5 {}
L 3 4400 -20 4400 5 {}
L 3 4405 -20 4415 -20 {}
L 3 4420 -15 4420 5 {}
L 3 4480 -20 4480 20 {}
L 3 4540 -20 4540 20 {}
L 3 4563.75 -20 4563.75 5 {}
L 3 4606.25 -20 4613.75 -20 {}
L 3 4600 -15 4600 -12.5 {}
L 3 4606.25 -7.5 4613.75 -7.5 {}
L 3 4620 -2.5 4620 0 {}
L 3 4606.25 5 4613.75 5 {}
L 3 4645 -35 4645 0 {}
L 3 4650 5 4655 5 {}
L 3 4720 -20 4730 5 {}
L 3 4730 5 4740 -20 {}
L 3 4800 5 4820 -20 {}
L 3 4800 -20 4820 5 {}
L 3 4840 -20 4850 5 {}
L 3 4850 5 4860 -20 {}
L 3 4843.75 20 4850 5 {}
L 3 4841.25 20 4843.75 20 {}
L 3 4880 -20 4900 -20 {}
L 3 4880 5 4900 -20 {}
L 3 4880 5 4900 5 {}
L 3 4930 -35 4935 -35 {}
L 3 4925 -30 4925 -25 {}
L 3 4925 -5 4925 0 {}
L 3 4930 5 4935 5 {}
L 3 4970 -35 4970 5 {}
L 3 5045 -35 5047.5 -35 {}
L 3 5047.5 -35 5052.5 -30 {}
L 3 5052.5 -30 5055 -30 {}
L 3 4760 -20 4765 5 {}
L 3 4775 5 4780 -20 {}
L 3 4645 -25 4655 -25 {}
L 3 4140 -15 4140 15 {}
L 3 4125 20 4135 20 {}
L 3 3260 -30 3260 0 {}
L 3 3245 5 3255 5 {}
L 3 3255 -5 3260 10 {}
L 3 4085 -10 4095 -10 {}
L 3 1331.25 2.5 1331.25 5 {}
L 3 1328.75 2.5 1328.75 5 {}
L 3 1328.75 2.5 1331.25 2.5 {}
L 3 1328.75 5 1331.25 5 {}
L 3 2760 -15 2770 -15 {}
L 3 3480 -35 3482.5 5 {}
L 3 3497.5 5 3500 -35 {}
L 3 3482.5 5 3490 -22.5 {}
L 3 3490 -22.5 3497.5 5 {}
L 3 4765 5 4770 -12.5 {}
L 3 4770 -12.5 4775 5 {}
L 3 2925 -35 2935 -35 {}
L 3 2925 5 2935 5 {}
L 3 2600 5 2607.5 -35 {}
L 3 2612.5 -35 2620 5 {}
L 3 2607.5 -35 2612.5 -35 {}
L 3 2602.5 -7.5 2617.5 -7.5 {}
L 3 2737.5 -27.5 2740 -17.5 {}
L 3 2737.5 -2.5 2740 -12.5 {}
L 3 2740 -17.5 2740 -12.5 {}
L 3 4058.75 2.5 4060 0 {}
L 3 4055 5 4058.75 2.5 {}
L 3 4060 -12.5 4060 -10 {}
L 3 4058.75 -17.5 4060 -12.5 {}
L 3 4055 -20 4058.75 -17.5 {}
L 3 4040 -12.5 4041.25 -17.5 {}
L 3 4041.25 -17.5 4045 -20 {}
L 3 4040 0 4041.25 2.5 {}
L 3 4041.25 2.5 4045 5 {}
L 3 4040 -12.5 4040 0 {}
L 3 4000 -15 4001.25 -17.5 {}
L 3 4001.25 -17.5 4006.25 -20 {}
L 3 4006.25 -20 4013.75 -20 {}
L 3 4013.75 -20 4018.75 -17.5 {}
L 3 4018.75 -17.5 4020 -15 {}
L 3 4018.75 2.5 4020 0 {}
L 3 4013.75 5 4018.75 2.5 {}
L 3 4001.25 2.5 4006.25 5 {}
L 3 4000 0 4001.25 2.5 {}
L 3 3960 -15 3961.25 -17.5 {}
L 3 3961.25 -17.5 3966.25 -20 {}
L 3 3961.25 2.5 3966.25 5 {}
L 3 3960 0 3961.25 2.5 {}
L 3 3966.25 -20 3973.75 -20 {}
L 3 3966.25 5 3973.75 5 {}
L 3 3966.25 -20 3973.75 -20 {}
L 3 3973.75 -20 3978.75 -17.5 {}
L 3 3978.75 -17.5 3980 -15 {}
L 3 3978.75 2.5 3980 0 {}
L 3 3973.75 5 3978.75 2.5 {}
L 3 3881.25 2.5 3885 5 {}
L 3 3880 0 3881.25 2.5 {}
L 3 3881.25 -7.5 3885 -10 {}
L 3 3880 -5 3881.25 -7.5 {}
L 3 3895 5 3898.75 2.5 {}
L 3 3898.75 2.5 3900 0 {}
L 3 3895 -10 3898.75 -7.5 {}
L 3 3898.75 -7.5 3900 -5 {}
L 3 3898.75 -17.5 3900 -15 {}
L 3 3895 -20 3898.75 -17.5 {}
L 3 3920 -15 3921.25 -17.5 {}
L 3 3921.25 -17.5 3926.25 -20 {}
L 3 3921.25 2.5 3926.25 5 {}
L 3 3920 0 3921.25 2.5 {}
L 3 3926.25 -20 3933.75 -20 {}
L 3 3926.25 5 3933.75 5 {}
L 3 3933.75 -20 3938.75 -17.5 {}
L 3 3938.75 -17.5 3940 -15 {}
L 3 3938.75 2.5 3940 0 {}
L 3 3933.75 5 3938.75 2.5 {}
L 3 4138.75 17.5 4140 15 {}
L 3 4135 20 4138.75 17.5 {}
L 3 4120 15 4121.25 17.5 {}
L 3 4121.25 17.5 4125 20 {}
L 3 4085 -27.5 4086.25 -32.5 {}
L 3 4086.25 -32.5 4090 -35 {}
L 3 4165 -20 4175 -20 {}
L 3 4178.75 -17.5 4180 -12.5 {}
L 3 4175 -20 4178.75 -17.5 {}
L 3 4160 -12.5 4161.25 -17.5 {}
L 3 4161.25 -17.5 4165 -20 {}
L 3 4446.25 -20 4453.75 -20 {}
L 3 4440 -15 4440 0 {}
L 3 4446.25 5 4453.75 5 {}
L 3 4440 -15 4441.25 -17.5 {}
L 3 4441.25 -17.5 4446.25 -20 {}
L 3 4446.25 -20 4453.75 -20 {}
L 3 4453.75 -20 4458.75 -17.5 {}
L 3 4458.75 -17.5 4460 -15 {}
L 3 4458.75 2.5 4460 0 {}
L 3 4453.75 5 4458.75 2.5 {}
L 3 4441.25 2.5 4446.25 5 {}
L 3 4440 0 4441.25 2.5 {}
L 3 4460 -15 4460 0 {}
L 3 4486.25 -20 4493.75 -20 {}
L 3 4486.25 5 4493.75 5 {}
L 3 4480 -15 4481.25 -17.5 {}
L 3 4481.25 -17.5 4486.25 -20 {}
L 3 4486.25 -20 4493.75 -20 {}
L 3 4493.75 -20 4498.75 -17.5 {}
L 3 4498.75 -17.5 4500 -15 {}
L 3 4498.75 2.5 4500 0 {}
L 3 4493.75 5 4498.75 2.5 {}
L 3 4481.25 2.5 4486.25 5 {}
L 3 4480 0 4481.25 2.5 {}
L 3 4500 -15 4500 0 {}
L 3 4526.25 -20 4533.75 -20 {}
L 3 4526.25 5 4533.75 5 {}
L 3 4538.75 -17.5 4540 -15 {}
L 3 4533.75 -20 4538.75 -17.5 {}
L 3 4526.25 -20 4533.75 -20 {}
L 3 4521.25 -17.5 4526.25 -20 {}
L 3 4520 -15 4521.25 -17.5 {}
L 3 4520 0 4521.25 2.5 {}
L 3 4521.25 2.5 4526.25 5 {}
L 3 4533.75 5 4538.75 2.5 {}
L 3 4538.75 2.5 4540 0 {}
L 3 4520 -15 4520 0 {}
L 3 4568.75 -20 4573.75 -20 {}
L 3 4577.5 -17.5 4578.75 -15 {}
L 3 4573.75 -20 4577.5 -17.5 {}
L 3 4565 -17.5 4568.75 -20 {}
L 3 4563.75 -15 4565 -17.5 {}
L 3 4618.75 -17.5 4620 -15 {}
L 3 4613.75 -20 4618.75 -17.5 {}
L 3 4600 -15 4601.25 -17.5 {}
L 3 4601.25 -17.5 4606.25 -20 {}
L 3 4600 -12.5 4601.25 -10 {}
L 3 4601.25 -10 4606.25 -7.5 {}
L 3 4620 -2.5 4620 0 {}
L 3 4618.75 -5 4620 -2.5 {}
L 3 4613.75 -7.5 4618.75 -5 {}
L 3 4618.75 2.5 4620 0 {}
L 3 4613.75 5 4618.75 2.5 {}
L 3 4600 0 4601.25 2.5 {}
L 3 4601.25 2.5 4606.25 5 {}
L 3 4646.25 3.75 4650 5 {}
L 3 4645 0 4646.25 3.75 {}
L 3 4248.75 17.5 4250 15 {}
L 3 4245 20 4248.75 17.5 {}
L 3 4360 -15 4362.5 -18.75 {}
L 3 4362.5 -18.75 4365 -20 {}
L 3 4370 -15 4372.5 -18.75 {}
L 3 4372.5 -18.75 4375 -20 {}
L 3 4400 -15 4402.5 -18.75 {}
L 3 4402.5 -18.75 4405 -20 {}
L 3 4417.5 -18.75 4420 -15 {}
L 3 4415 -20 4417.5 -18.75 {}
L 3 4380 -16.75 4380 5 {}
L 3 4370 -16.75 4370 5 {}
L 3 4375 -20 4378.75 -19 {}
L 3 4365 -20 4368.75 -19 {}
L 3 4368.75 -19 4370 -16.75 {}
L 3 4378.75 -19 4380 -16.75 {}
L 3 4925 -15 4926.25 -16.25 {}
L 3 4926.25 -16.25 4927.5 -18.75 {}
L 3 4927.5 -21.25 4927.5 -18.75 {}
L 3 4925 -25 4927.5 -21.25 {}
L 3 4925 -15 4926.25 -13.75 {}
L 3 4926.25 -13.75 4927.5 -11.25 {}
L 3 4927.5 -11.25 4927.5 -8.75 {}
L 3 4925 -5 4927.5 -8.75 {}
L 3 4925 -30 4926.25 -32.5 {}
L 3 4926.25 -32.5 4930 -35 {}
L 3 4925 0 4926.25 2.5 {}
L 3 4926.25 2.5 4930 5 {}
L 3 5005 -35 5010 -35 {}
L 3 5015 -30 5015 -25 {}
L 3 5015 -5 5015 0 {}
L 3 5005 5 5010 5 {}
L 3 5013.75 -16.25 5015 -15 {}
L 3 5012.5 -18.75 5013.75 -16.25 {}
L 3 5012.5 -21.25 5012.5 -18.75 {}
L 3 5012.5 -21.25 5015 -25 {}
L 3 5013.75 -13.75 5015 -15 {}
L 3 5012.5 -11.25 5013.75 -13.75 {}
L 3 5012.5 -11.25 5012.5 -8.75 {}
L 3 5012.5 -8.75 5015 -5 {}
L 3 5013.75 -32.5 5015 -30 {}
L 3 5010 -35 5013.75 -32.5 {}
L 3 5013.75 2.5 5015 0 {}
L 3 5010 5 5013.75 2.5 {}
L 3 5040 -30 5041.25 -32.5 {}
L 3 5041.25 -32.5 5045 -35 {}
L 3 5058.75 -32.5 5060 -35 {}
L 3 5055 -30 5058.75 -32.5 {}
L 3 1880 5 1900 -35 {}
L 3 1965 5 1975 5 {}
L 3 1970 -35 1970 5 {}
L 3 1965 -25 1970 -35 {}
L 3 2005 -35 2015 -35 {}
L 3 2020 -30 2020 -20 {}
L 3 2000 0 2000 5 {}
L 3 2000 5 2020 5 {}
L 3 2045 -35 2053.75 -35 {}
L 3 2060 -30 2060 -20 {}
L 3 2045 -15 2053.75 -15 {}
L 3 2060 -10 2060 0 {}
L 3 2045 5 2053.75 5 {}
L 3 2080 -7.5 2095 -35 {}
L 3 2080 -7.5 2100 -7.5 {}
L 3 2095 -35 2095 5 {}
L 3 2120 -35 2140 -35 {}
L 3 2120 5 2133.75 5 {}
L 3 2180 -10 2180 0 {}
L 3 2200 -35 2220 -35 {}
L 3 2210 5 2220 -35 {}
L 3 2400 -15 2420 -25 {}
L 3 2400 -15 2420 -5 {}
L 3 2440 -20 2460 -20 {}
L 3 2440 -10 2460 -10 {}
L 3 2120 -17.5 2133.75 -17.5 {}
L 3 2120 -35 2120 -17.5 {}
L 3 2140 -12.5 2140 0 {}
L 3 2327.5 -30 2327.5 -25 {}
L 3 2327.5 -30 2332.5 -30 {}
L 3 2332.5 -30 2332.5 -25 {}
L 3 2327.5 -25 2332.5 -25 {}
L 3 2327.5 -5 2327.5 0 {}
L 3 2327.5 -5 2332.5 -5 {}
L 3 2332.5 -5 2332.5 0 {}
L 3 2327.5 0 2332.5 0 {}
L 3 2367.5 -30 2367.5 -25 {}
L 3 2367.5 -30 2372.5 -30 {}
L 3 2372.5 -30 2372.5 -25 {}
L 3 2367.5 -25 2372.5 -25 {}
L 3 2367.5 -5 2367.5 0 {}
L 3 2367.5 -5 2372.5 -5 {}
L 3 2372.5 -5 2372.5 0 {}
L 3 2040 -32.5 2045 -35 {}
L 3 2040 2.5 2045 5 {}
L 3 2160 -22.5 2160 0 {}
L 3 2166.25 -15 2173.75 -15 {}
L 3 2160 -22.5 2163.75 -30 {}
L 3 2170 -33.75 2176.25 -35 {}
L 3 2163.75 -30 2170 -33.75 {}
L 3 2000 -30 2002.5 -33.75 {}
L 3 2002.5 -33.75 2005 -35 {}
L 3 2015 -35 2017.5 -33.75 {}
L 3 2017.5 -33.75 2020 -30 {}
L 3 2018.75 -17.5 2020 -20 {}
L 3 2016.25 -15 2018.75 -17.5 {}
L 3 2000 0 2001.25 -2.5 {}
L 3 2001.25 -2.5 2003.75 -5 {}
L 3 2003.75 -5 2016.25 -15 {}
L 3 2058.75 -17.5 2060 -20 {}
L 3 2053.75 -15 2058.75 -17.5 {}
L 3 2058.75 -12.5 2060 -10 {}
L 3 2053.75 -15 2058.75 -12.5 {}
L 3 2178.75 -12.5 2180 -10 {}
L 3 2173.75 -15 2178.75 -12.5 {}
L 3 2160 -10 2161.25 -12.5 {}
L 3 2161.25 -12.5 2166.25 -15 {}
L 3 2257.5 -11.25 2258.75 -8.75 {}
L 3 2255 -13.75 2257.5 -11.25 {}
L 3 2241.25 -8.75 2242.5 -11.25 {}
L 3 2242.5 -11.25 2245 -13.75 {}
L 3 2245 -13.75 2248.75 -15 {}
L 3 2251.25 -15 2255 -13.75 {}
L 3 2240 -1.25 2241.25 1.25 {}
L 3 2241.25 1.25 2243.75 3.75 {}
L 3 2258.75 1.25 2260 -1.25 {}
L 3 2256.25 3.75 2258.75 1.25 {}
L 3 2252.5 5 2256.25 3.75 {}
L 3 2243.75 3.75 2247.5 5 {}
L 3 2258.75 -8.75 2260 -1.25 {}
L 3 2240 -1.25 2241.25 -8.75 {}
L 3 2247.5 5 2252.5 5 {}
L 3 2248.75 -15 2251.25 -15 {}
L 3 2258.75 -31.25 2260 -28.75 {}
L 3 2256.25 -33.75 2258.75 -31.25 {}
L 3 2240 -28.75 2241.25 -31.25 {}
L 3 2241.25 -31.25 2243.75 -33.75 {}
L 3 2243.75 -33.75 2247.5 -35 {}
L 3 2252.5 -35 2256.25 -33.75 {}
L 3 2241.25 -21.25 2242.5 -18.75 {}
L 3 2242.5 -18.75 2245 -16.25 {}
L 3 2257.5 -18.75 2258.75 -21.25 {}
L 3 2255 -16.25 2257.5 -18.75 {}
L 3 2251.25 -15 2255 -16.25 {}
L 3 2245 -16.25 2248.75 -15 {}
L 3 2258.75 -21.25 2260 -28.75 {}
L 3 2240 -28.75 2241.25 -21.25 {}
L 3 2247.5 -35 2252.5 -35 {}
L 3 2176.25 -35 2177.5 -35 {}
L 3 1940 -30 1940 0 {}
L 3 1920 -30 1921.25 -32.5 {}
L 3 1921.25 -32.5 1925 -35 {}
L 3 1938.75 -32.5 1940 -30 {}
L 3 1935 -35 1938.75 -32.5 {}
L 3 1925 -35 1935 -35 {}
L 3 1938.75 2.5 1940 0 {}
L 3 1935 5 1938.75 2.5 {}
L 3 1920 0 1921.25 2.5 {}
L 3 1921.25 2.5 1925 5 {}
L 3 1925 5 1935 5 {}
L 3 1920 -30 1920 0 {}
L 3 1920 -5 1940 -25 {}
L 3 1853.75 0 1855 1.25 {}
L 3 1853.75 5 1855 3.75 {}
L 3 1850 1.25 1851.25 0 {}
L 3 1850 3.75 1851.25 5 {}
L 3 1851.25 5 1853.75 5 {}
L 3 1855 1.25 1855 3.75 {}
L 3 1851.25 0 1853.75 0 {}
L 3 1850 1.25 1850 3.75 {}
L 3 2371.25 2.5 2372.5 0 {}
L 3 2370 3.75 2371.25 2.5 {}
L 3 2366.25 5 2370 3.75 {}
L 3 2362.5 5 2366.25 5 {}
L 3 2362.5 5 2363.75 3.75 {}
L 3 2363.75 3.75 2366.25 2.5 {}
L 3 2366.25 2.5 2367.5 0 {}
L 3 1770 -5 1770 0 {}
L 3 1770 -5 1775 -5 {}
L 3 1775 -5 1775 0 {}
L 3 1773.75 2.5 1775 0 {}
L 3 1772.5 3.75 1773.75 2.5 {}
L 3 1768.75 5 1772.5 3.75 {}
L 3 1765 5 1768.75 5 {}
L 3 1765 5 1766.25 3.75 {}
L 3 1766.25 3.75 1768.75 2.5 {}
L 3 1768.75 2.5 1770 0 {}
L 3 1530 5 1535 0 {}
L 3 1535 0 1540 -13.75 {}
L 3 1521.25 2.5 1525 5 {}
L 3 1520 0 1521.25 2.5 {}
L 3 1535 -27.5 1536.25 -30 {}
L 3 1536.25 -32.5 1536.25 -30 {}
L 3 1535 -33.75 1536.25 -32.5 {}
L 3 1532.5 -35 1535 -33.75 {}
L 3 1526.25 -33.75 1528.75 -35 {}
L 3 1525 -31.25 1526.25 -33.75 {}
L 3 1525 -31.25 1525 -25 {}
L 3 2058.75 -32.5 2060 -30 {}
L 3 2053.75 -35 2058.75 -32.5 {}
L 3 2058.75 2.5 2060 0 {}
L 3 2053.75 5 2058.75 2.5 {}
L 3 2138.75 -15 2140 -12.5 {}
L 3 2133.75 -17.5 2138.75 -15 {}
L 3 2178.75 2.5 2180 0 {}
L 3 2173.75 5 2178.75 2.5 {}
L 3 2160 0 2161.25 2.5 {}
L 3 2161.25 2.5 2166.25 5 {}
L 3 2166.25 5 2173.75 5 {}
L 3 2138.75 2.5 2140 0 {}
L 3 2133.75 5 2138.75 2.5 {}
L 3 3325 -35 3335 -35 {}
L 3 3320 -30 3320 -20 {}
L 3 3325 -15 3335 -15 {}
L 3 3340 -10 3340 0 {}
L 3 3325 5 3335 5 {}
L 3 3322.5 3.75 3325 5 {}
L 3 3320 0 3322.5 3.75 {}
L 3 3335 5 3337.5 3.75 {}
L 3 3337.5 3.75 3340 0 {}
L 3 3337.5 -13.75 3340 -10 {}
L 3 3335 -15 3337.5 -13.75 {}
L 3 3322.5 -16.25 3325 -15 {}
L 3 3320 -20 3322.5 -16.25 {}
L 3 3322.5 -33.75 3325 -35 {}
L 3 3320 -30 3322.5 -33.75 {}
L 3 3335 -35 3337.5 -33.75 {}
L 3 3337.5 -33.75 3340 -30 {}
L 3 3402.5 3.75 3405 5 {}
L 3 3400 0 3402.5 3.75 {}
L 3 3415 5 3417.5 3.75 {}
L 3 3417.5 3.75 3420 0 {}
L 3 3295 -15 3297.5 -16.25 {}
L 3 3297.5 -16.25 3300 -20 {}
L 3 3297.5 -33.75 3300 -30 {}
L 3 3295 -35 3297.5 -33.75 {}
L 3 3257.5 -33.75 3260 -30 {}
L 3 3255 -35 3257.5 -33.75 {}
L 3 3240 -30 3242.5 -33.75 {}
L 3 3242.5 -33.75 3245 -35 {}
L 3 3240 0 3242.5 3.75 {}
L 3 3242.5 3.75 3245 5 {}
L 3 3257.5 3.75 3260 0 {}
L 3 3255 5 3257.5 3.75 {}
L 3 3215 -15 3217.5 -16.25 {}
L 3 3217.5 -16.25 3220 -20 {}
L 3 3217.5 -33.75 3220 -30 {}
L 3 3215 -35 3217.5 -33.75 {}
L 3 3177.5 -33.75 3180 -30 {}
L 3 3175 -35 3177.5 -33.75 {}
L 3 3160 -30 3162.5 -33.75 {}
L 3 3162.5 -33.75 3165 -35 {}
L 3 3160 0 3162.5 3.75 {}
L 3 3162.5 3.75 3165 5 {}
L 3 3177.5 3.75 3180 0 {}
L 3 3175 5 3177.5 3.75 {}
L 3 2965 5 2967.5 3.75 {}
L 3 2967.5 3.75 2970 0 {}
L 3 2960 3.75 2962.5 5 {}
L 3 2957.5 0 2960 3.75 {}
L 3 2962.5 5 2965 5 {}
L 3 2857.5 3.75 2860 0 {}
L 3 2855 5 2857.5 3.75 {}
L 3 2840 0 2842.5 3.75 {}
L 3 2842.5 3.75 2845 5 {}
L 3 2840 -30 2842.5 -33.75 {}
L 3 2842.5 -33.75 2845 -35 {}
L 3 2857.5 -33.75 2860 -30 {}
L 3 2855 -35 2857.5 -33.75 {}
L 3 2728.75 5 2731.25 3.75 {}
L 3 2731.25 3.75 2735 1.25 {}
L 3 2735 1.25 2737.5 -2.5 {}
L 3 2720 -35 2728.75 -35 {}
L 3 2728.75 -35 2731.25 -33.75 {}
L 3 2731.25 -33.75 2735 -31.25 {}
L 3 2735 -31.25 2737.5 -27.5 {}
L 3 2697.5 -33.75 2700 -30 {}
L 3 2695 -35 2697.5 -33.75 {}
L 3 2680 -30 2682.5 -33.75 {}
L 3 2682.5 -33.75 2685 -35 {}
L 3 2680 0 2682.5 3.75 {}
L 3 2682.5 3.75 2685 5 {}
L 3 2697.5 3.75 2700 0 {}
L 3 2695 5 2697.5 3.75 {}
L 3 2657.5 -33.75 2660 -30 {}
L 3 2655 -35 2657.5 -33.75 {}
L 3 2657.5 3.75 2660 0 {}
L 3 2655 5 2657.5 3.75 {}
L 3 2653.75 -15 2656.25 -13.75 {}
L 3 2653.75 -15 2656.25 -16.25 {}
L 3 2660 -7.5 2660 0 {}
L 3 2658.75 -11.25 2660 -7.5 {}
L 3 2656.25 -13.75 2658.75 -11.25 {}
L 3 2660 -30 2660 -22.5 {}
L 3 2658.75 -18.75 2660 -22.5 {}
L 3 2656.25 -16.25 2658.75 -18.75 {}
L 3 2280 -30 2280 -20 {}
L 3 2300 -30 2300 -7.5 {}
L 3 2286.25 -15 2293.75 -15 {}
L 3 2296.25 0 2300 -7.5 {}
L 3 2283.75 5 2290 3.75 {}
L 3 2290 3.75 2296.25 0 {}
L 3 2280 -20 2281.25 -17.5 {}
L 3 2281.25 -17.5 2286.25 -15 {}
L 3 2298.75 -17.5 2300 -20 {}
L 3 2293.75 -15 2298.75 -17.5 {}
L 3 2282.5 5 2283.75 5 {}
L 3 2280 -30 2281.25 -32.5 {}
L 3 2281.25 -32.5 2286.25 -35 {}
L 3 2298.75 -32.5 2300 -30 {}
L 3 2293.75 -35 2298.75 -32.5 {}
L 3 2286.25 -35 2293.75 -35 {}
L 3 4700 -20 4700 5 {}
L 3 4685 5 4695 5 {}
L 3 4680 -20 4680 0 {}
L 3 4697.5 3.75 4700 0 {}
L 3 4695 5 4697.5 3.75 {}
L 3 4680 0 4682.5 3.75 {}
L 3 4682.5 3.75 4685 5 {}
L 3 4126.25 -20 4133.75 -20 {}
L 3 4126.25 5 4133.75 5 {}
L 3 4138.75 -17.5 4140 -15 {}
L 3 4133.75 -20 4138.75 -17.5 {}
L 3 4126.25 -20 4133.75 -20 {}
L 3 4121.25 -17.5 4126.25 -20 {}
L 3 4120 -15 4121.25 -17.5 {}
L 3 4120 0 4121.25 2.5 {}
L 3 4121.25 2.5 4126.25 5 {}
L 3 4133.75 5 4138.75 2.5 {}
L 3 4138.75 2.5 4140 0 {}
L 3 4120 -15 4120 0 {}
